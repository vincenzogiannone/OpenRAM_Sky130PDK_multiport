* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/vincenzogiannone/Desktop/work_OpenRAM_multiport/technology/sky130A/models/tt.sp"
.include "sram_0rw2r1w_32_128_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_0rw2r1w_32_128_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a_0 a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 CSB WEB clk dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 vdd gnd sram_0rw2r1w_32_128_sky130A

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD10 dout1_0  0 27.56f
CD11 dout1_1  0 27.56f
CD12 dout1_2  0 27.56f
CD13 dout1_3  0 27.56f
CD14 dout1_4  0 27.56f
CD15 dout1_5  0 27.56f
CD16 dout1_6  0 27.56f
CD17 dout1_7  0 27.56f
CD18 dout1_8  0 27.56f
CD19 dout1_9  0 27.56f
CD110 dout1_10  0 27.56f
CD111 dout1_11  0 27.56f
CD112 dout1_12  0 27.56f
CD113 dout1_13  0 27.56f
CD114 dout1_14  0 27.56f
CD115 dout1_15  0 27.56f
CD116 dout1_16  0 27.56f
CD117 dout1_17  0 27.56f
CD118 dout1_18  0 27.56f
CD119 dout1_19  0 27.56f
CD120 dout1_20  0 27.56f
CD121 dout1_21  0 27.56f
CD122 dout1_22  0 27.56f
CD123 dout1_23  0 27.56f
CD124 dout1_24  0 27.56f
CD125 dout1_25  0 27.56f
CD126 dout1_26  0 27.56f
CD127 dout1_27  0 27.56f
CD128 dout1_28  0 27.56f
CD129 dout1_29  0 27.56f
CD130 dout1_30  0 27.56f
CD131 dout1_31  0 27.56f

* Important signals for debug
* rbl0:	['read_bl_0']
* rbl1:	['read_bl_1']
* wbl0:	write_bl_0
* q:	xsram_0rw2r1w_32_128_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xsram_0rw2r1w_32_128_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 00000010110100000011011000011101  to  address 000000001 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 11001110110000101000111000101010  to  address 001111110 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 00011000110001100001010110110010  to  address 001111101 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 00000010110100000011011000011101 from address 000000001 (from port 1) during cycle 4 (80ns - 100ns)
*	Reading 00011000110001100001010110110010 from address 001111101 (from port 2) during cycle 4 (80ns - 100ns)
*	Writing 01111001001110000110111101101001  to  address 000000001 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 00011000110001100001010110110010 from address 001111101 (from port 1) during cycle 5 (100ns - 120ns)
*	Writing 00011011101011001100000010110000  to  address 001111101 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 1) during cycle 6 (120ns - 140ns)
*	Reading 01111001001110000110111101101001 from address 000000001 (from port 2) during cycle 6 (120ns - 140ns)
*	Writing 11011100011001111011100100101110  to  address 001111101 (from port 0) during cycle 7 (140ns - 160ns)
*	Reading 01111001001110000110111101101001 from address 000000001 (from port 2) during cycle 7 (140ns - 160ns)
*	Writing 01001000000001111000000110101101  to  address 000000000 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 11011100011001111011100100101110 from address 001111101 (from port 1) during cycle 8 (160ns - 180ns)
*	Writing 10111110000001100010011011101110  to  address 000000000 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 01111001001110000110111101101001 from address 000000001 (from port 1) during cycle 9 (180ns - 200ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 2) during cycle 9 (180ns - 200ns)
*	Writing 00011100101000100011100100100101  to  address 001111101 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 1) during cycle 10 (200ns - 220ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 2) during cycle 10 (200ns - 220ns)
*	Writing 10010100101110000101000011101001  to  address 000000000 (from port 0) during cycle 11 (220ns - 240ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 1) during cycle 11 (220ns - 240ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 2) during cycle 11 (220ns - 240ns)
*	Writing 00111011011010001010010101110011  to  address 000000001 (from port 0) during cycle 12 (240ns - 260ns)
*	Reading 00011100101000100011100100100101 from address 001111101 (from port 1) during cycle 12 (240ns - 260ns)
*	Reading 10010100101110000101000011101001 from address 000000000 (from port 2) during cycle 12 (240ns - 260ns)
*	Writing 10101110110011001111111101100100  to  address 001111101 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 00101111110101101100010011101000  to  address 000000001 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 10101110110011001111111101100100 from address 001111101 (from port 1) during cycle 14 (280ns - 300ns)
*	Reading 10101110110011001111111101100100 from address 001111101 (from port 2) during cycle 14 (280ns - 300ns)
*	Writing 00111000001101101010000011101011  to  address 000000000 (from port 0) during cycle 15 (300ns - 320ns)
*	Reading 11001110110000101000111000101010 from address 001111110 (from port 2) during cycle 15 (300ns - 320ns)
*	Writing 10011001100101011100000000111101  to  address 001111110 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 00111000001101101010000011101011 from address 000000000 (from port 1) during cycle 16 (320ns - 340ns)
*	Writing 11001101010000000110000010011111  to  address 001111110 (from port 0) during cycle 17 (340ns - 360ns)
*	Reading 00101111110101101100010011101000 from address 000000001 (from port 1) during cycle 17 (340ns - 360ns)
*	Reading 00111000001101101010000011101011 from address 000000000 (from port 2) during cycle 17 (340ns - 360ns)
*	Writing 11011100000000010001000101000010  to  address 001111101 (from port 0) during cycle 18 (360ns - 380ns)
*	Reading 00101111110101101100010011101000 from address 000000001 (from port 1) during cycle 18 (360ns - 380ns)
*	Reading 00111000001101101010000011101011 from address 000000000 (from port 2) during cycle 18 (360ns - 380ns)
*	Writing 00101100010110101110011100001110  to  address 001111101 (from port 0) during cycle 19 (380ns - 400ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 1) during cycle 19 (380ns - 400ns)
*	Writing 00000001011001001111011111010000  to  address 000000000 (from port 0) during cycle 20 (400ns - 420ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 2) during cycle 20 (400ns - 420ns)
*	Writing 00111011001100101101000101100011  to  address 000000001 (from port 0) during cycle 21 (420ns - 440ns)
*	Reading 00000001011001001111011111010000 from address 000000000 (from port 1) during cycle 21 (420ns - 440ns)
*	Reading 00000001011001001111011111010000 from address 000000000 (from port 2) during cycle 21 (420ns - 440ns)
*	Writing 11001010011111001100001000111110  to  address 000000001 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 00101100010110101110011100001110 from address 001111101 (from port 2) during cycle 22 (440ns - 460ns)
*	Writing 10111000101001001110110001110100  to  address 000000001 (from port 0) during cycle 23 (460ns - 480ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 2) during cycle 23 (460ns - 480ns)
*	Writing 00110010010010111110101101011101  to  address 001111101 (from port 0) during cycle 24 (480ns - 500ns)
*	Reading 10111000101001001110110001110100 from address 000000001 (from port 2) during cycle 24 (480ns - 500ns)
*	Writing 10110101010100010011010011010001  to  address 000000000 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 1) during cycle 25 (500ns - 520ns)
*	Writing 10000111001110100010001111011111  to  address 000000001 (from port 0) during cycle 26 (520ns - 540ns)
*	Writing 10010101111101100001010011101000  to  address 000000000 (from port 0) during cycle 27 (540ns - 560ns)
*	Reading 00110010010010111110101101011101 from address 001111101 (from port 2) during cycle 27 (540ns - 560ns)
*	Writing 11110101101110101111100011100010  to  address 001111101 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 10010101111101100001010011101000 from address 000000000 (from port 2) during cycle 28 (560ns - 580ns)
*	Writing 10000100000000010110110011100110  to  address 000000000 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 2) during cycle 29 (580ns - 600ns)
*	Writing 00000000100010101111111100111010  to  address 000000001 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 10000100000000010110110011100110 from address 000000000 (from port 1) during cycle 30 (600ns - 620ns)
*	Writing 10000100011010111111101111001111  to  address 000000001 (from port 0) during cycle 31 (620ns - 640ns)
*	Reading 11001101010000000110000010011111 from address 001111110 (from port 2) during cycle 31 (620ns - 640ns)
*	Writing 00000011111111011110101001100000  to  address 000000000 (from port 0) during cycle 32 (640ns - 660ns)
*	Writing 01101000101001010111010011000010  to  address 000000001 (from port 0) during cycle 33 (660ns - 680ns)
*	Writing 10100001101110000000110011001010  to  address 001111110 (from port 0) during cycle 34 (680ns - 700ns)
*	Reading 00000011111111011110101001100000 from address 000000000 (from port 1) during cycle 34 (680ns - 700ns)
*	Reading 00000011111111011110101001100000 from address 000000000 (from port 2) during cycle 34 (680ns - 700ns)
*	Writing 10001011011110111011010111101000  to  address 000000000 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 01101000101001010111010011000010 from address 000000001 (from port 1) during cycle 35 (700ns - 720ns)
*	Reading 11110101101110101111100011100010 from address 001111101 (from port 2) during cycle 35 (700ns - 720ns)
*	Writing 00010000110110010100110110100101  to  address 000000000 (from port 0) during cycle 36 (720ns - 740ns)
*	Reading 11110101101110101111100011100010 from address 001111101 (from port 1) during cycle 36 (720ns - 740ns)
*	Reading 10100001101110000000110011001010 from address 001111110 (from port 2) during cycle 36 (720ns - 740ns)
*	Writing 00011011000001001100100101110110  to  address 001111101 (from port 0) during cycle 37 (740ns - 760ns)
*	Reading 01101000101001010111010011000010 from address 000000001 (from port 1) during cycle 37 (740ns - 760ns)
*	Reading 01101000101001010111010011000010 from address 000000001 (from port 2) during cycle 37 (740ns - 760ns)
*	Writing 01101011111110000011010111001011  to  address 000000001 (from port 0) during cycle 38 (760ns - 780ns)
*	Reading 00010000110110010100110110100101 from address 000000000 (from port 1) during cycle 38 (760ns - 780ns)
*	Reading 00010000110110010100110110100101 from address 000000000 (from port 2) during cycle 38 (760ns - 780ns)
*	Writing 10100001001000110101000000010110  to  address 001111101 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 00010000110110010100110110100101 from address 000000000 (from port 1) during cycle 39 (780ns - 800ns)
*	Writing 00001110011011101010100000100000  to  address 000000000 (from port 0) during cycle 40 (800ns - 820ns)
*	Reading 10100001101110000000110011001010 from address 001111110 (from port 2) during cycle 40 (800ns - 820ns)
*	Writing 11011000010001100110101100001110  to  address 001111110 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 00001110011011101010100000100000 from address 000000000 (from port 1) during cycle 41 (820ns - 840ns)
*	Reading 10100001001000110101000000010110 from address 001111101 (from port 2) during cycle 41 (820ns - 840ns)
*	Writing 10111100101001011001010110111010  to  address 001111101 (from port 0) during cycle 42 (840ns - 860ns)
*	Reading 11011000010001100110101100001110 from address 001111110 (from port 1) during cycle 42 (840ns - 860ns)
*	Writing 10001011001110001111101100100011  to  address 001111101 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 01101011111110000011010111001011 from address 000000001 (from port 1) during cycle 43 (860ns - 880ns)
*	Reading 00001110011011101010100000100000 from address 000000000 (from port 2) during cycle 43 (860ns - 880ns)
*	Writing 01000000101100000110001110101100  to  address 001111101 (from port 0) during cycle 44 (880ns - 900ns)
*	Reading 01101011111110000011010111001011 from address 000000001 (from port 1) during cycle 44 (880ns - 900ns)
*	Writing 01101110011011110110011010010100  to  address 000000000 (from port 0) during cycle 45 (900ns - 920ns)
*	Reading 11011000010001100110101100001110 from address 001111110 (from port 1) during cycle 45 (900ns - 920ns)
*	Reading 01101011111110000011010111001011 from address 000000001 (from port 2) during cycle 45 (900ns - 920ns)
*	Writing 11001100001111001110100101000100  to  address 000000000 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 11011000010001100110101100001110 from address 001111110 (from port 2) during cycle 46 (920ns - 940ns)
*	Writing 00001110101101101011111001010010  to  address 001111101 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 01101011111110000011010111001011 from address 000000001 (from port 1) during cycle 47 (940ns - 960ns)
*	Reading 11001100001111001110100101000100 from address 000000000 (from port 2) during cycle 47 (940ns - 960ns)
*	Writing 00101010100101011101001010000111  to  address 001111110 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 00001110101101101011111001010010 from address 001111101 (from port 1) during cycle 48 (960ns - 980ns)
*	Writing 11011111001000111110101001101010  to  address 000000001 (from port 0) during cycle 49 (980ns - 1000ns)
*	Reading 00101010100101011101001010000111 from address 001111110 (from port 1) during cycle 49 (980ns - 1000ns)
*	Writing 11001110000000000100100101011001  to  address 001111101 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 11011111001000111110101001101010 from address 000000001 (from port 1) during cycle 50 (1000ns - 1020ns)
*	Writing 00011110111100000001110010010110  to  address 001111101 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 00101010100101011101001010000111 from address 001111110 (from port 1) during cycle 51 (1020ns - 1040ns)
*	Writing 01001111001010010001101000000000  to  address 001111110 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 11001100001111001110100101000100 from address 000000000 (from port 1) during cycle 52 (1040ns - 1060ns)
*	Reading 11001100001111001110100101000100 from address 000000000 (from port 2) during cycle 52 (1040ns - 1060ns)
*	Writing 01001011100010011011010101010110  to  address 000000000 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Writing 10100100111110011001110110101100  to  address 000000001 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 01001111001010010001101000000000 from address 001111110 (from port 1) during cycle 54 (1080ns - 1100ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 2) during cycle 54 (1080ns - 1100ns)
*	Writing 11011001000000110000011100110001  to  address 001111110 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Reading 00011110111100000001110010010110 from address 001111101 (from port 1) during cycle 55 (1100ns - 1120ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 2) during cycle 55 (1100ns - 1120ns)
*	Writing 00111011001110001111011001110101  to  address 001111110 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 1) during cycle 56 (1120ns - 1140ns)
*	Reading 00011110111100000001110010010110 from address 001111101 (from port 2) during cycle 56 (1120ns - 1140ns)
*	Writing 00111000000010101111001000101111  to  address 001111110 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Reading 10100100111110011001110110101100 from address 000000001 (from port 1) during cycle 57 (1140ns - 1160ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 2) during cycle 57 (1140ns - 1160ns)
*	Writing 10010101101111001111111011100100  to  address 001111101 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Reading 00111000000010101111001000101111 from address 001111110 (from port 1) during cycle 58 (1160ns - 1180ns)
*	Reading 10100100111110011001110110101100 from address 000000001 (from port 2) during cycle 58 (1160ns - 1180ns)
*	Writing 00111010101000011111111010100000  to  address 001111101 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 1) during cycle 59 (1180ns - 1200ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 2) during cycle 59 (1180ns - 1200ns)
*	Writing 00111011101001110110101111001101  to  address 000000001 (from port 0) during cycle 60 (1200ns - 1220ns)
*	Reading 01001011100010011011010101010110 from address 000000000 (from port 2) during cycle 60 (1200ns - 1220ns)
*	Writing 10011101101011110010011100011110  to  address 000000001 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Reading 00111010101000011111111010100000 from address 001111101 (from port 1) during cycle 61 (1220ns - 1240ns)
*	Writing 11010110000101101001000100100111  to  address 000000000 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 00111000000010101111001000101111 from address 001111110 (from port 1) during cycle 62 (1240ns - 1260ns)
*	Reading 00111010101000011111111010100000 from address 001111101 (from port 2) during cycle 62 (1240ns - 1260ns)
*	Writing 11001111000000001010101111011101  to  address 001111101 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 10011101101011110010011100011110 from address 000000001 (from port 1) during cycle 63 (1260ns - 1280ns)
*	Writing 11001100111111010010011000111111  to  address 001111110 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 11010110000101101001000100100111 from address 000000000 (from port 1) during cycle 64 (1280ns - 1300ns)
*	Reading 11001111000000001010101111011101 from address 001111101 (from port 2) during cycle 64 (1280ns - 1300ns)
*	Writing 01011001110110100110100100101001  to  address 000000001 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 11001111000000001010101111011101 from address 001111101 (from port 1) during cycle 65 (1300ns - 1320ns)
*	Reading 11010110000101101001000100100111 from address 000000000 (from port 2) during cycle 65 (1300ns - 1320ns)
*	Writing 01001000110100111100111010001011  to  address 000000001 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 11010110000101101001000100100111 from address 000000000 (from port 1) during cycle 66 (1320ns - 1340ns)
*	Reading 11001111000000001010101111011101 from address 001111101 (from port 2) during cycle 66 (1320ns - 1340ns)
*	Writing 10111100100110001100110100001001  to  address 000000000 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Reading 11001100111111010010011000111111 from address 001111110 (from port 2) during cycle 67 (1340ns - 1360ns)
*	Writing 10010001010010011001111100011000  to  address 001111110 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 01001000110100111100111010001011 from address 000000001 (from port 1) during cycle 68 (1360ns - 1380ns)
*	Writing 11110100110010101011011010001011  to  address 001111110 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Reading 01001000110100111100111010001011 from address 000000001 (from port 1) during cycle 69 (1380ns - 1400ns)
*	Reading 10111100100110001100110100001001 from address 000000000 (from port 2) during cycle 69 (1380ns - 1400ns)
*	Writing 00000011100111011010000101011000  to  address 001111110 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Reading 01001000110100111100111010001011 from address 000000001 (from port 2) during cycle 70 (1400ns - 1420ns)
*	Writing 01011110000101000001100011110101  to  address 000000001 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 11001111000000001010101111011101 from address 001111101 (from port 1) during cycle 71 (1420ns - 1440ns)
*	Reading 10111100100110001100110100001001 from address 000000000 (from port 2) during cycle 71 (1420ns - 1440ns)
*	Writing 11101110101111001011010010101110  to  address 001111110 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 11001111000000001010101111011101 from address 001111101 (from port 1) during cycle 72 (1440ns - 1460ns)
*	Writing 10101001100111011011011111001011  to  address 001111110 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Reading 01011110000101000001100011110101 from address 000000001 (from port 1) during cycle 73 (1460ns - 1480ns)
*	Reading 01011110000101000001100011110101 from address 000000001 (from port 2) during cycle 73 (1460ns - 1480ns)
*	Writing 01110110101110010101000100111000  to  address 001111101 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Reading 10111100100110001100110100001001 from address 000000000 (from port 1) during cycle 74 (1480ns - 1500ns)
*	Reading 01011110000101000001100011110101 from address 000000001 (from port 2) during cycle 74 (1480ns - 1500ns)
*	Writing 01010101111011000001100011101011  to  address 000000000 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 01110110101110010101000100111000 from address 001111101 (from port 1) during cycle 75 (1500ns - 1520ns)
*	Reading 01110110101110010101000100111000 from address 001111101 (from port 2) during cycle 75 (1500ns - 1520ns)
*	Writing 10000011111110101011100001111011  to  address 001111101 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Reading 01010101111011000001100011101011 from address 000000000 (from port 2) during cycle 76 (1520ns - 1540ns)
*	Writing 00000011011111101001000001100000  to  address 000000000 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Reading 10000011111110101011100001111011 from address 001111101 (from port 1) during cycle 77 (1540ns - 1560ns)
*	Reading 10000011111110101011100001111011 from address 001111101 (from port 2) during cycle 77 (1540ns - 1560ns)
*	Writing 00101010010001000010010001010001  to  address 000000001 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Writing 10110101000001110000010111000010  to  address 001111101 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Writing 11000011101100001101010110100101  to  address 000000000 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Reading 00101010010001000010010001010001 from address 000000001 (from port 1) during cycle 80 (1600ns - 1620ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 2) during cycle 80 (1600ns - 1620ns)
*	Writing 00110000001100010000110110000111  to  address 001111101 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 1) during cycle 81 (1620ns - 1640ns)
*	Reading 00101010010001000010010001010001 from address 000000001 (from port 2) during cycle 81 (1620ns - 1640ns)
*	Writing 11100010001100110111101001010010  to  address 000000001 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 1) during cycle 82 (1640ns - 1660ns)
*	Reading 00110000001100010000110110000111 from address 001111101 (from port 2) during cycle 82 (1640ns - 1660ns)
*	Writing 11111010000100101000011011011000  to  address 000000001 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Writing 11101000100011111000001110000111  to  address 000000001 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Reading 11000011101100001101010110100101 from address 000000000 (from port 1) during cycle 84 (1680ns - 1700ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 2) during cycle 84 (1680ns - 1700ns)
*	Writing 00101011000111111100101010111101  to  address 000000000 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Reading 11101000100011111000001110000111 from address 000000001 (from port 1) during cycle 85 (1700ns - 1720ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 2) during cycle 85 (1700ns - 1720ns)
*	Writing 10000101111110000001010001010111  to  address 000000001 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Reading 00101011000111111100101010111101 from address 000000000 (from port 1) during cycle 86 (1720ns - 1740ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 2) during cycle 86 (1720ns - 1740ns)
*	Writing 10100010101011001111001110001010  to  address 000000001 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Reading 10101001100111011011011111001011 from address 001111110 (from port 1) during cycle 87 (1740ns - 1760ns)
*	Reading 00110000001100010000110110000111 from address 001111101 (from port 2) during cycle 87 (1740ns - 1760ns)
*	Writing 00011011101001110000000010111010  to  address 000000000 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 10100010101011001111001110001010 from address 000000001 (from port 2) during cycle 88 (1760ns - 1780ns)
*	Writing 10000100001111110000010001110110  to  address 001111110 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Reading 00110000001100010000110110000111 from address 001111101 (from port 1) during cycle 89 (1780ns - 1800ns)
*	Reading 00110000001100010000110110000111 from address 001111101 (from port 2) during cycle 89 (1780ns - 1800ns)
*	Writing 10111110010011001110000010001000  to  address 000000000 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Reading 10100010101011001111001110001010 from address 000000001 (from port 1) during cycle 90 (1800ns - 1820ns)
*	Reading 00110000001100010000110110000111 from address 001111101 (from port 2) during cycle 90 (1800ns - 1820ns)
*	Writing 11100100101100000010110010100000  to  address 001111101 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 10111110010011001110000010001000 from address 000000000 (from port 1) during cycle 91 (1820ns - 1840ns)
*	Reading 10000100001111110000010001110110 from address 001111110 (from port 2) during cycle 91 (1820ns - 1840ns)
*	Writing 10010011110000001010011101111111  to  address 000000001 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 10000100001111110000010001110110 from address 001111110 (from port 1) during cycle 92 (1840ns - 1860ns)
*	Reading 10000100001111110000010001110110 from address 001111110 (from port 2) during cycle 92 (1840ns - 1860ns)
*	Writing 01100101101010111011110000101010  to  address 000000000 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Reading 11100100101100000010110010100000 from address 001111101 (from port 1) during cycle 93 (1860ns - 1880ns)
*	Reading 10010011110000001010011101111111 from address 000000001 (from port 2) during cycle 93 (1860ns - 1880ns)
*	Writing 00000101001010010110111001110101  to  address 000000000 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Reading 11100100101100000010110010100000 from address 001111101 (from port 1) during cycle 94 (1880ns - 1900ns)
*	Reading 10000100001111110000010001110110 from address 001111110 (from port 2) during cycle 94 (1880ns - 1900ns)
*	Writing 10110000100001111111001111101111  to  address 001111110 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 11100100101100000010110010100000 from address 001111101 (from port 1) during cycle 95 (1900ns - 1920ns)
*	Reading 11100100101100000010110010100000 from address 001111101 (from port 2) during cycle 95 (1900ns - 1920ns)
*	Writing 10001011000101100000101011111001  to  address 001111101 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 10110000100001111111001111101111 from address 001111110 (from port 1) during cycle 96 (1920ns - 1940ns)
*	Reading 10010011110000001010011101111111 from address 000000001 (from port 2) during cycle 96 (1920ns - 1940ns)
*	Writing 11011000101111001000010111000100  to  address 000000000 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Reading 10110000100001111111001111101111 from address 001111110 (from port 1) during cycle 97 (1940ns - 1960ns)
*	Reading 10010011110000001010011101111111 from address 000000001 (from port 2) during cycle 97 (1940ns - 1960ns)
*	Writing 11010111001111100010101011000110  to  address 001111110 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 10001011000101100000101011111001 from address 001111101 (from port 1) during cycle 98 (1960ns - 1980ns)
*	Writing 10111101100101000100101100110000  to  address 000000001 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 11011000101111001000010111000100 from address 000000000 (from port 1) during cycle 99 (1980ns - 2000ns)
*	Reading 10001011000101100000101011111001 from address 001111101 (from port 2) during cycle 99 (1980ns - 2000ns)
*	Writing 00110111010000110001011110111001  to  address 001111110 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Reading 10111101100101000100101100110000 from address 000000001 (from port 1) during cycle 100 (2000ns - 2020ns)
*	Reading 11011000101111001000010111000100 from address 000000000 (from port 2) during cycle 100 (2000ns - 2020ns)
*	Writing 11000110100101001011101000100010  to  address 000000001 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Reading 10001011000101100000101011111001 from address 001111101 (from port 1) during cycle 101 (2020ns - 2040ns)
*	Reading 10001011000101100000101011111001 from address 001111101 (from port 2) during cycle 101 (2020ns - 2040ns)
*	Writing 10010100111100010100010101101110  to  address 001111110 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Reading 11000110100101001011101000100010 from address 000000001 (from port 1) during cycle 102 (2040ns - 2060ns)
*	Reading 11000110100101001011101000100010 from address 000000001 (from port 2) during cycle 102 (2040ns - 2060ns)
*	Writing 00100011011011001110011101110001  to  address 000000001 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 10001011000101100000101011111001 from address 001111101 (from port 1) during cycle 103 (2060ns - 2080ns)
*	Reading 10010100111100010100010101101110 from address 001111110 (from port 2) during cycle 103 (2060ns - 2080ns)
*	Writing 01000111100100011011110011110001  to  address 001111110 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 1) during cycle 104 (2080ns - 2100ns)
*	Writing 00101011001110000100010010010101  to  address 001111110 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 1) during cycle 105 (2100ns - 2120ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 2) during cycle 105 (2100ns - 2120ns)
*	Writing 11111011111111010001001111101011  to  address 001111101 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Reading 00101011001110000100010010010101 from address 001111110 (from port 1) during cycle 106 (2120ns - 2140ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 2) during cycle 106 (2120ns - 2140ns)
*	Writing 11011011101011100101001001100010  to  address 000000000 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 00101011001110000100010010010101 from address 001111110 (from port 1) during cycle 107 (2140ns - 2160ns)
*	Reading 00101011001110000100010010010101 from address 001111110 (from port 2) during cycle 107 (2140ns - 2160ns)
*	Writing 01100010101001011000110010011010  to  address 000000000 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 1) during cycle 108 (2160ns - 2180ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 2) during cycle 108 (2160ns - 2180ns)
*	Writing 10110100011111111111011011110011  to  address 001111101 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Reading 01100010101001011000110010011010 from address 000000000 (from port 2) during cycle 109 (2180ns - 2200ns)
*	Writing 10001100111111100101111001100000  to  address 001111110 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 10110100011111111111011011110011 from address 001111101 (from port 1) during cycle 110 (2200ns - 2220ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 2) during cycle 110 (2200ns - 2220ns)
*	Writing 11110101100100011111011111100001  to  address 000000000 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 2) during cycle 111 (2220ns - 2240ns)
*	Writing 01010100111100110111111100010001  to  address 001111110 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 10110100011111111111011011110011 from address 001111101 (from port 2) during cycle 112 (2240ns - 2260ns)
*	Writing 11111101111001000011100011011101  to  address 001111110 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Reading 00100011011011001110011101110001 from address 000000001 (from port 1) during cycle 113 (2260ns - 2280ns)
*	Reading 10110100011111111111011011110011 from address 001111101 (from port 2) during cycle 113 (2260ns - 2280ns)
*	Writing 01010011111100111011001011011101  to  address 001111101 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 11110101100100011111011111100001 from address 000000000 (from port 1) during cycle 114 (2280ns - 2300ns)
*	Reading 11110101100100011111011111100001 from address 000000000 (from port 2) during cycle 114 (2280ns - 2300ns)
*	Writing 11001011010101100000100110111110  to  address 000000000 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 01010011111100111011001011011101 from address 001111101 (from port 2) during cycle 115 (2300ns - 2320ns)
*	Writing 01111011001111110111111100010110  to  address 000000001 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 11001011010101100000100110111110 from address 000000000 (from port 1) during cycle 116 (2320ns - 2340ns)
*	Reading 11111101111001000011100011011101 from address 001111110 (from port 2) during cycle 116 (2320ns - 2340ns)
*	Writing 11111111000111010010111001110011  to  address 001111110 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 01111011001111110111111100010110 from address 000000001 (from port 1) during cycle 117 (2340ns - 2360ns)
*	Reading 01111011001111110111111100010110 from address 000000001 (from port 2) during cycle 117 (2340ns - 2360ns)
*	Writing 11011001110100100100010100110011  to  address 001111101 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 11111111000111010010111001110011 from address 001111110 (from port 1) during cycle 118 (2360ns - 2380ns)
*	Reading 11001011010101100000100110111110 from address 000000000 (from port 2) during cycle 118 (2360ns - 2380ns)
*	Writing 00001001001111110111010101101101  to  address 001111101 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 01111011001111110111111100010110 from address 000000001 (from port 1) during cycle 119 (2380ns - 2400ns)
*	Reading 01111011001111110111111100010110 from address 000000001 (from port 2) during cycle 119 (2380ns - 2400ns)
*	Writing 10100110100100110101000001001000  to  address 001111101 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Reading 11001011010101100000100110111110 from address 000000000 (from port 1) during cycle 120 (2400ns - 2420ns)
*	Writing 11010010010101001000100000011111  to  address 001111101 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Writing 01001000110110010100101110110100  to  address 000000001 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 11001011010101100000100110111110 from address 000000000 (from port 1) during cycle 122 (2440ns - 2460ns)
*	Reading 11001011010101100000100110111110 from address 000000000 (from port 2) during cycle 122 (2440ns - 2460ns)
*	Writing 11011011010111100100101000110001  to  address 000000000 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 11010010010101001000100000011111 from address 001111101 (from port 1) during cycle 123 (2460ns - 2480ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 2) during cycle 123 (2460ns - 2480ns)
*	Writing 01110100101010000000000100010001  to  address 000000000 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Reading 11111111000111010010111001110011 from address 001111110 (from port 1) during cycle 124 (2480ns - 2500ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 2) during cycle 124 (2480ns - 2500ns)
*	Writing 01010110100010111010111101000011  to  address 000000000 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 1) during cycle 125 (2500ns - 2520ns)
*	Reading 11010010010101001000100000011111 from address 001111101 (from port 2) during cycle 125 (2500ns - 2520ns)
*	Writing 10011111111011111000100011011000  to  address 001111110 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 11010010010101001000100000011111 from address 001111101 (from port 1) during cycle 126 (2520ns - 2540ns)
*	Reading 11010010010101001000100000011111 from address 001111101 (from port 2) during cycle 126 (2520ns - 2540ns)
*	Writing 01111011000101000011101100000000  to  address 001111110 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 2) during cycle 127 (2540ns - 2560ns)
*	Writing 00011001001000100101100011011110  to  address 001111110 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Writing 10111011000010000010011000001000  to  address 000000000 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 1) during cycle 129 (2580ns - 2600ns)
*	Reading 01001000110110010100101110110100 from address 000000001 (from port 2) during cycle 129 (2580ns - 2600ns)
*	Writing 00010111110110010011010000110101  to  address 001111101 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 10111011000010000010011000001000 from address 000000000 (from port 1) during cycle 130 (2600ns - 2620ns)
*	Reading 10111011000010000010011000001000 from address 000000000 (from port 2) during cycle 130 (2600ns - 2620ns)
*	Writing 01010100110100011000101110110010  to  address 000000001 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Reading 00011001001000100101100011011110 from address 001111110 (from port 1) during cycle 131 (2620ns - 2640ns)
*	Writing 11001001010000011111000100011110  to  address 000000001 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 1) during cycle 132 (2640ns - 2660ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 2) during cycle 132 (2640ns - 2660ns)
*	Writing 10110011110010011010011100011011  to  address 001111110 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Reading 11001001010000011111000100011110 from address 000000001 (from port 1) during cycle 133 (2660ns - 2680ns)
*	Writing 01010011111000001000001001101111  to  address 001111110 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 1) during cycle 134 (2680ns - 2700ns)
*	Reading 10111011000010000010011000001000 from address 000000000 (from port 2) during cycle 134 (2680ns - 2700ns)
*	Writing 10100010010010110111010000010010  to  address 000000001 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 2) during cycle 135 (2700ns - 2720ns)
*	Writing 11001110111111110110011000010110  to  address 000000000 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Reading 01010011111000001000001001101111 from address 001111110 (from port 1) during cycle 136 (2720ns - 2740ns)
*	Reading 10100010010010110111010000010010 from address 000000001 (from port 2) during cycle 136 (2720ns - 2740ns)
*	Writing 10101010011100001011110001100100  to  address 001111110 (from port 0) during cycle 137 (2740ns - 2760ns)
*	Reading 10100010010010110111010000010010 from address 000000001 (from port 1) during cycle 137 (2740ns - 2760ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 2) during cycle 137 (2740ns - 2760ns)
*	Writing 10010101011100101110101101010000  to  address 000000000 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Reading 10100010010010110111010000010010 from address 000000001 (from port 1) during cycle 138 (2760ns - 2780ns)
*	Reading 00010111110110010011010000110101 from address 001111101 (from port 2) during cycle 138 (2760ns - 2780ns)
*	Writing 01100001101011100101010001110001  to  address 001111101 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 1) during cycle 139 (2780ns - 2800ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 2) during cycle 139 (2780ns - 2800ns)
*	Writing 11100000011100101000011110110111  to  address 000000000 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Reading 01100001101011100101010001110001 from address 001111101 (from port 1) during cycle 140 (2800ns - 2820ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 2) during cycle 140 (2800ns - 2820ns)
*	Writing 00111111011001111111101101010010  to  address 001111101 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 141 (2820ns - 2840ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 141 (2820ns - 2840ns)
*	Writing 00000101100011100001111110011000  to  address 000000001 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 142 (2840ns - 2860ns)
*	Writing 11111011010100011011101011000111  to  address 000000001 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 143 (2860ns - 2880ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 2) during cycle 143 (2860ns - 2880ns)
*	Writing 11000011000100100000010100001000  to  address 000000001 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 1) during cycle 144 (2880ns - 2900ns)
*	Writing 01011100011110110100001001100011  to  address 001111101 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 1) during cycle 145 (2900ns - 2920ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 145 (2900ns - 2920ns)
*	Writing 10000001110011011000010110001010  to  address 001111101 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 146 (2920ns - 2940ns)
*	Reading 10101010011100001011110001100100 from address 001111110 (from port 2) during cycle 146 (2920ns - 2940ns)
*	Writing 10111110100010100010000111011010  to  address 001111110 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 10000001110011011000010110001010 from address 001111101 (from port 1) during cycle 147 (2940ns - 2960ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 147 (2940ns - 2960ns)
*	Writing 01000111010100101100100000000011  to  address 000000001 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 148 (2960ns - 2980ns)
*	Reading 10000001110011011000010110001010 from address 001111101 (from port 2) during cycle 148 (2960ns - 2980ns)
*	Writing 10111001111110010100001110111101  to  address 001111110 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 01000111010100101100100000000011 from address 000000001 (from port 1) during cycle 149 (2980ns - 3000ns)
*	Reading 01000111010100101100100000000011 from address 000000001 (from port 2) during cycle 149 (2980ns - 3000ns)
*	Writing 11101100100010110010001011010000  to  address 001111101 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 150 (3000ns - 3020ns)
*	Writing 01010001001010100011001110110001  to  address 001111101 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Reading 01000111010100101100100000000011 from address 000000001 (from port 1) during cycle 151 (3020ns - 3040ns)
*	Reading 10111001111110010100001110111101 from address 001111110 (from port 2) during cycle 151 (3020ns - 3040ns)
*	Writing 10101010111110101110111110000001  to  address 001111101 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 152 (3040ns - 3060ns)
*	Writing 11000010110010010100101001001010  to  address 001111101 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 1) during cycle 153 (3060ns - 3080ns)
*	Reading 10111001111110010100001110111101 from address 001111110 (from port 2) during cycle 153 (3060ns - 3080ns)
*	Writing 10011110111110001001110011101000  to  address 001111110 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 1) during cycle 154 (3080ns - 3100ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 2) during cycle 154 (3080ns - 3100ns)
*	Writing 01000101110000111010000101010110  to  address 000000001 (from port 0) during cycle 155 (3100ns - 3120ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 1) during cycle 155 (3100ns - 3120ns)
*	Reading 11100000011100101000011110110111 from address 000000000 (from port 2) during cycle 155 (3100ns - 3120ns)
*	Writing 01001001010000000110010011100100  to  address 000000001 (from port 0) during cycle 156 (3120ns - 3140ns)
*	Reading 10011110111110001001110011101000 from address 001111110 (from port 1) during cycle 156 (3120ns - 3140ns)
*	Writing 10110011010100100100010001001010  to  address 000000000 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 1) during cycle 157 (3140ns - 3160ns)
*	Writing 01111100111000001011100010101010  to  address 000000000 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 1) during cycle 158 (3160ns - 3180ns)
*	Reading 11000010110010010100101001001010 from address 001111101 (from port 2) during cycle 158 (3160ns - 3180ns)
*	Writing 00001100100111010010001001000010  to  address 000000001 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Reading 01111100111000001011100010101010 from address 000000000 (from port 1) during cycle 159 (3180ns - 3200ns)
*	Writing 01010100111100011011111011100011  to  address 000000000 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 10011110111110001001110011101000 from address 001111110 (from port 1) during cycle 160 (3200ns - 3220ns)
*	Reading 00001100100111010010001001000010 from address 000000001 (from port 2) during cycle 160 (3200ns - 3220ns)
*	Writing 11000111110100100111010110110111  to  address 001111110 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 01010100111100011011111011100011 from address 000000000 (from port 1) during cycle 161 (3220ns - 3240ns)
*	Writing 00000001101100010101000101100010  to  address 001111101 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Reading 01010100111100011011111011100011 from address 000000000 (from port 2) during cycle 162 (3240ns - 3260ns)
*	Writing 11000101000110011111000100010010  to  address 000000001 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Reading 00000001101100010101000101100010 from address 001111101 (from port 1) during cycle 163 (3260ns - 3280ns)
*	Reading 11000111110100100111010110110111 from address 001111110 (from port 2) during cycle 163 (3260ns - 3280ns)
*	Writing 00010110010110010011110001000001  to  address 000000000 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Reading 11000101000110011111000100010010 from address 000000001 (from port 1) during cycle 164 (3280ns - 3300ns)
*	Reading 11000101000110011111000100010010 from address 000000001 (from port 2) during cycle 164 (3280ns - 3300ns)
*	Writing 10100010100111111011000101001110  to  address 001111101 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Writing 00011111111111001101011100101110  to  address 001111110 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 11000101000110011111000100010010 from address 000000001 (from port 1) during cycle 166 (3320ns - 3340ns)
*	Reading 11000101000110011111000100010010 from address 000000001 (from port 2) during cycle 166 (3320ns - 3340ns)
*	Writing 01100001011110001010011110001010  to  address 001111101 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Reading 00010110010110010011110001000001 from address 000000000 (from port 1) during cycle 167 (3340ns - 3360ns)
*	Reading 00011111111111001101011100101110 from address 001111110 (from port 2) during cycle 167 (3340ns - 3360ns)
*	Writing 01101100101110100001101100000010  to  address 001111110 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 11000101000110011111000100010010 from address 000000001 (from port 2) during cycle 168 (3360ns - 3380ns)
*	Writing 01011010011010000000001011011111  to  address 000000000 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Reading 01101100101110100001101100000010 from address 001111110 (from port 2) during cycle 169 (3380ns - 3400ns)
*	Writing 01010011111010011000101001101111  to  address 000000001 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 1) during cycle 170 (3400ns - 3420ns)
*	Reading 01011010011010000000001011011111 from address 000000000 (from port 2) during cycle 170 (3400ns - 3420ns)
*	Writing 00010001011110101100011001011011  to  address 000000001 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Reading 01011010011010000000001011011111 from address 000000000 (from port 1) during cycle 171 (3420ns - 3440ns)
*	Reading 01011010011010000000001011011111 from address 000000000 (from port 2) during cycle 171 (3420ns - 3440ns)
*	Writing 00111010111110110001110110100110  to  address 000000001 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 01011010011010000000001011011111 from address 000000000 (from port 2) during cycle 172 (3440ns - 3460ns)
*	Writing 11111010111001010101100011100101  to  address 001111110 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 1) during cycle 173 (3460ns - 3480ns)
*	Reading 00111010111110110001110110100110 from address 000000001 (from port 2) during cycle 173 (3460ns - 3480ns)
*	Writing 11100100111111100001010110110100  to  address 000000000 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 11111010111001010101100011100101 from address 001111110 (from port 1) during cycle 174 (3480ns - 3500ns)
*	Reading 11111010111001010101100011100101 from address 001111110 (from port 2) during cycle 174 (3480ns - 3500ns)
*	Writing 10111111011010110001101111100010  to  address 000000000 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 00111010111110110001110110100110 from address 000000001 (from port 1) during cycle 175 (3500ns - 3520ns)
*	Reading 00111010111110110001110110100110 from address 000000001 (from port 2) during cycle 175 (3500ns - 3520ns)
*	Writing 10111010110001110100100010000010  to  address 001111110 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 2) during cycle 176 (3520ns - 3540ns)
*	Writing 01011110111110110110010101111010  to  address 000000000 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 00111010111110110001110110100110 from address 000000001 (from port 1) during cycle 177 (3540ns - 3560ns)
*	Reading 00111010111110110001110110100110 from address 000000001 (from port 2) during cycle 177 (3540ns - 3560ns)
*	Writing 11101100001100000000101001001010  to  address 000000001 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 01011110111110110110010101111010 from address 000000000 (from port 1) during cycle 178 (3560ns - 3580ns)
*	Writing 00001011111110110000101100001001  to  address 000000001 (from port 0) during cycle 179 (3580ns - 3600ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 1) during cycle 179 (3580ns - 3600ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 2) during cycle 179 (3580ns - 3600ns)
*	Writing 10011100100011000101100111110100  to  address 000000000 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Writing 11011010100101111000100011110011  to  address 000000001 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 1) during cycle 181 (3620ns - 3640ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 2) during cycle 181 (3620ns - 3640ns)
*	Writing 00111001011001010011001101000011  to  address 000000001 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 1) during cycle 182 (3640ns - 3660ns)
*	Reading 01100001011110001010011110001010 from address 001111101 (from port 2) during cycle 182 (3640ns - 3660ns)
*	Writing 00111001100100111111110100010011  to  address 001111101 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Reading 00111001011001010011001101000011 from address 000000001 (from port 1) during cycle 183 (3660ns - 3680ns)
*	Reading 00111001011001010011001101000011 from address 000000001 (from port 2) during cycle 183 (3660ns - 3680ns)
*	Writing 11011010000001100101111000101001  to  address 000000001 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 10011100100011000101100111110100 from address 000000000 (from port 1) during cycle 184 (3680ns - 3700ns)
*	Writing 01010111110100000111111110001101  to  address 000000001 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Reading 10011100100011000101100111110100 from address 000000000 (from port 1) during cycle 185 (3700ns - 3720ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 2) during cycle 185 (3700ns - 3720ns)
*	Writing 11110110001101010110110101110111  to  address 000000001 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 1) during cycle 186 (3720ns - 3740ns)
*	Reading 00111001100100111111110100010011 from address 001111101 (from port 2) during cycle 186 (3720ns - 3740ns)
*	Writing 10111101110011001011010101000110  to  address 000000000 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 1) during cycle 187 (3740ns - 3760ns)
*	Reading 00111001100100111111110100010011 from address 001111101 (from port 2) during cycle 187 (3740ns - 3760ns)
*	Writing 00011000111010001001100001110101  to  address 000000001 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Reading 00111001100100111111110100010011 from address 001111101 (from port 1) during cycle 188 (3760ns - 3780ns)
*	Writing 01101100000101110011110010110010  to  address 001111101 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 1) during cycle 189 (3780ns - 3800ns)
*	Reading 00011000111010001001100001110101 from address 000000001 (from port 2) during cycle 189 (3780ns - 3800ns)
*	Writing 00011000101101011001011101011110  to  address 000000000 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Reading 00011000111010001001100001110101 from address 000000001 (from port 1) during cycle 190 (3800ns - 3820ns)
*	Reading 01101100000101110011110010110010 from address 001111101 (from port 2) during cycle 190 (3800ns - 3820ns)
*	Writing 11000000111111011011000111101001  to  address 000000001 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 1) during cycle 191 (3820ns - 3840ns)
*	Reading 01101100000101110011110010110010 from address 001111101 (from port 2) during cycle 191 (3820ns - 3840ns)
*	Writing 10100100001100011100011001111110  to  address 000000001 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Reading 01101100000101110011110010110010 from address 001111101 (from port 1) during cycle 192 (3840ns - 3860ns)
*	Reading 10111010110001110100100010000010 from address 001111110 (from port 2) during cycle 192 (3840ns - 3860ns)
*	Writing 00100010100000011110010110111110  to  address 001111110 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Reading 01101100000101110011110010110010 from address 001111101 (from port 2) during cycle 193 (3860ns - 3880ns)
*	Writing 10000001110100011001101010000101  to  address 001111101 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 00100010100000011110010110111110 from address 001111110 (from port 1) during cycle 194 (3880ns - 3900ns)
*	Reading 10100100001100011100011001111110 from address 000000001 (from port 2) during cycle 194 (3880ns - 3900ns)
*	Writing 00101000110110010000010010001111  to  address 000000001 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Reading 10000001110100011001101010000101 from address 001111101 (from port 1) during cycle 195 (3900ns - 3920ns)
*	Reading 00100010100000011110010110111110 from address 001111110 (from port 2) during cycle 195 (3900ns - 3920ns)
*	Writing 01001011110010100100101011100000  to  address 001111101 (from port 0) during cycle 196 (3920ns - 3940ns)
*	Reading 00101000110110010000010010001111 from address 000000001 (from port 1) during cycle 196 (3920ns - 3940ns)
*	Reading 00101000110110010000010010001111 from address 000000001 (from port 2) during cycle 196 (3920ns - 3940ns)
*	Writing 11111111001111110110000110101010  to  address 000000001 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 00011000101101011001011101011110 from address 000000000 (from port 2) during cycle 197 (3940ns - 3960ns)
*	Writing 00110001101000010001000000110001  to  address 000000000 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 11111111001111110110000110101010 from address 000000001 (from port 1) during cycle 198 (3960ns - 3980ns)
*	Reading 01001011110010100100101011100000 from address 001111101 (from port 2) during cycle 198 (3960ns - 3980ns)
*	Writing 11100111001100010000001001001101  to  address 000000000 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Reading 11111111001111110110000110101010 from address 000000001 (from port 1) during cycle 199 (3980ns - 4000ns)
*	Reading 00100010100000011110010110111110 from address 001111110 (from port 2) during cycle 199 (3980ns - 4000ns)
*	Writing 10010101101110000100100100000111  to  address 000000000 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Reading 00100010100000011110010110111110 from address 001111110 (from port 1) during cycle 200 (4000ns - 4020ns)
*	Reading 11111111001111110110000110101010 from address 000000001 (from port 2) during cycle 200 (4000ns - 4020ns)
*	Writing 10111100000101001010011001100100  to  address 000000000 (from port 0) during cycle 201 (4020ns - 4040ns)
*	Reading 11111111001111110110000110101010 from address 000000001 (from port 1) during cycle 201 (4020ns - 4040ns)
*	Writing 11011110001101111111101010010101  to  address 001111110 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Reading 01001011110010100100101011100000 from address 001111101 (from port 1) during cycle 202 (4040ns - 4060ns)
*	Writing 00001111011100011101011011001100  to  address 000000000 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Reading 11111111001111110110000110101010 from address 000000001 (from port 1) during cycle 203 (4060ns - 4080ns)
*	Reading 11011110001101111111101010010101 from address 001111110 (from port 2) during cycle 203 (4060ns - 4080ns)
*	Writing 11011000011001000000000011110011  to  address 000000001 (from port 0) during cycle 204 (4080ns - 4100ns)
*	Reading 11011110001101111111101010010101 from address 001111110 (from port 1) during cycle 204 (4080ns - 4100ns)
*	Reading 11011110001101111111101010010101 from address 001111110 (from port 2) during cycle 204 (4080ns - 4100ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 0), (380, 0), (400, 0), (420, 1), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 0), (600, 0), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 0), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 0), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 1), (400, 0), (420, 1), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 0), (660, 1), (680, 1), (700, 0), (720, 0), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 1), (1300, 0), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 0), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 0), (380, 1), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 1), (540, 0), (560, 0), (580, 1), (600, 0), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 1), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 0), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 1), (2660, 0), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 0), (140, 1), (160, 1), (180, 1), (200, 0), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 0), (380, 1), (400, 0), (420, 0), (440, 1), (460, 0), (480, 1), (500, 0), (520, 1), (540, 1), (560, 0), (580, 0), (600, 1), (620, 1), (640, 0), (660, 0), (680, 1), (700, 1), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 0), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 0), (1700, 1), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 0), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 0), (2880, 1), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 0), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 0), (600, 1), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 1), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 0), (1060, 1), (1080, 0), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 1), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 1), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 1), (380, 0), (400, 1), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 0), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 1), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 0), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 1), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 1), (360, 0), (380, 0), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 0), (3120, 1), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 1), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 1), (180, 0), (200, 1), (220, 0), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 1), (500, 0), (520, 1), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 0), (2480, 1), (2500, 1), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 1), (3820, 1), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 1), (500, 0), (520, 1), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 0), (1360, 1), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 1), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 1), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 0), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 0), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 1), (3860, 0), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 1), (480, 0), (500, 1), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 1), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 1), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 1), (2860, 0), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 1), (3100, 0), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 1), (820, 1), (840, 0), (860, 1), (880, 0), (900, 0), (920, 1), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 0), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 1), (380, 0), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 1), (520, 0), (540, 1), (560, 1), (580, 0), (600, 1), (620, 1), (640, 0), (660, 1), (680, 0), (700, 1), (720, 0), (740, 0), (760, 1), (780, 1), (800, 0), (820, 0), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 1), (160, 0), (180, 1), (200, 1), (220, 0), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 0), (740, 0), (760, 1), (780, 0), (800, 1), (820, 1), (840, 0), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 0), (3820, 1), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 1), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 0), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 1), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 1), (720, 0), (740, 1), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 0), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 1), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 1), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 0), (2120, 1), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 0), (2440, 1), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 0), (420, 1), (440, 0), (460, 0), (480, 1), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 1), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 0), (900, 1), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 0), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 0), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 1), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 0), (420, 0), (440, 1), (460, 0), (480, 1), (500, 0), (520, 1), (540, 0), (560, 1), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 1), (720, 1), (740, 0), (760, 1), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 0), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 1), (400, 0), (420, 1), (440, 1), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 1), (700, 1), (720, 1), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 0), (740, 0), (760, 1), (780, 1), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 0), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 1), (360, 0), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 1), (500, 1), (520, 0), (540, 1), (560, 0), (580, 0), (600, 0), (620, 1), (640, 1), (660, 0), (680, 0), (700, 1), (720, 1), (740, 0), (760, 1), (780, 0), (800, 1), (820, 1), (840, 0), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 1), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 0), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 1), (280, 1), (300, 0), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 1), (580, 0), (600, 1), (620, 0), (640, 1), (660, 1), (680, 1), (700, 0), (720, 1), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 0), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 1), (260, 0), (280, 1), (300, 0), (320, 1), (340, 1), (360, 0), (380, 0), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 1), (700, 1), (720, 0), (740, 1), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 1), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 1), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 1), (460, 0), (480, 1), (500, 0), (520, 1), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 0), (700, 1), (720, 0), (740, 1), (760, 1), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 0), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 0), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 1.8v 658.995n 1.8v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 1), (280, 1), (300, 0), (320, 0), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 1), (3280, 1), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 0), (700, 1), (720, 0), (740, 1), (760, 1), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 1), (3100, 0), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 1), (380, 0), (400, 0), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 1), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 0), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 1), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 0), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 0), (3060, 1), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 1.8v 778.995n 1.8v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 1.8v 898.995n 1.8v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 1.8v 1078.995n 1.8v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 0), (180, 1), (200, 0), (220, 1), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 0), (660, 0), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 1), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 1), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 1), (380, 1), (400, 0), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 1), (540, 0), (560, 1), (580, 0), (600, 1), (620, 1), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 1), (780, 1), (800, 0), (820, 0), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 0), (2320, 1), (2340, 0), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 1.8v 38.995n 1.8v 39.005n 0.0v 58.995n 0.0v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 1.8v 438.995n 1.8v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 1.8v 538.995n 1.8v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 0.0v 658.995n 0.0v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 1.8v 778.995n 1.8v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 1.8v 1218.995n 1.8v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 1.8v 2458.995n 1.8v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 1.8v 2858.995n 1.8v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 1.8v 3438.995n 1.8v 3439.005n 1.8v 3458.995n 1.8v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 1.8v 58.995n 1.8v 59.005n 1.8v 78.995n 1.8v 79.005n 1.8v 98.995n 1.8v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 1.8v 278.995n 1.8v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 1.8v 338.995n 1.8v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 1.8v 398.995n 1.8v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 1.8v 578.995n 1.8v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 1.8v 698.995n 1.8v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 1.8v 798.995n 1.8v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 1.8v 1058.995n 1.8v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 1.8v 1198.995n 1.8v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 1.8v 2298.995n 1.8v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 1.8v 2618.995n 1.8v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 1.8v 2838.995n 1.8v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 1.8v 3258.995n 1.8v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 0), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 1.8v 178.995n 1.8v 179.005n 1.8v 198.995n 1.8v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 1.8v 358.995n 1.8v 359.005n 1.8v 378.995n 1.8v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 1.8v 878.995n 1.8v 879.005n 1.8v 898.995n 1.8v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 1.8v 958.995n 1.8v 959.005n 1.8v 978.995n 1.8v 979.005n 0.0v 998.995n 0.0v 999.005n 1.8v 1018.995n 1.8v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 1.8v 1158.995n 1.8v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 1.8v 1398.995n 1.8v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 1.8v 2018.995n 1.8v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 1.8v 2198.995n 1.8v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 1.8v 3018.995n 1.8v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 1.8v 3058.995n 1.8v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 1.8v 3958.995n 1.8v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va1_1  a1_1  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va1_2  a1_2  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va1_4  a1_4  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va1_5  a1_5  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va1_6  a1_6  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 1.8v 258.995n 1.8v 259.005n 1.8v 278.995n 1.8v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 1.8v 398.995n 1.8v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 1.8v 578.995n 1.8v 579.005n 1.8v 598.995n 1.8v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 1.8v 978.995n 1.8v 979.005n 1.8v 998.995n 1.8v 999.005n 0.0v 1018.995n 0.0v 1019.005n 1.8v 1038.995n 1.8v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 1.8v 1098.995n 1.8v 1099.005n 1.8v 1118.995n 1.8v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 1.8v 1238.995n 1.8v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 1.8v 1318.995n 1.8v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 1.8v 1438.995n 1.8v 1439.005n 1.8v 1458.995n 1.8v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 1.8v 1538.995n 1.8v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 1.8v 2378.995n 1.8v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 1.8v 2638.995n 1.8v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 1.8v 2698.995n 1.8v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 1.8v 2918.995n 1.8v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 1.8v 2958.995n 1.8v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 1.8v 3118.995n 1.8v 3119.005n 1.8v 3138.995n 1.8v 3139.005n 1.8v 3158.995n 1.8v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 1.8v 3418.995n 1.8v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va1_7  a1_7  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va1_8  a1_8  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 0), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va2_0  a2_0  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 1.8v 138.995n 1.8v 139.005n 1.8v 158.995n 1.8v 159.005n 1.8v 178.995n 1.8v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 0.0v 478.995n 0.0v 479.005n 1.8v 498.995n 1.8v 499.005n 1.8v 518.995n 1.8v 519.005n 1.8v 538.995n 1.8v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 0.0v 738.995n 0.0v 739.005n 1.8v 758.995n 1.8v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 1.8v 918.995n 1.8v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 1.8v 1178.995n 1.8v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 1.8v 1418.995n 1.8v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 1.8v 1478.995n 1.8v 1479.005n 1.8v 1498.995n 1.8v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 1.8v 1638.995n 1.8v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 1.8v 1778.995n 1.8v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 1.8v 1878.995n 1.8v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 1.8v 1938.995n 1.8v 1939.005n 1.8v 1958.995n 1.8v 1959.005n 1.8v 1978.995n 1.8v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 1.8v 2058.995n 1.8v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 1.8v 2118.995n 1.8v 2119.005n 1.8v 2138.995n 1.8v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 1.8v 2178.995n 1.8v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 1.8v 2218.995n 1.8v 2219.005n 1.8v 2238.995n 1.8v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 1.8v 2358.995n 1.8v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 1.8v 2398.995n 1.8v 2399.005n 1.8v 2418.995n 1.8v 2419.005n 1.8v 2438.995n 1.8v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 1.8v 2478.995n 1.8v 2479.005n 1.8v 2498.995n 1.8v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 1.8v 2558.995n 1.8v 2559.005n 1.8v 2578.995n 1.8v 2579.005n 1.8v 2598.995n 1.8v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 1.8v 2738.995n 1.8v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 1.8v 2998.995n 1.8v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 1.8v 3218.995n 1.8v 3219.005n 1.8v 3238.995n 1.8v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 1.8v 3298.995n 1.8v 3299.005n 1.8v 3318.995n 1.8v 3319.005n 1.8v 3338.995n 1.8v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 1.8v 3378.995n 1.8v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 1.8v 3478.995n 1.8v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 1.8v 3518.995n 1.8v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 1.8v 3558.995n 1.8v 3559.005n 1.8v 3578.995n 1.8v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 1.8v 3678.995n 1.8v 3679.005n 1.8v 3698.995n 1.8v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 1.8v 3798.995n 1.8v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 1.8v 3898.995n 1.8v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 1.8v 3938.995n 1.8v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 1.8v 4018.995n 1.8v 4019.005n 1.8v 4038.995n 1.8v 4039.005n 1.8v 4058.995n 1.8v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 1), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_1  a2_1  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_2  a2_2  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_3  a2_3  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_4  a2_4  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_5  a2_5  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va2_6  a2_6  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 1.8v 98.995n 1.8v 99.005n 1.8v 118.995n 1.8v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 1.8v 198.995n 1.8v 199.005n 1.8v 218.995n 1.8v 219.005n 1.8v 238.995n 1.8v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 1.8v 298.995n 1.8v 299.005n 1.8v 318.995n 1.8v 319.005n 1.8v 338.995n 1.8v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 1.8v 418.995n 1.8v 419.005n 0.0v 438.995n 0.0v 439.005n 1.8v 458.995n 1.8v 459.005n 1.8v 478.995n 1.8v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 1.8v 558.995n 1.8v 559.005n 0.0v 578.995n 0.0v 579.005n 1.8v 598.995n 1.8v 599.005n 1.8v 618.995n 1.8v 619.005n 1.8v 638.995n 1.8v 639.005n 1.8v 658.995n 1.8v 659.005n 1.8v 678.995n 1.8v 679.005n 0.0v 698.995n 0.0v 699.005n 1.8v 718.995n 1.8v 719.005n 1.8v 738.995n 1.8v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 1.8v 818.995n 1.8v 819.005n 1.8v 838.995n 1.8v 839.005n 1.8v 858.995n 1.8v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 1.8v 938.995n 1.8v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 1.8v 1138.995n 1.8v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 1.8v 1258.995n 1.8v 1259.005n 1.8v 1278.995n 1.8v 1279.005n 1.8v 1298.995n 1.8v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 1.8v 1338.995n 1.8v 1339.005n 1.8v 1358.995n 1.8v 1359.005n 1.8v 1378.995n 1.8v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 1.8v 1518.995n 1.8v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 1.8v 1558.995n 1.8v 1559.005n 1.8v 1578.995n 1.8v 1579.005n 1.8v 1598.995n 1.8v 1599.005n 1.8v 1618.995n 1.8v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 1.8v 1658.995n 1.8v 1659.005n 1.8v 1678.995n 1.8v 1679.005n 1.8v 1698.995n 1.8v 1699.005n 1.8v 1718.995n 1.8v 1719.005n 1.8v 1738.995n 1.8v 1739.005n 1.8v 1758.995n 1.8v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 1.8v 1798.995n 1.8v 1799.005n 1.8v 1818.995n 1.8v 1819.005n 1.8v 1838.995n 1.8v 1839.005n 1.8v 1858.995n 1.8v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 1.8v 1898.995n 1.8v 1899.005n 1.8v 1918.995n 1.8v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 1.8v 1998.995n 1.8v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 1.8v 2038.995n 1.8v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 1.8v 2078.995n 1.8v 2079.005n 1.8v 2098.995n 1.8v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 1.8v 2158.995n 1.8v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 1.8v 2258.995n 1.8v 2259.005n 1.8v 2278.995n 1.8v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 1.8v 2318.995n 1.8v 2319.005n 1.8v 2338.995n 1.8v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 1.8v 2518.995n 1.8v 2519.005n 1.8v 2538.995n 1.8v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 1.8v 2658.995n 1.8v 2659.005n 1.8v 2678.995n 1.8v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 1.8v 2718.995n 1.8v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 1.8v 2758.995n 1.8v 2759.005n 1.8v 2778.995n 1.8v 2779.005n 1.8v 2798.995n 1.8v 2799.005n 1.8v 2818.995n 1.8v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 1.8v 2878.995n 1.8v 2879.005n 1.8v 2898.995n 1.8v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 1.8v 2938.995n 1.8v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 1.8v 2978.995n 1.8v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 1.8v 3038.995n 1.8v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 1.8v 3078.995n 1.8v 3079.005n 1.8v 3098.995n 1.8v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 1.8v 3178.995n 1.8v 3179.005n 1.8v 3198.995n 1.8v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 1.8v 3278.995n 1.8v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 1.8v 3358.995n 1.8v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 1.8v 3398.995n 1.8v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 1.8v 3498.995n 1.8v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 1.8v 3538.995n 1.8v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 1.8v 3598.995n 1.8v 3599.005n 1.8v 3618.995n 1.8v 3619.005n 1.8v 3638.995n 1.8v 3639.005n 1.8v 3658.995n 1.8v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 1.8v 3718.995n 1.8v 3719.005n 1.8v 3738.995n 1.8v 3739.005n 1.8v 3758.995n 1.8v 3759.005n 1.8v 3778.995n 1.8v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 1.8v 3818.995n 1.8v 3819.005n 1.8v 3838.995n 1.8v 3839.005n 1.8v 3858.995n 1.8v 3859.005n 1.8v 3878.995n 1.8v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 1.8v 3918.995n 1.8v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 1.8v 3978.995n 1.8v 3979.005n 1.8v 3998.995n 1.8v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 1.8v 4078.995n 1.8v 4079.005n 1.8v 4098.995n 1.8v 4099.005n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va2_7  a2_7  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va2_8  a2_8  0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )

 * Generation of control signals
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
VCSB CSB 0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
VWEB WEB 0 PWL (0n 0.0v 18.995n 0.0v 19.005n 0.0v 38.995n 0.0v 39.005n 0.0v 58.995n 0.0v 59.005n 0.0v 78.995n 0.0v 79.005n 0.0v 98.995n 0.0v 99.005n 0.0v 118.995n 0.0v 119.005n 0.0v 138.995n 0.0v 139.005n 0.0v 158.995n 0.0v 159.005n 0.0v 178.995n 0.0v 179.005n 0.0v 198.995n 0.0v 199.005n 0.0v 218.995n 0.0v 219.005n 0.0v 238.995n 0.0v 239.005n 0.0v 258.995n 0.0v 259.005n 0.0v 278.995n 0.0v 279.005n 0.0v 298.995n 0.0v 299.005n 0.0v 318.995n 0.0v 319.005n 0.0v 338.995n 0.0v 339.005n 0.0v 358.995n 0.0v 359.005n 0.0v 378.995n 0.0v 379.005n 0.0v 398.995n 0.0v 399.005n 0.0v 418.995n 0.0v 419.005n 0.0v 438.995n 0.0v 439.005n 0.0v 458.995n 0.0v 459.005n 0.0v 478.995n 0.0v 479.005n 0.0v 498.995n 0.0v 499.005n 0.0v 518.995n 0.0v 519.005n 0.0v 538.995n 0.0v 539.005n 0.0v 558.995n 0.0v 559.005n 0.0v 578.995n 0.0v 579.005n 0.0v 598.995n 0.0v 599.005n 0.0v 618.995n 0.0v 619.005n 0.0v 638.995n 0.0v 639.005n 0.0v 658.995n 0.0v 659.005n 0.0v 678.995n 0.0v 679.005n 0.0v 698.995n 0.0v 699.005n 0.0v 718.995n 0.0v 719.005n 0.0v 738.995n 0.0v 739.005n 0.0v 758.995n 0.0v 759.005n 0.0v 778.995n 0.0v 779.005n 0.0v 798.995n 0.0v 799.005n 0.0v 818.995n 0.0v 819.005n 0.0v 838.995n 0.0v 839.005n 0.0v 858.995n 0.0v 859.005n 0.0v 878.995n 0.0v 879.005n 0.0v 898.995n 0.0v 899.005n 0.0v 918.995n 0.0v 919.005n 0.0v 938.995n 0.0v 939.005n 0.0v 958.995n 0.0v 959.005n 0.0v 978.995n 0.0v 979.005n 0.0v 998.995n 0.0v 999.005n 0.0v 1018.995n 0.0v 1019.005n 0.0v 1038.995n 0.0v 1039.005n 0.0v 1058.995n 0.0v 1059.005n 0.0v 1078.995n 0.0v 1079.005n 0.0v 1098.995n 0.0v 1099.005n 0.0v 1118.995n 0.0v 1119.005n 0.0v 1138.995n 0.0v 1139.005n 0.0v 1158.995n 0.0v 1159.005n 0.0v 1178.995n 0.0v 1179.005n 0.0v 1198.995n 0.0v 1199.005n 0.0v 1218.995n 0.0v 1219.005n 0.0v 1238.995n 0.0v 1239.005n 0.0v 1258.995n 0.0v 1259.005n 0.0v 1278.995n 0.0v 1279.005n 0.0v 1298.995n 0.0v 1299.005n 0.0v 1318.995n 0.0v 1319.005n 0.0v 1338.995n 0.0v 1339.005n 0.0v 1358.995n 0.0v 1359.005n 0.0v 1378.995n 0.0v 1379.005n 0.0v 1398.995n 0.0v 1399.005n 0.0v 1418.995n 0.0v 1419.005n 0.0v 1438.995n 0.0v 1439.005n 0.0v 1458.995n 0.0v 1459.005n 0.0v 1478.995n 0.0v 1479.005n 0.0v 1498.995n 0.0v 1499.005n 0.0v 1518.995n 0.0v 1519.005n 0.0v 1538.995n 0.0v 1539.005n 0.0v 1558.995n 0.0v 1559.005n 0.0v 1578.995n 0.0v 1579.005n 0.0v 1598.995n 0.0v 1599.005n 0.0v 1618.995n 0.0v 1619.005n 0.0v 1638.995n 0.0v 1639.005n 0.0v 1658.995n 0.0v 1659.005n 0.0v 1678.995n 0.0v 1679.005n 0.0v 1698.995n 0.0v 1699.005n 0.0v 1718.995n 0.0v 1719.005n 0.0v 1738.995n 0.0v 1739.005n 0.0v 1758.995n 0.0v 1759.005n 0.0v 1778.995n 0.0v 1779.005n 0.0v 1798.995n 0.0v 1799.005n 0.0v 1818.995n 0.0v 1819.005n 0.0v 1838.995n 0.0v 1839.005n 0.0v 1858.995n 0.0v 1859.005n 0.0v 1878.995n 0.0v 1879.005n 0.0v 1898.995n 0.0v 1899.005n 0.0v 1918.995n 0.0v 1919.005n 0.0v 1938.995n 0.0v 1939.005n 0.0v 1958.995n 0.0v 1959.005n 0.0v 1978.995n 0.0v 1979.005n 0.0v 1998.995n 0.0v 1999.005n 0.0v 2018.995n 0.0v 2019.005n 0.0v 2038.995n 0.0v 2039.005n 0.0v 2058.995n 0.0v 2059.005n 0.0v 2078.995n 0.0v 2079.005n 0.0v 2098.995n 0.0v 2099.005n 0.0v 2118.995n 0.0v 2119.005n 0.0v 2138.995n 0.0v 2139.005n 0.0v 2158.995n 0.0v 2159.005n 0.0v 2178.995n 0.0v 2179.005n 0.0v 2198.995n 0.0v 2199.005n 0.0v 2218.995n 0.0v 2219.005n 0.0v 2238.995n 0.0v 2239.005n 0.0v 2258.995n 0.0v 2259.005n 0.0v 2278.995n 0.0v 2279.005n 0.0v 2298.995n 0.0v 2299.005n 0.0v 2318.995n 0.0v 2319.005n 0.0v 2338.995n 0.0v 2339.005n 0.0v 2358.995n 0.0v 2359.005n 0.0v 2378.995n 0.0v 2379.005n 0.0v 2398.995n 0.0v 2399.005n 0.0v 2418.995n 0.0v 2419.005n 0.0v 2438.995n 0.0v 2439.005n 0.0v 2458.995n 0.0v 2459.005n 0.0v 2478.995n 0.0v 2479.005n 0.0v 2498.995n 0.0v 2499.005n 0.0v 2518.995n 0.0v 2519.005n 0.0v 2538.995n 0.0v 2539.005n 0.0v 2558.995n 0.0v 2559.005n 0.0v 2578.995n 0.0v 2579.005n 0.0v 2598.995n 0.0v 2599.005n 0.0v 2618.995n 0.0v 2619.005n 0.0v 2638.995n 0.0v 2639.005n 0.0v 2658.995n 0.0v 2659.005n 0.0v 2678.995n 0.0v 2679.005n 0.0v 2698.995n 0.0v 2699.005n 0.0v 2718.995n 0.0v 2719.005n 0.0v 2738.995n 0.0v 2739.005n 0.0v 2758.995n 0.0v 2759.005n 0.0v 2778.995n 0.0v 2779.005n 0.0v 2798.995n 0.0v 2799.005n 0.0v 2818.995n 0.0v 2819.005n 0.0v 2838.995n 0.0v 2839.005n 0.0v 2858.995n 0.0v 2859.005n 0.0v 2878.995n 0.0v 2879.005n 0.0v 2898.995n 0.0v 2899.005n 0.0v 2918.995n 0.0v 2919.005n 0.0v 2938.995n 0.0v 2939.005n 0.0v 2958.995n 0.0v 2959.005n 0.0v 2978.995n 0.0v 2979.005n 0.0v 2998.995n 0.0v 2999.005n 0.0v 3018.995n 0.0v 3019.005n 0.0v 3038.995n 0.0v 3039.005n 0.0v 3058.995n 0.0v 3059.005n 0.0v 3078.995n 0.0v 3079.005n 0.0v 3098.995n 0.0v 3099.005n 0.0v 3118.995n 0.0v 3119.005n 0.0v 3138.995n 0.0v 3139.005n 0.0v 3158.995n 0.0v 3159.005n 0.0v 3178.995n 0.0v 3179.005n 0.0v 3198.995n 0.0v 3199.005n 0.0v 3218.995n 0.0v 3219.005n 0.0v 3238.995n 0.0v 3239.005n 0.0v 3258.995n 0.0v 3259.005n 0.0v 3278.995n 0.0v 3279.005n 0.0v 3298.995n 0.0v 3299.005n 0.0v 3318.995n 0.0v 3319.005n 0.0v 3338.995n 0.0v 3339.005n 0.0v 3358.995n 0.0v 3359.005n 0.0v 3378.995n 0.0v 3379.005n 0.0v 3398.995n 0.0v 3399.005n 0.0v 3418.995n 0.0v 3419.005n 0.0v 3438.995n 0.0v 3439.005n 0.0v 3458.995n 0.0v 3459.005n 0.0v 3478.995n 0.0v 3479.005n 0.0v 3498.995n 0.0v 3499.005n 0.0v 3518.995n 0.0v 3519.005n 0.0v 3538.995n 0.0v 3539.005n 0.0v 3558.995n 0.0v 3559.005n 0.0v 3578.995n 0.0v 3579.005n 0.0v 3598.995n 0.0v 3599.005n 0.0v 3618.995n 0.0v 3619.005n 0.0v 3638.995n 0.0v 3639.005n 0.0v 3658.995n 0.0v 3659.005n 0.0v 3678.995n 0.0v 3679.005n 0.0v 3698.995n 0.0v 3699.005n 0.0v 3718.995n 0.0v 3719.005n 0.0v 3738.995n 0.0v 3739.005n 0.0v 3758.995n 0.0v 3759.005n 0.0v 3778.995n 0.0v 3779.005n 0.0v 3798.995n 0.0v 3799.005n 0.0v 3818.995n 0.0v 3819.005n 0.0v 3838.995n 0.0v 3839.005n 0.0v 3858.995n 0.0v 3859.005n 0.0v 3878.995n 0.0v 3879.005n 0.0v 3898.995n 0.0v 3899.005n 0.0v 3918.995n 0.0v 3919.005n 0.0v 3938.995n 0.0v 3939.005n 0.0v 3958.995n 0.0v 3959.005n 0.0v 3978.995n 0.0v 3979.005n 0.0v 3998.995n 0.0v 3999.005n 0.0v 4018.995n 0.0v 4019.005n 0.0v 4038.995n 0.0v 4039.005n 0.0v 4058.995n 0.0v 4059.005n 0.0v 4078.995n 0.0v 4079.005n 0.0v 4098.995n 0.0v 4099.005n 0.0v )
* PULSE: period=20
Vclk clk 0 PULSE (0 1.8 19.995n 0.01n 0.01n 9.989999999999998n 20n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 1.8 time = 100
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=100.1n

* CHECK dout1_1 Vdout1_1ck4 = 0 time = 100
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=100.1n

* CHECK dout1_2 Vdout1_2ck4 = 1.8 time = 100
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=100.1n

* CHECK dout1_3 Vdout1_3ck4 = 1.8 time = 100
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=100.1n

* CHECK dout1_4 Vdout1_4ck4 = 1.8 time = 100
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=100.1n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 100
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=100.1n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 100
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=100.1n

* CHECK dout1_7 Vdout1_7ck4 = 0 time = 100
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=100.1n

* CHECK dout1_8 Vdout1_8ck4 = 0 time = 100
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=100.1n

* CHECK dout1_9 Vdout1_9ck4 = 1.8 time = 100
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=100.1n

* CHECK dout1_10 Vdout1_10ck4 = 1.8 time = 100
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=100.1n

* CHECK dout1_11 Vdout1_11ck4 = 0 time = 100
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=100.1n

* CHECK dout1_12 Vdout1_12ck4 = 1.8 time = 100
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=100.1n

* CHECK dout1_13 Vdout1_13ck4 = 1.8 time = 100
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=100.1n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 100
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=100.1n

* CHECK dout1_15 Vdout1_15ck4 = 0 time = 100
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=100.1n

* CHECK dout1_16 Vdout1_16ck4 = 0 time = 100
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=100.1n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 100
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=100.1n

* CHECK dout1_18 Vdout1_18ck4 = 0 time = 100
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=100.1n

* CHECK dout1_19 Vdout1_19ck4 = 0 time = 100
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=100.1n

* CHECK dout1_20 Vdout1_20ck4 = 1.8 time = 100
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=100.1n

* CHECK dout1_21 Vdout1_21ck4 = 0 time = 100
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=100.1n

* CHECK dout1_22 Vdout1_22ck4 = 1.8 time = 100
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=100.1n

* CHECK dout1_23 Vdout1_23ck4 = 1.8 time = 100
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=100.1n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 100
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=100.1n

* CHECK dout1_25 Vdout1_25ck4 = 1.8 time = 100
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=100.1n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 100
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=100.1n

* CHECK dout1_27 Vdout1_27ck4 = 0 time = 100
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=100.1n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 100
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=100.1n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 100
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=100.1n

* CHECK dout1_30 Vdout1_30ck4 = 0 time = 100
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=100.1n

* CHECK dout1_31 Vdout1_31ck4 = 0 time = 100
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=100.1n

* CHECK dout2_0 Vdout2_0ck4 = 0 time = 100
.meas tran vdout2_0ck4 FIND v(dout2_0) AT=100.1n

* CHECK dout2_1 Vdout2_1ck4 = 1.8 time = 100
.meas tran vdout2_1ck4 FIND v(dout2_1) AT=100.1n

* CHECK dout2_2 Vdout2_2ck4 = 0 time = 100
.meas tran vdout2_2ck4 FIND v(dout2_2) AT=100.1n

* CHECK dout2_3 Vdout2_3ck4 = 0 time = 100
.meas tran vdout2_3ck4 FIND v(dout2_3) AT=100.1n

* CHECK dout2_4 Vdout2_4ck4 = 1.8 time = 100
.meas tran vdout2_4ck4 FIND v(dout2_4) AT=100.1n

* CHECK dout2_5 Vdout2_5ck4 = 1.8 time = 100
.meas tran vdout2_5ck4 FIND v(dout2_5) AT=100.1n

* CHECK dout2_6 Vdout2_6ck4 = 0 time = 100
.meas tran vdout2_6ck4 FIND v(dout2_6) AT=100.1n

* CHECK dout2_7 Vdout2_7ck4 = 1.8 time = 100
.meas tran vdout2_7ck4 FIND v(dout2_7) AT=100.1n

* CHECK dout2_8 Vdout2_8ck4 = 1.8 time = 100
.meas tran vdout2_8ck4 FIND v(dout2_8) AT=100.1n

* CHECK dout2_9 Vdout2_9ck4 = 0 time = 100
.meas tran vdout2_9ck4 FIND v(dout2_9) AT=100.1n

* CHECK dout2_10 Vdout2_10ck4 = 1.8 time = 100
.meas tran vdout2_10ck4 FIND v(dout2_10) AT=100.1n

* CHECK dout2_11 Vdout2_11ck4 = 0 time = 100
.meas tran vdout2_11ck4 FIND v(dout2_11) AT=100.1n

* CHECK dout2_12 Vdout2_12ck4 = 1.8 time = 100
.meas tran vdout2_12ck4 FIND v(dout2_12) AT=100.1n

* CHECK dout2_13 Vdout2_13ck4 = 0 time = 100
.meas tran vdout2_13ck4 FIND v(dout2_13) AT=100.1n

* CHECK dout2_14 Vdout2_14ck4 = 0 time = 100
.meas tran vdout2_14ck4 FIND v(dout2_14) AT=100.1n

* CHECK dout2_15 Vdout2_15ck4 = 0 time = 100
.meas tran vdout2_15ck4 FIND v(dout2_15) AT=100.1n

* CHECK dout2_16 Vdout2_16ck4 = 0 time = 100
.meas tran vdout2_16ck4 FIND v(dout2_16) AT=100.1n

* CHECK dout2_17 Vdout2_17ck4 = 1.8 time = 100
.meas tran vdout2_17ck4 FIND v(dout2_17) AT=100.1n

* CHECK dout2_18 Vdout2_18ck4 = 1.8 time = 100
.meas tran vdout2_18ck4 FIND v(dout2_18) AT=100.1n

* CHECK dout2_19 Vdout2_19ck4 = 0 time = 100
.meas tran vdout2_19ck4 FIND v(dout2_19) AT=100.1n

* CHECK dout2_20 Vdout2_20ck4 = 0 time = 100
.meas tran vdout2_20ck4 FIND v(dout2_20) AT=100.1n

* CHECK dout2_21 Vdout2_21ck4 = 0 time = 100
.meas tran vdout2_21ck4 FIND v(dout2_21) AT=100.1n

* CHECK dout2_22 Vdout2_22ck4 = 1.8 time = 100
.meas tran vdout2_22ck4 FIND v(dout2_22) AT=100.1n

* CHECK dout2_23 Vdout2_23ck4 = 1.8 time = 100
.meas tran vdout2_23ck4 FIND v(dout2_23) AT=100.1n

* CHECK dout2_24 Vdout2_24ck4 = 0 time = 100
.meas tran vdout2_24ck4 FIND v(dout2_24) AT=100.1n

* CHECK dout2_25 Vdout2_25ck4 = 0 time = 100
.meas tran vdout2_25ck4 FIND v(dout2_25) AT=100.1n

* CHECK dout2_26 Vdout2_26ck4 = 0 time = 100
.meas tran vdout2_26ck4 FIND v(dout2_26) AT=100.1n

* CHECK dout2_27 Vdout2_27ck4 = 1.8 time = 100
.meas tran vdout2_27ck4 FIND v(dout2_27) AT=100.1n

* CHECK dout2_28 Vdout2_28ck4 = 1.8 time = 100
.meas tran vdout2_28ck4 FIND v(dout2_28) AT=100.1n

* CHECK dout2_29 Vdout2_29ck4 = 0 time = 100
.meas tran vdout2_29ck4 FIND v(dout2_29) AT=100.1n

* CHECK dout2_30 Vdout2_30ck4 = 0 time = 100
.meas tran vdout2_30ck4 FIND v(dout2_30) AT=100.1n

* CHECK dout2_31 Vdout2_31ck4 = 0 time = 100
.meas tran vdout2_31ck4 FIND v(dout2_31) AT=100.1n

* CHECK dout1_0 Vdout1_0ck5 = 0 time = 120
.meas tran vdout1_0ck5 FIND v(dout1_0) AT=120.1n

* CHECK dout1_1 Vdout1_1ck5 = 1.8 time = 120
.meas tran vdout1_1ck5 FIND v(dout1_1) AT=120.1n

* CHECK dout1_2 Vdout1_2ck5 = 0 time = 120
.meas tran vdout1_2ck5 FIND v(dout1_2) AT=120.1n

* CHECK dout1_3 Vdout1_3ck5 = 0 time = 120
.meas tran vdout1_3ck5 FIND v(dout1_3) AT=120.1n

* CHECK dout1_4 Vdout1_4ck5 = 1.8 time = 120
.meas tran vdout1_4ck5 FIND v(dout1_4) AT=120.1n

* CHECK dout1_5 Vdout1_5ck5 = 1.8 time = 120
.meas tran vdout1_5ck5 FIND v(dout1_5) AT=120.1n

* CHECK dout1_6 Vdout1_6ck5 = 0 time = 120
.meas tran vdout1_6ck5 FIND v(dout1_6) AT=120.1n

* CHECK dout1_7 Vdout1_7ck5 = 1.8 time = 120
.meas tran vdout1_7ck5 FIND v(dout1_7) AT=120.1n

* CHECK dout1_8 Vdout1_8ck5 = 1.8 time = 120
.meas tran vdout1_8ck5 FIND v(dout1_8) AT=120.1n

* CHECK dout1_9 Vdout1_9ck5 = 0 time = 120
.meas tran vdout1_9ck5 FIND v(dout1_9) AT=120.1n

* CHECK dout1_10 Vdout1_10ck5 = 1.8 time = 120
.meas tran vdout1_10ck5 FIND v(dout1_10) AT=120.1n

* CHECK dout1_11 Vdout1_11ck5 = 0 time = 120
.meas tran vdout1_11ck5 FIND v(dout1_11) AT=120.1n

* CHECK dout1_12 Vdout1_12ck5 = 1.8 time = 120
.meas tran vdout1_12ck5 FIND v(dout1_12) AT=120.1n

* CHECK dout1_13 Vdout1_13ck5 = 0 time = 120
.meas tran vdout1_13ck5 FIND v(dout1_13) AT=120.1n

* CHECK dout1_14 Vdout1_14ck5 = 0 time = 120
.meas tran vdout1_14ck5 FIND v(dout1_14) AT=120.1n

* CHECK dout1_15 Vdout1_15ck5 = 0 time = 120
.meas tran vdout1_15ck5 FIND v(dout1_15) AT=120.1n

* CHECK dout1_16 Vdout1_16ck5 = 0 time = 120
.meas tran vdout1_16ck5 FIND v(dout1_16) AT=120.1n

* CHECK dout1_17 Vdout1_17ck5 = 1.8 time = 120
.meas tran vdout1_17ck5 FIND v(dout1_17) AT=120.1n

* CHECK dout1_18 Vdout1_18ck5 = 1.8 time = 120
.meas tran vdout1_18ck5 FIND v(dout1_18) AT=120.1n

* CHECK dout1_19 Vdout1_19ck5 = 0 time = 120
.meas tran vdout1_19ck5 FIND v(dout1_19) AT=120.1n

* CHECK dout1_20 Vdout1_20ck5 = 0 time = 120
.meas tran vdout1_20ck5 FIND v(dout1_20) AT=120.1n

* CHECK dout1_21 Vdout1_21ck5 = 0 time = 120
.meas tran vdout1_21ck5 FIND v(dout1_21) AT=120.1n

* CHECK dout1_22 Vdout1_22ck5 = 1.8 time = 120
.meas tran vdout1_22ck5 FIND v(dout1_22) AT=120.1n

* CHECK dout1_23 Vdout1_23ck5 = 1.8 time = 120
.meas tran vdout1_23ck5 FIND v(dout1_23) AT=120.1n

* CHECK dout1_24 Vdout1_24ck5 = 0 time = 120
.meas tran vdout1_24ck5 FIND v(dout1_24) AT=120.1n

* CHECK dout1_25 Vdout1_25ck5 = 0 time = 120
.meas tran vdout1_25ck5 FIND v(dout1_25) AT=120.1n

* CHECK dout1_26 Vdout1_26ck5 = 0 time = 120
.meas tran vdout1_26ck5 FIND v(dout1_26) AT=120.1n

* CHECK dout1_27 Vdout1_27ck5 = 1.8 time = 120
.meas tran vdout1_27ck5 FIND v(dout1_27) AT=120.1n

* CHECK dout1_28 Vdout1_28ck5 = 1.8 time = 120
.meas tran vdout1_28ck5 FIND v(dout1_28) AT=120.1n

* CHECK dout1_29 Vdout1_29ck5 = 0 time = 120
.meas tran vdout1_29ck5 FIND v(dout1_29) AT=120.1n

* CHECK dout1_30 Vdout1_30ck5 = 0 time = 120
.meas tran vdout1_30ck5 FIND v(dout1_30) AT=120.1n

* CHECK dout1_31 Vdout1_31ck5 = 0 time = 120
.meas tran vdout1_31ck5 FIND v(dout1_31) AT=120.1n

* CHECK dout1_0 Vdout1_0ck6 = 0 time = 140
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=140.1n

* CHECK dout1_1 Vdout1_1ck6 = 1.8 time = 140
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=140.1n

* CHECK dout1_2 Vdout1_2ck6 = 0 time = 140
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=140.1n

* CHECK dout1_3 Vdout1_3ck6 = 1.8 time = 140
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=140.1n

* CHECK dout1_4 Vdout1_4ck6 = 0 time = 140
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=140.1n

* CHECK dout1_5 Vdout1_5ck6 = 1.8 time = 140
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=140.1n

* CHECK dout1_6 Vdout1_6ck6 = 0 time = 140
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=140.1n

* CHECK dout1_7 Vdout1_7ck6 = 0 time = 140
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=140.1n

* CHECK dout1_8 Vdout1_8ck6 = 0 time = 140
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=140.1n

* CHECK dout1_9 Vdout1_9ck6 = 1.8 time = 140
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=140.1n

* CHECK dout1_10 Vdout1_10ck6 = 1.8 time = 140
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=140.1n

* CHECK dout1_11 Vdout1_11ck6 = 1.8 time = 140
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=140.1n

* CHECK dout1_12 Vdout1_12ck6 = 0 time = 140
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=140.1n

* CHECK dout1_13 Vdout1_13ck6 = 0 time = 140
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=140.1n

* CHECK dout1_14 Vdout1_14ck6 = 0 time = 140
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=140.1n

* CHECK dout1_15 Vdout1_15ck6 = 1.8 time = 140
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=140.1n

* CHECK dout1_16 Vdout1_16ck6 = 0 time = 140
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=140.1n

* CHECK dout1_17 Vdout1_17ck6 = 1.8 time = 140
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=140.1n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 140
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=140.1n

* CHECK dout1_19 Vdout1_19ck6 = 0 time = 140
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=140.1n

* CHECK dout1_20 Vdout1_20ck6 = 0 time = 140
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=140.1n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 140
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=140.1n

* CHECK dout1_22 Vdout1_22ck6 = 1.8 time = 140
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=140.1n

* CHECK dout1_23 Vdout1_23ck6 = 1.8 time = 140
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=140.1n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 140
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=140.1n

* CHECK dout1_25 Vdout1_25ck6 = 1.8 time = 140
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=140.1n

* CHECK dout1_26 Vdout1_26ck6 = 1.8 time = 140
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=140.1n

* CHECK dout1_27 Vdout1_27ck6 = 1.8 time = 140
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=140.1n

* CHECK dout1_28 Vdout1_28ck6 = 0 time = 140
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=140.1n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 140
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=140.1n

* CHECK dout1_30 Vdout1_30ck6 = 1.8 time = 140
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=140.1n

* CHECK dout1_31 Vdout1_31ck6 = 1.8 time = 140
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=140.1n

* CHECK dout2_0 Vdout2_0ck6 = 1.8 time = 140
.meas tran vdout2_0ck6 FIND v(dout2_0) AT=140.1n

* CHECK dout2_1 Vdout2_1ck6 = 0 time = 140
.meas tran vdout2_1ck6 FIND v(dout2_1) AT=140.1n

* CHECK dout2_2 Vdout2_2ck6 = 0 time = 140
.meas tran vdout2_2ck6 FIND v(dout2_2) AT=140.1n

* CHECK dout2_3 Vdout2_3ck6 = 1.8 time = 140
.meas tran vdout2_3ck6 FIND v(dout2_3) AT=140.1n

* CHECK dout2_4 Vdout2_4ck6 = 0 time = 140
.meas tran vdout2_4ck6 FIND v(dout2_4) AT=140.1n

* CHECK dout2_5 Vdout2_5ck6 = 1.8 time = 140
.meas tran vdout2_5ck6 FIND v(dout2_5) AT=140.1n

* CHECK dout2_6 Vdout2_6ck6 = 1.8 time = 140
.meas tran vdout2_6ck6 FIND v(dout2_6) AT=140.1n

* CHECK dout2_7 Vdout2_7ck6 = 0 time = 140
.meas tran vdout2_7ck6 FIND v(dout2_7) AT=140.1n

* CHECK dout2_8 Vdout2_8ck6 = 1.8 time = 140
.meas tran vdout2_8ck6 FIND v(dout2_8) AT=140.1n

* CHECK dout2_9 Vdout2_9ck6 = 1.8 time = 140
.meas tran vdout2_9ck6 FIND v(dout2_9) AT=140.1n

* CHECK dout2_10 Vdout2_10ck6 = 1.8 time = 140
.meas tran vdout2_10ck6 FIND v(dout2_10) AT=140.1n

* CHECK dout2_11 Vdout2_11ck6 = 1.8 time = 140
.meas tran vdout2_11ck6 FIND v(dout2_11) AT=140.1n

* CHECK dout2_12 Vdout2_12ck6 = 0 time = 140
.meas tran vdout2_12ck6 FIND v(dout2_12) AT=140.1n

* CHECK dout2_13 Vdout2_13ck6 = 1.8 time = 140
.meas tran vdout2_13ck6 FIND v(dout2_13) AT=140.1n

* CHECK dout2_14 Vdout2_14ck6 = 1.8 time = 140
.meas tran vdout2_14ck6 FIND v(dout2_14) AT=140.1n

* CHECK dout2_15 Vdout2_15ck6 = 0 time = 140
.meas tran vdout2_15ck6 FIND v(dout2_15) AT=140.1n

* CHECK dout2_16 Vdout2_16ck6 = 0 time = 140
.meas tran vdout2_16ck6 FIND v(dout2_16) AT=140.1n

* CHECK dout2_17 Vdout2_17ck6 = 0 time = 140
.meas tran vdout2_17ck6 FIND v(dout2_17) AT=140.1n

* CHECK dout2_18 Vdout2_18ck6 = 0 time = 140
.meas tran vdout2_18ck6 FIND v(dout2_18) AT=140.1n

* CHECK dout2_19 Vdout2_19ck6 = 1.8 time = 140
.meas tran vdout2_19ck6 FIND v(dout2_19) AT=140.1n

* CHECK dout2_20 Vdout2_20ck6 = 1.8 time = 140
.meas tran vdout2_20ck6 FIND v(dout2_20) AT=140.1n

* CHECK dout2_21 Vdout2_21ck6 = 1.8 time = 140
.meas tran vdout2_21ck6 FIND v(dout2_21) AT=140.1n

* CHECK dout2_22 Vdout2_22ck6 = 0 time = 140
.meas tran vdout2_22ck6 FIND v(dout2_22) AT=140.1n

* CHECK dout2_23 Vdout2_23ck6 = 0 time = 140
.meas tran vdout2_23ck6 FIND v(dout2_23) AT=140.1n

* CHECK dout2_24 Vdout2_24ck6 = 1.8 time = 140
.meas tran vdout2_24ck6 FIND v(dout2_24) AT=140.1n

* CHECK dout2_25 Vdout2_25ck6 = 0 time = 140
.meas tran vdout2_25ck6 FIND v(dout2_25) AT=140.1n

* CHECK dout2_26 Vdout2_26ck6 = 0 time = 140
.meas tran vdout2_26ck6 FIND v(dout2_26) AT=140.1n

* CHECK dout2_27 Vdout2_27ck6 = 1.8 time = 140
.meas tran vdout2_27ck6 FIND v(dout2_27) AT=140.1n

* CHECK dout2_28 Vdout2_28ck6 = 1.8 time = 140
.meas tran vdout2_28ck6 FIND v(dout2_28) AT=140.1n

* CHECK dout2_29 Vdout2_29ck6 = 1.8 time = 140
.meas tran vdout2_29ck6 FIND v(dout2_29) AT=140.1n

* CHECK dout2_30 Vdout2_30ck6 = 1.8 time = 140
.meas tran vdout2_30ck6 FIND v(dout2_30) AT=140.1n

* CHECK dout2_31 Vdout2_31ck6 = 0 time = 140
.meas tran vdout2_31ck6 FIND v(dout2_31) AT=140.1n

* CHECK dout2_0 Vdout2_0ck7 = 1.8 time = 160
.meas tran vdout2_0ck7 FIND v(dout2_0) AT=160.1n

* CHECK dout2_1 Vdout2_1ck7 = 0 time = 160
.meas tran vdout2_1ck7 FIND v(dout2_1) AT=160.1n

* CHECK dout2_2 Vdout2_2ck7 = 0 time = 160
.meas tran vdout2_2ck7 FIND v(dout2_2) AT=160.1n

* CHECK dout2_3 Vdout2_3ck7 = 1.8 time = 160
.meas tran vdout2_3ck7 FIND v(dout2_3) AT=160.1n

* CHECK dout2_4 Vdout2_4ck7 = 0 time = 160
.meas tran vdout2_4ck7 FIND v(dout2_4) AT=160.1n

* CHECK dout2_5 Vdout2_5ck7 = 1.8 time = 160
.meas tran vdout2_5ck7 FIND v(dout2_5) AT=160.1n

* CHECK dout2_6 Vdout2_6ck7 = 1.8 time = 160
.meas tran vdout2_6ck7 FIND v(dout2_6) AT=160.1n

* CHECK dout2_7 Vdout2_7ck7 = 0 time = 160
.meas tran vdout2_7ck7 FIND v(dout2_7) AT=160.1n

* CHECK dout2_8 Vdout2_8ck7 = 1.8 time = 160
.meas tran vdout2_8ck7 FIND v(dout2_8) AT=160.1n

* CHECK dout2_9 Vdout2_9ck7 = 1.8 time = 160
.meas tran vdout2_9ck7 FIND v(dout2_9) AT=160.1n

* CHECK dout2_10 Vdout2_10ck7 = 1.8 time = 160
.meas tran vdout2_10ck7 FIND v(dout2_10) AT=160.1n

* CHECK dout2_11 Vdout2_11ck7 = 1.8 time = 160
.meas tran vdout2_11ck7 FIND v(dout2_11) AT=160.1n

* CHECK dout2_12 Vdout2_12ck7 = 0 time = 160
.meas tran vdout2_12ck7 FIND v(dout2_12) AT=160.1n

* CHECK dout2_13 Vdout2_13ck7 = 1.8 time = 160
.meas tran vdout2_13ck7 FIND v(dout2_13) AT=160.1n

* CHECK dout2_14 Vdout2_14ck7 = 1.8 time = 160
.meas tran vdout2_14ck7 FIND v(dout2_14) AT=160.1n

* CHECK dout2_15 Vdout2_15ck7 = 0 time = 160
.meas tran vdout2_15ck7 FIND v(dout2_15) AT=160.1n

* CHECK dout2_16 Vdout2_16ck7 = 0 time = 160
.meas tran vdout2_16ck7 FIND v(dout2_16) AT=160.1n

* CHECK dout2_17 Vdout2_17ck7 = 0 time = 160
.meas tran vdout2_17ck7 FIND v(dout2_17) AT=160.1n

* CHECK dout2_18 Vdout2_18ck7 = 0 time = 160
.meas tran vdout2_18ck7 FIND v(dout2_18) AT=160.1n

* CHECK dout2_19 Vdout2_19ck7 = 1.8 time = 160
.meas tran vdout2_19ck7 FIND v(dout2_19) AT=160.1n

* CHECK dout2_20 Vdout2_20ck7 = 1.8 time = 160
.meas tran vdout2_20ck7 FIND v(dout2_20) AT=160.1n

* CHECK dout2_21 Vdout2_21ck7 = 1.8 time = 160
.meas tran vdout2_21ck7 FIND v(dout2_21) AT=160.1n

* CHECK dout2_22 Vdout2_22ck7 = 0 time = 160
.meas tran vdout2_22ck7 FIND v(dout2_22) AT=160.1n

* CHECK dout2_23 Vdout2_23ck7 = 0 time = 160
.meas tran vdout2_23ck7 FIND v(dout2_23) AT=160.1n

* CHECK dout2_24 Vdout2_24ck7 = 1.8 time = 160
.meas tran vdout2_24ck7 FIND v(dout2_24) AT=160.1n

* CHECK dout2_25 Vdout2_25ck7 = 0 time = 160
.meas tran vdout2_25ck7 FIND v(dout2_25) AT=160.1n

* CHECK dout2_26 Vdout2_26ck7 = 0 time = 160
.meas tran vdout2_26ck7 FIND v(dout2_26) AT=160.1n

* CHECK dout2_27 Vdout2_27ck7 = 1.8 time = 160
.meas tran vdout2_27ck7 FIND v(dout2_27) AT=160.1n

* CHECK dout2_28 Vdout2_28ck7 = 1.8 time = 160
.meas tran vdout2_28ck7 FIND v(dout2_28) AT=160.1n

* CHECK dout2_29 Vdout2_29ck7 = 1.8 time = 160
.meas tran vdout2_29ck7 FIND v(dout2_29) AT=160.1n

* CHECK dout2_30 Vdout2_30ck7 = 1.8 time = 160
.meas tran vdout2_30ck7 FIND v(dout2_30) AT=160.1n

* CHECK dout2_31 Vdout2_31ck7 = 0 time = 160
.meas tran vdout2_31ck7 FIND v(dout2_31) AT=160.1n

* CHECK dout1_0 Vdout1_0ck8 = 0 time = 180
.meas tran vdout1_0ck8 FIND v(dout1_0) AT=180.1n

* CHECK dout1_1 Vdout1_1ck8 = 1.8 time = 180
.meas tran vdout1_1ck8 FIND v(dout1_1) AT=180.1n

* CHECK dout1_2 Vdout1_2ck8 = 1.8 time = 180
.meas tran vdout1_2ck8 FIND v(dout1_2) AT=180.1n

* CHECK dout1_3 Vdout1_3ck8 = 1.8 time = 180
.meas tran vdout1_3ck8 FIND v(dout1_3) AT=180.1n

* CHECK dout1_4 Vdout1_4ck8 = 0 time = 180
.meas tran vdout1_4ck8 FIND v(dout1_4) AT=180.1n

* CHECK dout1_5 Vdout1_5ck8 = 1.8 time = 180
.meas tran vdout1_5ck8 FIND v(dout1_5) AT=180.1n

* CHECK dout1_6 Vdout1_6ck8 = 0 time = 180
.meas tran vdout1_6ck8 FIND v(dout1_6) AT=180.1n

* CHECK dout1_7 Vdout1_7ck8 = 0 time = 180
.meas tran vdout1_7ck8 FIND v(dout1_7) AT=180.1n

* CHECK dout1_8 Vdout1_8ck8 = 1.8 time = 180
.meas tran vdout1_8ck8 FIND v(dout1_8) AT=180.1n

* CHECK dout1_9 Vdout1_9ck8 = 0 time = 180
.meas tran vdout1_9ck8 FIND v(dout1_9) AT=180.1n

* CHECK dout1_10 Vdout1_10ck8 = 0 time = 180
.meas tran vdout1_10ck8 FIND v(dout1_10) AT=180.1n

* CHECK dout1_11 Vdout1_11ck8 = 1.8 time = 180
.meas tran vdout1_11ck8 FIND v(dout1_11) AT=180.1n

* CHECK dout1_12 Vdout1_12ck8 = 1.8 time = 180
.meas tran vdout1_12ck8 FIND v(dout1_12) AT=180.1n

* CHECK dout1_13 Vdout1_13ck8 = 1.8 time = 180
.meas tran vdout1_13ck8 FIND v(dout1_13) AT=180.1n

* CHECK dout1_14 Vdout1_14ck8 = 0 time = 180
.meas tran vdout1_14ck8 FIND v(dout1_14) AT=180.1n

* CHECK dout1_15 Vdout1_15ck8 = 1.8 time = 180
.meas tran vdout1_15ck8 FIND v(dout1_15) AT=180.1n

* CHECK dout1_16 Vdout1_16ck8 = 1.8 time = 180
.meas tran vdout1_16ck8 FIND v(dout1_16) AT=180.1n

* CHECK dout1_17 Vdout1_17ck8 = 1.8 time = 180
.meas tran vdout1_17ck8 FIND v(dout1_17) AT=180.1n

* CHECK dout1_18 Vdout1_18ck8 = 1.8 time = 180
.meas tran vdout1_18ck8 FIND v(dout1_18) AT=180.1n

* CHECK dout1_19 Vdout1_19ck8 = 0 time = 180
.meas tran vdout1_19ck8 FIND v(dout1_19) AT=180.1n

* CHECK dout1_20 Vdout1_20ck8 = 0 time = 180
.meas tran vdout1_20ck8 FIND v(dout1_20) AT=180.1n

* CHECK dout1_21 Vdout1_21ck8 = 1.8 time = 180
.meas tran vdout1_21ck8 FIND v(dout1_21) AT=180.1n

* CHECK dout1_22 Vdout1_22ck8 = 1.8 time = 180
.meas tran vdout1_22ck8 FIND v(dout1_22) AT=180.1n

* CHECK dout1_23 Vdout1_23ck8 = 0 time = 180
.meas tran vdout1_23ck8 FIND v(dout1_23) AT=180.1n

* CHECK dout1_24 Vdout1_24ck8 = 0 time = 180
.meas tran vdout1_24ck8 FIND v(dout1_24) AT=180.1n

* CHECK dout1_25 Vdout1_25ck8 = 0 time = 180
.meas tran vdout1_25ck8 FIND v(dout1_25) AT=180.1n

* CHECK dout1_26 Vdout1_26ck8 = 1.8 time = 180
.meas tran vdout1_26ck8 FIND v(dout1_26) AT=180.1n

* CHECK dout1_27 Vdout1_27ck8 = 1.8 time = 180
.meas tran vdout1_27ck8 FIND v(dout1_27) AT=180.1n

* CHECK dout1_28 Vdout1_28ck8 = 1.8 time = 180
.meas tran vdout1_28ck8 FIND v(dout1_28) AT=180.1n

* CHECK dout1_29 Vdout1_29ck8 = 0 time = 180
.meas tran vdout1_29ck8 FIND v(dout1_29) AT=180.1n

* CHECK dout1_30 Vdout1_30ck8 = 1.8 time = 180
.meas tran vdout1_30ck8 FIND v(dout1_30) AT=180.1n

* CHECK dout1_31 Vdout1_31ck8 = 1.8 time = 180
.meas tran vdout1_31ck8 FIND v(dout1_31) AT=180.1n

* CHECK dout1_0 Vdout1_0ck9 = 1.8 time = 200
.meas tran vdout1_0ck9 FIND v(dout1_0) AT=200.1n

* CHECK dout1_1 Vdout1_1ck9 = 0 time = 200
.meas tran vdout1_1ck9 FIND v(dout1_1) AT=200.1n

* CHECK dout1_2 Vdout1_2ck9 = 0 time = 200
.meas tran vdout1_2ck9 FIND v(dout1_2) AT=200.1n

* CHECK dout1_3 Vdout1_3ck9 = 1.8 time = 200
.meas tran vdout1_3ck9 FIND v(dout1_3) AT=200.1n

* CHECK dout1_4 Vdout1_4ck9 = 0 time = 200
.meas tran vdout1_4ck9 FIND v(dout1_4) AT=200.1n

* CHECK dout1_5 Vdout1_5ck9 = 1.8 time = 200
.meas tran vdout1_5ck9 FIND v(dout1_5) AT=200.1n

* CHECK dout1_6 Vdout1_6ck9 = 1.8 time = 200
.meas tran vdout1_6ck9 FIND v(dout1_6) AT=200.1n

* CHECK dout1_7 Vdout1_7ck9 = 0 time = 200
.meas tran vdout1_7ck9 FIND v(dout1_7) AT=200.1n

* CHECK dout1_8 Vdout1_8ck9 = 1.8 time = 200
.meas tran vdout1_8ck9 FIND v(dout1_8) AT=200.1n

* CHECK dout1_9 Vdout1_9ck9 = 1.8 time = 200
.meas tran vdout1_9ck9 FIND v(dout1_9) AT=200.1n

* CHECK dout1_10 Vdout1_10ck9 = 1.8 time = 200
.meas tran vdout1_10ck9 FIND v(dout1_10) AT=200.1n

* CHECK dout1_11 Vdout1_11ck9 = 1.8 time = 200
.meas tran vdout1_11ck9 FIND v(dout1_11) AT=200.1n

* CHECK dout1_12 Vdout1_12ck9 = 0 time = 200
.meas tran vdout1_12ck9 FIND v(dout1_12) AT=200.1n

* CHECK dout1_13 Vdout1_13ck9 = 1.8 time = 200
.meas tran vdout1_13ck9 FIND v(dout1_13) AT=200.1n

* CHECK dout1_14 Vdout1_14ck9 = 1.8 time = 200
.meas tran vdout1_14ck9 FIND v(dout1_14) AT=200.1n

* CHECK dout1_15 Vdout1_15ck9 = 0 time = 200
.meas tran vdout1_15ck9 FIND v(dout1_15) AT=200.1n

* CHECK dout1_16 Vdout1_16ck9 = 0 time = 200
.meas tran vdout1_16ck9 FIND v(dout1_16) AT=200.1n

* CHECK dout1_17 Vdout1_17ck9 = 0 time = 200
.meas tran vdout1_17ck9 FIND v(dout1_17) AT=200.1n

* CHECK dout1_18 Vdout1_18ck9 = 0 time = 200
.meas tran vdout1_18ck9 FIND v(dout1_18) AT=200.1n

* CHECK dout1_19 Vdout1_19ck9 = 1.8 time = 200
.meas tran vdout1_19ck9 FIND v(dout1_19) AT=200.1n

* CHECK dout1_20 Vdout1_20ck9 = 1.8 time = 200
.meas tran vdout1_20ck9 FIND v(dout1_20) AT=200.1n

* CHECK dout1_21 Vdout1_21ck9 = 1.8 time = 200
.meas tran vdout1_21ck9 FIND v(dout1_21) AT=200.1n

* CHECK dout1_22 Vdout1_22ck9 = 0 time = 200
.meas tran vdout1_22ck9 FIND v(dout1_22) AT=200.1n

* CHECK dout1_23 Vdout1_23ck9 = 0 time = 200
.meas tran vdout1_23ck9 FIND v(dout1_23) AT=200.1n

* CHECK dout1_24 Vdout1_24ck9 = 1.8 time = 200
.meas tran vdout1_24ck9 FIND v(dout1_24) AT=200.1n

* CHECK dout1_25 Vdout1_25ck9 = 0 time = 200
.meas tran vdout1_25ck9 FIND v(dout1_25) AT=200.1n

* CHECK dout1_26 Vdout1_26ck9 = 0 time = 200
.meas tran vdout1_26ck9 FIND v(dout1_26) AT=200.1n

* CHECK dout1_27 Vdout1_27ck9 = 1.8 time = 200
.meas tran vdout1_27ck9 FIND v(dout1_27) AT=200.1n

* CHECK dout1_28 Vdout1_28ck9 = 1.8 time = 200
.meas tran vdout1_28ck9 FIND v(dout1_28) AT=200.1n

* CHECK dout1_29 Vdout1_29ck9 = 1.8 time = 200
.meas tran vdout1_29ck9 FIND v(dout1_29) AT=200.1n

* CHECK dout1_30 Vdout1_30ck9 = 1.8 time = 200
.meas tran vdout1_30ck9 FIND v(dout1_30) AT=200.1n

* CHECK dout1_31 Vdout1_31ck9 = 0 time = 200
.meas tran vdout1_31ck9 FIND v(dout1_31) AT=200.1n

* CHECK dout2_0 Vdout2_0ck9 = 0 time = 200
.meas tran vdout2_0ck9 FIND v(dout2_0) AT=200.1n

* CHECK dout2_1 Vdout2_1ck9 = 1.8 time = 200
.meas tran vdout2_1ck9 FIND v(dout2_1) AT=200.1n

* CHECK dout2_2 Vdout2_2ck9 = 0 time = 200
.meas tran vdout2_2ck9 FIND v(dout2_2) AT=200.1n

* CHECK dout2_3 Vdout2_3ck9 = 1.8 time = 200
.meas tran vdout2_3ck9 FIND v(dout2_3) AT=200.1n

* CHECK dout2_4 Vdout2_4ck9 = 0 time = 200
.meas tran vdout2_4ck9 FIND v(dout2_4) AT=200.1n

* CHECK dout2_5 Vdout2_5ck9 = 1.8 time = 200
.meas tran vdout2_5ck9 FIND v(dout2_5) AT=200.1n

* CHECK dout2_6 Vdout2_6ck9 = 0 time = 200
.meas tran vdout2_6ck9 FIND v(dout2_6) AT=200.1n

* CHECK dout2_7 Vdout2_7ck9 = 0 time = 200
.meas tran vdout2_7ck9 FIND v(dout2_7) AT=200.1n

* CHECK dout2_8 Vdout2_8ck9 = 0 time = 200
.meas tran vdout2_8ck9 FIND v(dout2_8) AT=200.1n

* CHECK dout2_9 Vdout2_9ck9 = 1.8 time = 200
.meas tran vdout2_9ck9 FIND v(dout2_9) AT=200.1n

* CHECK dout2_10 Vdout2_10ck9 = 1.8 time = 200
.meas tran vdout2_10ck9 FIND v(dout2_10) AT=200.1n

* CHECK dout2_11 Vdout2_11ck9 = 1.8 time = 200
.meas tran vdout2_11ck9 FIND v(dout2_11) AT=200.1n

* CHECK dout2_12 Vdout2_12ck9 = 0 time = 200
.meas tran vdout2_12ck9 FIND v(dout2_12) AT=200.1n

* CHECK dout2_13 Vdout2_13ck9 = 0 time = 200
.meas tran vdout2_13ck9 FIND v(dout2_13) AT=200.1n

* CHECK dout2_14 Vdout2_14ck9 = 0 time = 200
.meas tran vdout2_14ck9 FIND v(dout2_14) AT=200.1n

* CHECK dout2_15 Vdout2_15ck9 = 1.8 time = 200
.meas tran vdout2_15ck9 FIND v(dout2_15) AT=200.1n

* CHECK dout2_16 Vdout2_16ck9 = 0 time = 200
.meas tran vdout2_16ck9 FIND v(dout2_16) AT=200.1n

* CHECK dout2_17 Vdout2_17ck9 = 1.8 time = 200
.meas tran vdout2_17ck9 FIND v(dout2_17) AT=200.1n

* CHECK dout2_18 Vdout2_18ck9 = 0 time = 200
.meas tran vdout2_18ck9 FIND v(dout2_18) AT=200.1n

* CHECK dout2_19 Vdout2_19ck9 = 0 time = 200
.meas tran vdout2_19ck9 FIND v(dout2_19) AT=200.1n

* CHECK dout2_20 Vdout2_20ck9 = 0 time = 200
.meas tran vdout2_20ck9 FIND v(dout2_20) AT=200.1n

* CHECK dout2_21 Vdout2_21ck9 = 0 time = 200
.meas tran vdout2_21ck9 FIND v(dout2_21) AT=200.1n

* CHECK dout2_22 Vdout2_22ck9 = 1.8 time = 200
.meas tran vdout2_22ck9 FIND v(dout2_22) AT=200.1n

* CHECK dout2_23 Vdout2_23ck9 = 1.8 time = 200
.meas tran vdout2_23ck9 FIND v(dout2_23) AT=200.1n

* CHECK dout2_24 Vdout2_24ck9 = 0 time = 200
.meas tran vdout2_24ck9 FIND v(dout2_24) AT=200.1n

* CHECK dout2_25 Vdout2_25ck9 = 1.8 time = 200
.meas tran vdout2_25ck9 FIND v(dout2_25) AT=200.1n

* CHECK dout2_26 Vdout2_26ck9 = 1.8 time = 200
.meas tran vdout2_26ck9 FIND v(dout2_26) AT=200.1n

* CHECK dout2_27 Vdout2_27ck9 = 1.8 time = 200
.meas tran vdout2_27ck9 FIND v(dout2_27) AT=200.1n

* CHECK dout2_28 Vdout2_28ck9 = 0 time = 200
.meas tran vdout2_28ck9 FIND v(dout2_28) AT=200.1n

* CHECK dout2_29 Vdout2_29ck9 = 0 time = 200
.meas tran vdout2_29ck9 FIND v(dout2_29) AT=200.1n

* CHECK dout2_30 Vdout2_30ck9 = 1.8 time = 200
.meas tran vdout2_30ck9 FIND v(dout2_30) AT=200.1n

* CHECK dout2_31 Vdout2_31ck9 = 1.8 time = 200
.meas tran vdout2_31ck9 FIND v(dout2_31) AT=200.1n

* CHECK dout1_0 Vdout1_0ck10 = 0 time = 220
.meas tran vdout1_0ck10 FIND v(dout1_0) AT=220.1n

* CHECK dout1_1 Vdout1_1ck10 = 1.8 time = 220
.meas tran vdout1_1ck10 FIND v(dout1_1) AT=220.1n

* CHECK dout1_2 Vdout1_2ck10 = 0 time = 220
.meas tran vdout1_2ck10 FIND v(dout1_2) AT=220.1n

* CHECK dout1_3 Vdout1_3ck10 = 1.8 time = 220
.meas tran vdout1_3ck10 FIND v(dout1_3) AT=220.1n

* CHECK dout1_4 Vdout1_4ck10 = 0 time = 220
.meas tran vdout1_4ck10 FIND v(dout1_4) AT=220.1n

* CHECK dout1_5 Vdout1_5ck10 = 1.8 time = 220
.meas tran vdout1_5ck10 FIND v(dout1_5) AT=220.1n

* CHECK dout1_6 Vdout1_6ck10 = 0 time = 220
.meas tran vdout1_6ck10 FIND v(dout1_6) AT=220.1n

* CHECK dout1_7 Vdout1_7ck10 = 0 time = 220
.meas tran vdout1_7ck10 FIND v(dout1_7) AT=220.1n

* CHECK dout1_8 Vdout1_8ck10 = 0 time = 220
.meas tran vdout1_8ck10 FIND v(dout1_8) AT=220.1n

* CHECK dout1_9 Vdout1_9ck10 = 1.8 time = 220
.meas tran vdout1_9ck10 FIND v(dout1_9) AT=220.1n

* CHECK dout1_10 Vdout1_10ck10 = 1.8 time = 220
.meas tran vdout1_10ck10 FIND v(dout1_10) AT=220.1n

* CHECK dout1_11 Vdout1_11ck10 = 1.8 time = 220
.meas tran vdout1_11ck10 FIND v(dout1_11) AT=220.1n

* CHECK dout1_12 Vdout1_12ck10 = 0 time = 220
.meas tran vdout1_12ck10 FIND v(dout1_12) AT=220.1n

* CHECK dout1_13 Vdout1_13ck10 = 0 time = 220
.meas tran vdout1_13ck10 FIND v(dout1_13) AT=220.1n

* CHECK dout1_14 Vdout1_14ck10 = 0 time = 220
.meas tran vdout1_14ck10 FIND v(dout1_14) AT=220.1n

* CHECK dout1_15 Vdout1_15ck10 = 1.8 time = 220
.meas tran vdout1_15ck10 FIND v(dout1_15) AT=220.1n

* CHECK dout1_16 Vdout1_16ck10 = 0 time = 220
.meas tran vdout1_16ck10 FIND v(dout1_16) AT=220.1n

* CHECK dout1_17 Vdout1_17ck10 = 1.8 time = 220
.meas tran vdout1_17ck10 FIND v(dout1_17) AT=220.1n

* CHECK dout1_18 Vdout1_18ck10 = 0 time = 220
.meas tran vdout1_18ck10 FIND v(dout1_18) AT=220.1n

* CHECK dout1_19 Vdout1_19ck10 = 0 time = 220
.meas tran vdout1_19ck10 FIND v(dout1_19) AT=220.1n

* CHECK dout1_20 Vdout1_20ck10 = 0 time = 220
.meas tran vdout1_20ck10 FIND v(dout1_20) AT=220.1n

* CHECK dout1_21 Vdout1_21ck10 = 0 time = 220
.meas tran vdout1_21ck10 FIND v(dout1_21) AT=220.1n

* CHECK dout1_22 Vdout1_22ck10 = 1.8 time = 220
.meas tran vdout1_22ck10 FIND v(dout1_22) AT=220.1n

* CHECK dout1_23 Vdout1_23ck10 = 1.8 time = 220
.meas tran vdout1_23ck10 FIND v(dout1_23) AT=220.1n

* CHECK dout1_24 Vdout1_24ck10 = 0 time = 220
.meas tran vdout1_24ck10 FIND v(dout1_24) AT=220.1n

* CHECK dout1_25 Vdout1_25ck10 = 1.8 time = 220
.meas tran vdout1_25ck10 FIND v(dout1_25) AT=220.1n

* CHECK dout1_26 Vdout1_26ck10 = 1.8 time = 220
.meas tran vdout1_26ck10 FIND v(dout1_26) AT=220.1n

* CHECK dout1_27 Vdout1_27ck10 = 1.8 time = 220
.meas tran vdout1_27ck10 FIND v(dout1_27) AT=220.1n

* CHECK dout1_28 Vdout1_28ck10 = 0 time = 220
.meas tran vdout1_28ck10 FIND v(dout1_28) AT=220.1n

* CHECK dout1_29 Vdout1_29ck10 = 0 time = 220
.meas tran vdout1_29ck10 FIND v(dout1_29) AT=220.1n

* CHECK dout1_30 Vdout1_30ck10 = 1.8 time = 220
.meas tran vdout1_30ck10 FIND v(dout1_30) AT=220.1n

* CHECK dout1_31 Vdout1_31ck10 = 1.8 time = 220
.meas tran vdout1_31ck10 FIND v(dout1_31) AT=220.1n

* CHECK dout2_0 Vdout2_0ck10 = 0 time = 220
.meas tran vdout2_0ck10 FIND v(dout2_0) AT=220.1n

* CHECK dout2_1 Vdout2_1ck10 = 1.8 time = 220
.meas tran vdout2_1ck10 FIND v(dout2_1) AT=220.1n

* CHECK dout2_2 Vdout2_2ck10 = 0 time = 220
.meas tran vdout2_2ck10 FIND v(dout2_2) AT=220.1n

* CHECK dout2_3 Vdout2_3ck10 = 1.8 time = 220
.meas tran vdout2_3ck10 FIND v(dout2_3) AT=220.1n

* CHECK dout2_4 Vdout2_4ck10 = 0 time = 220
.meas tran vdout2_4ck10 FIND v(dout2_4) AT=220.1n

* CHECK dout2_5 Vdout2_5ck10 = 1.8 time = 220
.meas tran vdout2_5ck10 FIND v(dout2_5) AT=220.1n

* CHECK dout2_6 Vdout2_6ck10 = 0 time = 220
.meas tran vdout2_6ck10 FIND v(dout2_6) AT=220.1n

* CHECK dout2_7 Vdout2_7ck10 = 0 time = 220
.meas tran vdout2_7ck10 FIND v(dout2_7) AT=220.1n

* CHECK dout2_8 Vdout2_8ck10 = 0 time = 220
.meas tran vdout2_8ck10 FIND v(dout2_8) AT=220.1n

* CHECK dout2_9 Vdout2_9ck10 = 1.8 time = 220
.meas tran vdout2_9ck10 FIND v(dout2_9) AT=220.1n

* CHECK dout2_10 Vdout2_10ck10 = 1.8 time = 220
.meas tran vdout2_10ck10 FIND v(dout2_10) AT=220.1n

* CHECK dout2_11 Vdout2_11ck10 = 1.8 time = 220
.meas tran vdout2_11ck10 FIND v(dout2_11) AT=220.1n

* CHECK dout2_12 Vdout2_12ck10 = 0 time = 220
.meas tran vdout2_12ck10 FIND v(dout2_12) AT=220.1n

* CHECK dout2_13 Vdout2_13ck10 = 0 time = 220
.meas tran vdout2_13ck10 FIND v(dout2_13) AT=220.1n

* CHECK dout2_14 Vdout2_14ck10 = 0 time = 220
.meas tran vdout2_14ck10 FIND v(dout2_14) AT=220.1n

* CHECK dout2_15 Vdout2_15ck10 = 1.8 time = 220
.meas tran vdout2_15ck10 FIND v(dout2_15) AT=220.1n

* CHECK dout2_16 Vdout2_16ck10 = 0 time = 220
.meas tran vdout2_16ck10 FIND v(dout2_16) AT=220.1n

* CHECK dout2_17 Vdout2_17ck10 = 1.8 time = 220
.meas tran vdout2_17ck10 FIND v(dout2_17) AT=220.1n

* CHECK dout2_18 Vdout2_18ck10 = 0 time = 220
.meas tran vdout2_18ck10 FIND v(dout2_18) AT=220.1n

* CHECK dout2_19 Vdout2_19ck10 = 0 time = 220
.meas tran vdout2_19ck10 FIND v(dout2_19) AT=220.1n

* CHECK dout2_20 Vdout2_20ck10 = 0 time = 220
.meas tran vdout2_20ck10 FIND v(dout2_20) AT=220.1n

* CHECK dout2_21 Vdout2_21ck10 = 0 time = 220
.meas tran vdout2_21ck10 FIND v(dout2_21) AT=220.1n

* CHECK dout2_22 Vdout2_22ck10 = 1.8 time = 220
.meas tran vdout2_22ck10 FIND v(dout2_22) AT=220.1n

* CHECK dout2_23 Vdout2_23ck10 = 1.8 time = 220
.meas tran vdout2_23ck10 FIND v(dout2_23) AT=220.1n

* CHECK dout2_24 Vdout2_24ck10 = 0 time = 220
.meas tran vdout2_24ck10 FIND v(dout2_24) AT=220.1n

* CHECK dout2_25 Vdout2_25ck10 = 1.8 time = 220
.meas tran vdout2_25ck10 FIND v(dout2_25) AT=220.1n

* CHECK dout2_26 Vdout2_26ck10 = 1.8 time = 220
.meas tran vdout2_26ck10 FIND v(dout2_26) AT=220.1n

* CHECK dout2_27 Vdout2_27ck10 = 1.8 time = 220
.meas tran vdout2_27ck10 FIND v(dout2_27) AT=220.1n

* CHECK dout2_28 Vdout2_28ck10 = 0 time = 220
.meas tran vdout2_28ck10 FIND v(dout2_28) AT=220.1n

* CHECK dout2_29 Vdout2_29ck10 = 0 time = 220
.meas tran vdout2_29ck10 FIND v(dout2_29) AT=220.1n

* CHECK dout2_30 Vdout2_30ck10 = 1.8 time = 220
.meas tran vdout2_30ck10 FIND v(dout2_30) AT=220.1n

* CHECK dout2_31 Vdout2_31ck10 = 1.8 time = 220
.meas tran vdout2_31ck10 FIND v(dout2_31) AT=220.1n

* CHECK dout1_0 Vdout1_0ck11 = 0 time = 240
.meas tran vdout1_0ck11 FIND v(dout1_0) AT=240.1n

* CHECK dout1_1 Vdout1_1ck11 = 1.8 time = 240
.meas tran vdout1_1ck11 FIND v(dout1_1) AT=240.1n

* CHECK dout1_2 Vdout1_2ck11 = 0 time = 240
.meas tran vdout1_2ck11 FIND v(dout1_2) AT=240.1n

* CHECK dout1_3 Vdout1_3ck11 = 1.8 time = 240
.meas tran vdout1_3ck11 FIND v(dout1_3) AT=240.1n

* CHECK dout1_4 Vdout1_4ck11 = 0 time = 240
.meas tran vdout1_4ck11 FIND v(dout1_4) AT=240.1n

* CHECK dout1_5 Vdout1_5ck11 = 1.8 time = 240
.meas tran vdout1_5ck11 FIND v(dout1_5) AT=240.1n

* CHECK dout1_6 Vdout1_6ck11 = 0 time = 240
.meas tran vdout1_6ck11 FIND v(dout1_6) AT=240.1n

* CHECK dout1_7 Vdout1_7ck11 = 0 time = 240
.meas tran vdout1_7ck11 FIND v(dout1_7) AT=240.1n

* CHECK dout1_8 Vdout1_8ck11 = 0 time = 240
.meas tran vdout1_8ck11 FIND v(dout1_8) AT=240.1n

* CHECK dout1_9 Vdout1_9ck11 = 1.8 time = 240
.meas tran vdout1_9ck11 FIND v(dout1_9) AT=240.1n

* CHECK dout1_10 Vdout1_10ck11 = 1.8 time = 240
.meas tran vdout1_10ck11 FIND v(dout1_10) AT=240.1n

* CHECK dout1_11 Vdout1_11ck11 = 1.8 time = 240
.meas tran vdout1_11ck11 FIND v(dout1_11) AT=240.1n

* CHECK dout1_12 Vdout1_12ck11 = 0 time = 240
.meas tran vdout1_12ck11 FIND v(dout1_12) AT=240.1n

* CHECK dout1_13 Vdout1_13ck11 = 0 time = 240
.meas tran vdout1_13ck11 FIND v(dout1_13) AT=240.1n

* CHECK dout1_14 Vdout1_14ck11 = 0 time = 240
.meas tran vdout1_14ck11 FIND v(dout1_14) AT=240.1n

* CHECK dout1_15 Vdout1_15ck11 = 1.8 time = 240
.meas tran vdout1_15ck11 FIND v(dout1_15) AT=240.1n

* CHECK dout1_16 Vdout1_16ck11 = 0 time = 240
.meas tran vdout1_16ck11 FIND v(dout1_16) AT=240.1n

* CHECK dout1_17 Vdout1_17ck11 = 1.8 time = 240
.meas tran vdout1_17ck11 FIND v(dout1_17) AT=240.1n

* CHECK dout1_18 Vdout1_18ck11 = 0 time = 240
.meas tran vdout1_18ck11 FIND v(dout1_18) AT=240.1n

* CHECK dout1_19 Vdout1_19ck11 = 0 time = 240
.meas tran vdout1_19ck11 FIND v(dout1_19) AT=240.1n

* CHECK dout1_20 Vdout1_20ck11 = 0 time = 240
.meas tran vdout1_20ck11 FIND v(dout1_20) AT=240.1n

* CHECK dout1_21 Vdout1_21ck11 = 0 time = 240
.meas tran vdout1_21ck11 FIND v(dout1_21) AT=240.1n

* CHECK dout1_22 Vdout1_22ck11 = 1.8 time = 240
.meas tran vdout1_22ck11 FIND v(dout1_22) AT=240.1n

* CHECK dout1_23 Vdout1_23ck11 = 1.8 time = 240
.meas tran vdout1_23ck11 FIND v(dout1_23) AT=240.1n

* CHECK dout1_24 Vdout1_24ck11 = 0 time = 240
.meas tran vdout1_24ck11 FIND v(dout1_24) AT=240.1n

* CHECK dout1_25 Vdout1_25ck11 = 1.8 time = 240
.meas tran vdout1_25ck11 FIND v(dout1_25) AT=240.1n

* CHECK dout1_26 Vdout1_26ck11 = 1.8 time = 240
.meas tran vdout1_26ck11 FIND v(dout1_26) AT=240.1n

* CHECK dout1_27 Vdout1_27ck11 = 1.8 time = 240
.meas tran vdout1_27ck11 FIND v(dout1_27) AT=240.1n

* CHECK dout1_28 Vdout1_28ck11 = 0 time = 240
.meas tran vdout1_28ck11 FIND v(dout1_28) AT=240.1n

* CHECK dout1_29 Vdout1_29ck11 = 0 time = 240
.meas tran vdout1_29ck11 FIND v(dout1_29) AT=240.1n

* CHECK dout1_30 Vdout1_30ck11 = 1.8 time = 240
.meas tran vdout1_30ck11 FIND v(dout1_30) AT=240.1n

* CHECK dout1_31 Vdout1_31ck11 = 1.8 time = 240
.meas tran vdout1_31ck11 FIND v(dout1_31) AT=240.1n

* CHECK dout2_0 Vdout2_0ck11 = 0 time = 240
.meas tran vdout2_0ck11 FIND v(dout2_0) AT=240.1n

* CHECK dout2_1 Vdout2_1ck11 = 1.8 time = 240
.meas tran vdout2_1ck11 FIND v(dout2_1) AT=240.1n

* CHECK dout2_2 Vdout2_2ck11 = 0 time = 240
.meas tran vdout2_2ck11 FIND v(dout2_2) AT=240.1n

* CHECK dout2_3 Vdout2_3ck11 = 1.8 time = 240
.meas tran vdout2_3ck11 FIND v(dout2_3) AT=240.1n

* CHECK dout2_4 Vdout2_4ck11 = 0 time = 240
.meas tran vdout2_4ck11 FIND v(dout2_4) AT=240.1n

* CHECK dout2_5 Vdout2_5ck11 = 1.8 time = 240
.meas tran vdout2_5ck11 FIND v(dout2_5) AT=240.1n

* CHECK dout2_6 Vdout2_6ck11 = 0 time = 240
.meas tran vdout2_6ck11 FIND v(dout2_6) AT=240.1n

* CHECK dout2_7 Vdout2_7ck11 = 0 time = 240
.meas tran vdout2_7ck11 FIND v(dout2_7) AT=240.1n

* CHECK dout2_8 Vdout2_8ck11 = 0 time = 240
.meas tran vdout2_8ck11 FIND v(dout2_8) AT=240.1n

* CHECK dout2_9 Vdout2_9ck11 = 1.8 time = 240
.meas tran vdout2_9ck11 FIND v(dout2_9) AT=240.1n

* CHECK dout2_10 Vdout2_10ck11 = 1.8 time = 240
.meas tran vdout2_10ck11 FIND v(dout2_10) AT=240.1n

* CHECK dout2_11 Vdout2_11ck11 = 1.8 time = 240
.meas tran vdout2_11ck11 FIND v(dout2_11) AT=240.1n

* CHECK dout2_12 Vdout2_12ck11 = 0 time = 240
.meas tran vdout2_12ck11 FIND v(dout2_12) AT=240.1n

* CHECK dout2_13 Vdout2_13ck11 = 0 time = 240
.meas tran vdout2_13ck11 FIND v(dout2_13) AT=240.1n

* CHECK dout2_14 Vdout2_14ck11 = 0 time = 240
.meas tran vdout2_14ck11 FIND v(dout2_14) AT=240.1n

* CHECK dout2_15 Vdout2_15ck11 = 1.8 time = 240
.meas tran vdout2_15ck11 FIND v(dout2_15) AT=240.1n

* CHECK dout2_16 Vdout2_16ck11 = 0 time = 240
.meas tran vdout2_16ck11 FIND v(dout2_16) AT=240.1n

* CHECK dout2_17 Vdout2_17ck11 = 1.8 time = 240
.meas tran vdout2_17ck11 FIND v(dout2_17) AT=240.1n

* CHECK dout2_18 Vdout2_18ck11 = 0 time = 240
.meas tran vdout2_18ck11 FIND v(dout2_18) AT=240.1n

* CHECK dout2_19 Vdout2_19ck11 = 0 time = 240
.meas tran vdout2_19ck11 FIND v(dout2_19) AT=240.1n

* CHECK dout2_20 Vdout2_20ck11 = 0 time = 240
.meas tran vdout2_20ck11 FIND v(dout2_20) AT=240.1n

* CHECK dout2_21 Vdout2_21ck11 = 0 time = 240
.meas tran vdout2_21ck11 FIND v(dout2_21) AT=240.1n

* CHECK dout2_22 Vdout2_22ck11 = 1.8 time = 240
.meas tran vdout2_22ck11 FIND v(dout2_22) AT=240.1n

* CHECK dout2_23 Vdout2_23ck11 = 1.8 time = 240
.meas tran vdout2_23ck11 FIND v(dout2_23) AT=240.1n

* CHECK dout2_24 Vdout2_24ck11 = 0 time = 240
.meas tran vdout2_24ck11 FIND v(dout2_24) AT=240.1n

* CHECK dout2_25 Vdout2_25ck11 = 1.8 time = 240
.meas tran vdout2_25ck11 FIND v(dout2_25) AT=240.1n

* CHECK dout2_26 Vdout2_26ck11 = 1.8 time = 240
.meas tran vdout2_26ck11 FIND v(dout2_26) AT=240.1n

* CHECK dout2_27 Vdout2_27ck11 = 1.8 time = 240
.meas tran vdout2_27ck11 FIND v(dout2_27) AT=240.1n

* CHECK dout2_28 Vdout2_28ck11 = 0 time = 240
.meas tran vdout2_28ck11 FIND v(dout2_28) AT=240.1n

* CHECK dout2_29 Vdout2_29ck11 = 0 time = 240
.meas tran vdout2_29ck11 FIND v(dout2_29) AT=240.1n

* CHECK dout2_30 Vdout2_30ck11 = 1.8 time = 240
.meas tran vdout2_30ck11 FIND v(dout2_30) AT=240.1n

* CHECK dout2_31 Vdout2_31ck11 = 1.8 time = 240
.meas tran vdout2_31ck11 FIND v(dout2_31) AT=240.1n

* CHECK dout1_0 Vdout1_0ck12 = 1.8 time = 260
.meas tran vdout1_0ck12 FIND v(dout1_0) AT=260.1n

* CHECK dout1_1 Vdout1_1ck12 = 0 time = 260
.meas tran vdout1_1ck12 FIND v(dout1_1) AT=260.1n

* CHECK dout1_2 Vdout1_2ck12 = 1.8 time = 260
.meas tran vdout1_2ck12 FIND v(dout1_2) AT=260.1n

* CHECK dout1_3 Vdout1_3ck12 = 0 time = 260
.meas tran vdout1_3ck12 FIND v(dout1_3) AT=260.1n

* CHECK dout1_4 Vdout1_4ck12 = 0 time = 260
.meas tran vdout1_4ck12 FIND v(dout1_4) AT=260.1n

* CHECK dout1_5 Vdout1_5ck12 = 1.8 time = 260
.meas tran vdout1_5ck12 FIND v(dout1_5) AT=260.1n

* CHECK dout1_6 Vdout1_6ck12 = 0 time = 260
.meas tran vdout1_6ck12 FIND v(dout1_6) AT=260.1n

* CHECK dout1_7 Vdout1_7ck12 = 0 time = 260
.meas tran vdout1_7ck12 FIND v(dout1_7) AT=260.1n

* CHECK dout1_8 Vdout1_8ck12 = 1.8 time = 260
.meas tran vdout1_8ck12 FIND v(dout1_8) AT=260.1n

* CHECK dout1_9 Vdout1_9ck12 = 0 time = 260
.meas tran vdout1_9ck12 FIND v(dout1_9) AT=260.1n

* CHECK dout1_10 Vdout1_10ck12 = 0 time = 260
.meas tran vdout1_10ck12 FIND v(dout1_10) AT=260.1n

* CHECK dout1_11 Vdout1_11ck12 = 1.8 time = 260
.meas tran vdout1_11ck12 FIND v(dout1_11) AT=260.1n

* CHECK dout1_12 Vdout1_12ck12 = 1.8 time = 260
.meas tran vdout1_12ck12 FIND v(dout1_12) AT=260.1n

* CHECK dout1_13 Vdout1_13ck12 = 1.8 time = 260
.meas tran vdout1_13ck12 FIND v(dout1_13) AT=260.1n

* CHECK dout1_14 Vdout1_14ck12 = 0 time = 260
.meas tran vdout1_14ck12 FIND v(dout1_14) AT=260.1n

* CHECK dout1_15 Vdout1_15ck12 = 0 time = 260
.meas tran vdout1_15ck12 FIND v(dout1_15) AT=260.1n

* CHECK dout1_16 Vdout1_16ck12 = 0 time = 260
.meas tran vdout1_16ck12 FIND v(dout1_16) AT=260.1n

* CHECK dout1_17 Vdout1_17ck12 = 1.8 time = 260
.meas tran vdout1_17ck12 FIND v(dout1_17) AT=260.1n

* CHECK dout1_18 Vdout1_18ck12 = 0 time = 260
.meas tran vdout1_18ck12 FIND v(dout1_18) AT=260.1n

* CHECK dout1_19 Vdout1_19ck12 = 0 time = 260
.meas tran vdout1_19ck12 FIND v(dout1_19) AT=260.1n

* CHECK dout1_20 Vdout1_20ck12 = 0 time = 260
.meas tran vdout1_20ck12 FIND v(dout1_20) AT=260.1n

* CHECK dout1_21 Vdout1_21ck12 = 1.8 time = 260
.meas tran vdout1_21ck12 FIND v(dout1_21) AT=260.1n

* CHECK dout1_22 Vdout1_22ck12 = 0 time = 260
.meas tran vdout1_22ck12 FIND v(dout1_22) AT=260.1n

* CHECK dout1_23 Vdout1_23ck12 = 1.8 time = 260
.meas tran vdout1_23ck12 FIND v(dout1_23) AT=260.1n

* CHECK dout1_24 Vdout1_24ck12 = 0 time = 260
.meas tran vdout1_24ck12 FIND v(dout1_24) AT=260.1n

* CHECK dout1_25 Vdout1_25ck12 = 0 time = 260
.meas tran vdout1_25ck12 FIND v(dout1_25) AT=260.1n

* CHECK dout1_26 Vdout1_26ck12 = 1.8 time = 260
.meas tran vdout1_26ck12 FIND v(dout1_26) AT=260.1n

* CHECK dout1_27 Vdout1_27ck12 = 1.8 time = 260
.meas tran vdout1_27ck12 FIND v(dout1_27) AT=260.1n

* CHECK dout1_28 Vdout1_28ck12 = 1.8 time = 260
.meas tran vdout1_28ck12 FIND v(dout1_28) AT=260.1n

* CHECK dout1_29 Vdout1_29ck12 = 0 time = 260
.meas tran vdout1_29ck12 FIND v(dout1_29) AT=260.1n

* CHECK dout1_30 Vdout1_30ck12 = 0 time = 260
.meas tran vdout1_30ck12 FIND v(dout1_30) AT=260.1n

* CHECK dout1_31 Vdout1_31ck12 = 0 time = 260
.meas tran vdout1_31ck12 FIND v(dout1_31) AT=260.1n

* CHECK dout2_0 Vdout2_0ck12 = 1.8 time = 260
.meas tran vdout2_0ck12 FIND v(dout2_0) AT=260.1n

* CHECK dout2_1 Vdout2_1ck12 = 0 time = 260
.meas tran vdout2_1ck12 FIND v(dout2_1) AT=260.1n

* CHECK dout2_2 Vdout2_2ck12 = 0 time = 260
.meas tran vdout2_2ck12 FIND v(dout2_2) AT=260.1n

* CHECK dout2_3 Vdout2_3ck12 = 1.8 time = 260
.meas tran vdout2_3ck12 FIND v(dout2_3) AT=260.1n

* CHECK dout2_4 Vdout2_4ck12 = 0 time = 260
.meas tran vdout2_4ck12 FIND v(dout2_4) AT=260.1n

* CHECK dout2_5 Vdout2_5ck12 = 1.8 time = 260
.meas tran vdout2_5ck12 FIND v(dout2_5) AT=260.1n

* CHECK dout2_6 Vdout2_6ck12 = 1.8 time = 260
.meas tran vdout2_6ck12 FIND v(dout2_6) AT=260.1n

* CHECK dout2_7 Vdout2_7ck12 = 1.8 time = 260
.meas tran vdout2_7ck12 FIND v(dout2_7) AT=260.1n

* CHECK dout2_8 Vdout2_8ck12 = 0 time = 260
.meas tran vdout2_8ck12 FIND v(dout2_8) AT=260.1n

* CHECK dout2_9 Vdout2_9ck12 = 0 time = 260
.meas tran vdout2_9ck12 FIND v(dout2_9) AT=260.1n

* CHECK dout2_10 Vdout2_10ck12 = 0 time = 260
.meas tran vdout2_10ck12 FIND v(dout2_10) AT=260.1n

* CHECK dout2_11 Vdout2_11ck12 = 0 time = 260
.meas tran vdout2_11ck12 FIND v(dout2_11) AT=260.1n

* CHECK dout2_12 Vdout2_12ck12 = 1.8 time = 260
.meas tran vdout2_12ck12 FIND v(dout2_12) AT=260.1n

* CHECK dout2_13 Vdout2_13ck12 = 0 time = 260
.meas tran vdout2_13ck12 FIND v(dout2_13) AT=260.1n

* CHECK dout2_14 Vdout2_14ck12 = 1.8 time = 260
.meas tran vdout2_14ck12 FIND v(dout2_14) AT=260.1n

* CHECK dout2_15 Vdout2_15ck12 = 0 time = 260
.meas tran vdout2_15ck12 FIND v(dout2_15) AT=260.1n

* CHECK dout2_16 Vdout2_16ck12 = 0 time = 260
.meas tran vdout2_16ck12 FIND v(dout2_16) AT=260.1n

* CHECK dout2_17 Vdout2_17ck12 = 0 time = 260
.meas tran vdout2_17ck12 FIND v(dout2_17) AT=260.1n

* CHECK dout2_18 Vdout2_18ck12 = 0 time = 260
.meas tran vdout2_18ck12 FIND v(dout2_18) AT=260.1n

* CHECK dout2_19 Vdout2_19ck12 = 1.8 time = 260
.meas tran vdout2_19ck12 FIND v(dout2_19) AT=260.1n

* CHECK dout2_20 Vdout2_20ck12 = 1.8 time = 260
.meas tran vdout2_20ck12 FIND v(dout2_20) AT=260.1n

* CHECK dout2_21 Vdout2_21ck12 = 1.8 time = 260
.meas tran vdout2_21ck12 FIND v(dout2_21) AT=260.1n

* CHECK dout2_22 Vdout2_22ck12 = 0 time = 260
.meas tran vdout2_22ck12 FIND v(dout2_22) AT=260.1n

* CHECK dout2_23 Vdout2_23ck12 = 1.8 time = 260
.meas tran vdout2_23ck12 FIND v(dout2_23) AT=260.1n

* CHECK dout2_24 Vdout2_24ck12 = 0 time = 260
.meas tran vdout2_24ck12 FIND v(dout2_24) AT=260.1n

* CHECK dout2_25 Vdout2_25ck12 = 0 time = 260
.meas tran vdout2_25ck12 FIND v(dout2_25) AT=260.1n

* CHECK dout2_26 Vdout2_26ck12 = 1.8 time = 260
.meas tran vdout2_26ck12 FIND v(dout2_26) AT=260.1n

* CHECK dout2_27 Vdout2_27ck12 = 0 time = 260
.meas tran vdout2_27ck12 FIND v(dout2_27) AT=260.1n

* CHECK dout2_28 Vdout2_28ck12 = 1.8 time = 260
.meas tran vdout2_28ck12 FIND v(dout2_28) AT=260.1n

* CHECK dout2_29 Vdout2_29ck12 = 0 time = 260
.meas tran vdout2_29ck12 FIND v(dout2_29) AT=260.1n

* CHECK dout2_30 Vdout2_30ck12 = 0 time = 260
.meas tran vdout2_30ck12 FIND v(dout2_30) AT=260.1n

* CHECK dout2_31 Vdout2_31ck12 = 1.8 time = 260
.meas tran vdout2_31ck12 FIND v(dout2_31) AT=260.1n

* CHECK dout1_0 Vdout1_0ck14 = 0 time = 300
.meas tran vdout1_0ck14 FIND v(dout1_0) AT=300.1n

* CHECK dout1_1 Vdout1_1ck14 = 0 time = 300
.meas tran vdout1_1ck14 FIND v(dout1_1) AT=300.1n

* CHECK dout1_2 Vdout1_2ck14 = 1.8 time = 300
.meas tran vdout1_2ck14 FIND v(dout1_2) AT=300.1n

* CHECK dout1_3 Vdout1_3ck14 = 0 time = 300
.meas tran vdout1_3ck14 FIND v(dout1_3) AT=300.1n

* CHECK dout1_4 Vdout1_4ck14 = 0 time = 300
.meas tran vdout1_4ck14 FIND v(dout1_4) AT=300.1n

* CHECK dout1_5 Vdout1_5ck14 = 1.8 time = 300
.meas tran vdout1_5ck14 FIND v(dout1_5) AT=300.1n

* CHECK dout1_6 Vdout1_6ck14 = 1.8 time = 300
.meas tran vdout1_6ck14 FIND v(dout1_6) AT=300.1n

* CHECK dout1_7 Vdout1_7ck14 = 0 time = 300
.meas tran vdout1_7ck14 FIND v(dout1_7) AT=300.1n

* CHECK dout1_8 Vdout1_8ck14 = 1.8 time = 300
.meas tran vdout1_8ck14 FIND v(dout1_8) AT=300.1n

* CHECK dout1_9 Vdout1_9ck14 = 1.8 time = 300
.meas tran vdout1_9ck14 FIND v(dout1_9) AT=300.1n

* CHECK dout1_10 Vdout1_10ck14 = 1.8 time = 300
.meas tran vdout1_10ck14 FIND v(dout1_10) AT=300.1n

* CHECK dout1_11 Vdout1_11ck14 = 1.8 time = 300
.meas tran vdout1_11ck14 FIND v(dout1_11) AT=300.1n

* CHECK dout1_12 Vdout1_12ck14 = 1.8 time = 300
.meas tran vdout1_12ck14 FIND v(dout1_12) AT=300.1n

* CHECK dout1_13 Vdout1_13ck14 = 1.8 time = 300
.meas tran vdout1_13ck14 FIND v(dout1_13) AT=300.1n

* CHECK dout1_14 Vdout1_14ck14 = 1.8 time = 300
.meas tran vdout1_14ck14 FIND v(dout1_14) AT=300.1n

* CHECK dout1_15 Vdout1_15ck14 = 1.8 time = 300
.meas tran vdout1_15ck14 FIND v(dout1_15) AT=300.1n

* CHECK dout1_16 Vdout1_16ck14 = 0 time = 300
.meas tran vdout1_16ck14 FIND v(dout1_16) AT=300.1n

* CHECK dout1_17 Vdout1_17ck14 = 0 time = 300
.meas tran vdout1_17ck14 FIND v(dout1_17) AT=300.1n

* CHECK dout1_18 Vdout1_18ck14 = 1.8 time = 300
.meas tran vdout1_18ck14 FIND v(dout1_18) AT=300.1n

* CHECK dout1_19 Vdout1_19ck14 = 1.8 time = 300
.meas tran vdout1_19ck14 FIND v(dout1_19) AT=300.1n

* CHECK dout1_20 Vdout1_20ck14 = 0 time = 300
.meas tran vdout1_20ck14 FIND v(dout1_20) AT=300.1n

* CHECK dout1_21 Vdout1_21ck14 = 0 time = 300
.meas tran vdout1_21ck14 FIND v(dout1_21) AT=300.1n

* CHECK dout1_22 Vdout1_22ck14 = 1.8 time = 300
.meas tran vdout1_22ck14 FIND v(dout1_22) AT=300.1n

* CHECK dout1_23 Vdout1_23ck14 = 1.8 time = 300
.meas tran vdout1_23ck14 FIND v(dout1_23) AT=300.1n

* CHECK dout1_24 Vdout1_24ck14 = 0 time = 300
.meas tran vdout1_24ck14 FIND v(dout1_24) AT=300.1n

* CHECK dout1_25 Vdout1_25ck14 = 1.8 time = 300
.meas tran vdout1_25ck14 FIND v(dout1_25) AT=300.1n

* CHECK dout1_26 Vdout1_26ck14 = 1.8 time = 300
.meas tran vdout1_26ck14 FIND v(dout1_26) AT=300.1n

* CHECK dout1_27 Vdout1_27ck14 = 1.8 time = 300
.meas tran vdout1_27ck14 FIND v(dout1_27) AT=300.1n

* CHECK dout1_28 Vdout1_28ck14 = 0 time = 300
.meas tran vdout1_28ck14 FIND v(dout1_28) AT=300.1n

* CHECK dout1_29 Vdout1_29ck14 = 1.8 time = 300
.meas tran vdout1_29ck14 FIND v(dout1_29) AT=300.1n

* CHECK dout1_30 Vdout1_30ck14 = 0 time = 300
.meas tran vdout1_30ck14 FIND v(dout1_30) AT=300.1n

* CHECK dout1_31 Vdout1_31ck14 = 1.8 time = 300
.meas tran vdout1_31ck14 FIND v(dout1_31) AT=300.1n

* CHECK dout2_0 Vdout2_0ck14 = 0 time = 300
.meas tran vdout2_0ck14 FIND v(dout2_0) AT=300.1n

* CHECK dout2_1 Vdout2_1ck14 = 0 time = 300
.meas tran vdout2_1ck14 FIND v(dout2_1) AT=300.1n

* CHECK dout2_2 Vdout2_2ck14 = 1.8 time = 300
.meas tran vdout2_2ck14 FIND v(dout2_2) AT=300.1n

* CHECK dout2_3 Vdout2_3ck14 = 0 time = 300
.meas tran vdout2_3ck14 FIND v(dout2_3) AT=300.1n

* CHECK dout2_4 Vdout2_4ck14 = 0 time = 300
.meas tran vdout2_4ck14 FIND v(dout2_4) AT=300.1n

* CHECK dout2_5 Vdout2_5ck14 = 1.8 time = 300
.meas tran vdout2_5ck14 FIND v(dout2_5) AT=300.1n

* CHECK dout2_6 Vdout2_6ck14 = 1.8 time = 300
.meas tran vdout2_6ck14 FIND v(dout2_6) AT=300.1n

* CHECK dout2_7 Vdout2_7ck14 = 0 time = 300
.meas tran vdout2_7ck14 FIND v(dout2_7) AT=300.1n

* CHECK dout2_8 Vdout2_8ck14 = 1.8 time = 300
.meas tran vdout2_8ck14 FIND v(dout2_8) AT=300.1n

* CHECK dout2_9 Vdout2_9ck14 = 1.8 time = 300
.meas tran vdout2_9ck14 FIND v(dout2_9) AT=300.1n

* CHECK dout2_10 Vdout2_10ck14 = 1.8 time = 300
.meas tran vdout2_10ck14 FIND v(dout2_10) AT=300.1n

* CHECK dout2_11 Vdout2_11ck14 = 1.8 time = 300
.meas tran vdout2_11ck14 FIND v(dout2_11) AT=300.1n

* CHECK dout2_12 Vdout2_12ck14 = 1.8 time = 300
.meas tran vdout2_12ck14 FIND v(dout2_12) AT=300.1n

* CHECK dout2_13 Vdout2_13ck14 = 1.8 time = 300
.meas tran vdout2_13ck14 FIND v(dout2_13) AT=300.1n

* CHECK dout2_14 Vdout2_14ck14 = 1.8 time = 300
.meas tran vdout2_14ck14 FIND v(dout2_14) AT=300.1n

* CHECK dout2_15 Vdout2_15ck14 = 1.8 time = 300
.meas tran vdout2_15ck14 FIND v(dout2_15) AT=300.1n

* CHECK dout2_16 Vdout2_16ck14 = 0 time = 300
.meas tran vdout2_16ck14 FIND v(dout2_16) AT=300.1n

* CHECK dout2_17 Vdout2_17ck14 = 0 time = 300
.meas tran vdout2_17ck14 FIND v(dout2_17) AT=300.1n

* CHECK dout2_18 Vdout2_18ck14 = 1.8 time = 300
.meas tran vdout2_18ck14 FIND v(dout2_18) AT=300.1n

* CHECK dout2_19 Vdout2_19ck14 = 1.8 time = 300
.meas tran vdout2_19ck14 FIND v(dout2_19) AT=300.1n

* CHECK dout2_20 Vdout2_20ck14 = 0 time = 300
.meas tran vdout2_20ck14 FIND v(dout2_20) AT=300.1n

* CHECK dout2_21 Vdout2_21ck14 = 0 time = 300
.meas tran vdout2_21ck14 FIND v(dout2_21) AT=300.1n

* CHECK dout2_22 Vdout2_22ck14 = 1.8 time = 300
.meas tran vdout2_22ck14 FIND v(dout2_22) AT=300.1n

* CHECK dout2_23 Vdout2_23ck14 = 1.8 time = 300
.meas tran vdout2_23ck14 FIND v(dout2_23) AT=300.1n

* CHECK dout2_24 Vdout2_24ck14 = 0 time = 300
.meas tran vdout2_24ck14 FIND v(dout2_24) AT=300.1n

* CHECK dout2_25 Vdout2_25ck14 = 1.8 time = 300
.meas tran vdout2_25ck14 FIND v(dout2_25) AT=300.1n

* CHECK dout2_26 Vdout2_26ck14 = 1.8 time = 300
.meas tran vdout2_26ck14 FIND v(dout2_26) AT=300.1n

* CHECK dout2_27 Vdout2_27ck14 = 1.8 time = 300
.meas tran vdout2_27ck14 FIND v(dout2_27) AT=300.1n

* CHECK dout2_28 Vdout2_28ck14 = 0 time = 300
.meas tran vdout2_28ck14 FIND v(dout2_28) AT=300.1n

* CHECK dout2_29 Vdout2_29ck14 = 1.8 time = 300
.meas tran vdout2_29ck14 FIND v(dout2_29) AT=300.1n

* CHECK dout2_30 Vdout2_30ck14 = 0 time = 300
.meas tran vdout2_30ck14 FIND v(dout2_30) AT=300.1n

* CHECK dout2_31 Vdout2_31ck14 = 1.8 time = 300
.meas tran vdout2_31ck14 FIND v(dout2_31) AT=300.1n

* CHECK dout2_0 Vdout2_0ck15 = 0 time = 320
.meas tran vdout2_0ck15 FIND v(dout2_0) AT=320.1n

* CHECK dout2_1 Vdout2_1ck15 = 1.8 time = 320
.meas tran vdout2_1ck15 FIND v(dout2_1) AT=320.1n

* CHECK dout2_2 Vdout2_2ck15 = 0 time = 320
.meas tran vdout2_2ck15 FIND v(dout2_2) AT=320.1n

* CHECK dout2_3 Vdout2_3ck15 = 1.8 time = 320
.meas tran vdout2_3ck15 FIND v(dout2_3) AT=320.1n

* CHECK dout2_4 Vdout2_4ck15 = 0 time = 320
.meas tran vdout2_4ck15 FIND v(dout2_4) AT=320.1n

* CHECK dout2_5 Vdout2_5ck15 = 1.8 time = 320
.meas tran vdout2_5ck15 FIND v(dout2_5) AT=320.1n

* CHECK dout2_6 Vdout2_6ck15 = 0 time = 320
.meas tran vdout2_6ck15 FIND v(dout2_6) AT=320.1n

* CHECK dout2_7 Vdout2_7ck15 = 0 time = 320
.meas tran vdout2_7ck15 FIND v(dout2_7) AT=320.1n

* CHECK dout2_8 Vdout2_8ck15 = 0 time = 320
.meas tran vdout2_8ck15 FIND v(dout2_8) AT=320.1n

* CHECK dout2_9 Vdout2_9ck15 = 1.8 time = 320
.meas tran vdout2_9ck15 FIND v(dout2_9) AT=320.1n

* CHECK dout2_10 Vdout2_10ck15 = 1.8 time = 320
.meas tran vdout2_10ck15 FIND v(dout2_10) AT=320.1n

* CHECK dout2_11 Vdout2_11ck15 = 1.8 time = 320
.meas tran vdout2_11ck15 FIND v(dout2_11) AT=320.1n

* CHECK dout2_12 Vdout2_12ck15 = 0 time = 320
.meas tran vdout2_12ck15 FIND v(dout2_12) AT=320.1n

* CHECK dout2_13 Vdout2_13ck15 = 0 time = 320
.meas tran vdout2_13ck15 FIND v(dout2_13) AT=320.1n

* CHECK dout2_14 Vdout2_14ck15 = 0 time = 320
.meas tran vdout2_14ck15 FIND v(dout2_14) AT=320.1n

* CHECK dout2_15 Vdout2_15ck15 = 1.8 time = 320
.meas tran vdout2_15ck15 FIND v(dout2_15) AT=320.1n

* CHECK dout2_16 Vdout2_16ck15 = 0 time = 320
.meas tran vdout2_16ck15 FIND v(dout2_16) AT=320.1n

* CHECK dout2_17 Vdout2_17ck15 = 1.8 time = 320
.meas tran vdout2_17ck15 FIND v(dout2_17) AT=320.1n

* CHECK dout2_18 Vdout2_18ck15 = 0 time = 320
.meas tran vdout2_18ck15 FIND v(dout2_18) AT=320.1n

* CHECK dout2_19 Vdout2_19ck15 = 0 time = 320
.meas tran vdout2_19ck15 FIND v(dout2_19) AT=320.1n

* CHECK dout2_20 Vdout2_20ck15 = 0 time = 320
.meas tran vdout2_20ck15 FIND v(dout2_20) AT=320.1n

* CHECK dout2_21 Vdout2_21ck15 = 0 time = 320
.meas tran vdout2_21ck15 FIND v(dout2_21) AT=320.1n

* CHECK dout2_22 Vdout2_22ck15 = 1.8 time = 320
.meas tran vdout2_22ck15 FIND v(dout2_22) AT=320.1n

* CHECK dout2_23 Vdout2_23ck15 = 1.8 time = 320
.meas tran vdout2_23ck15 FIND v(dout2_23) AT=320.1n

* CHECK dout2_24 Vdout2_24ck15 = 0 time = 320
.meas tran vdout2_24ck15 FIND v(dout2_24) AT=320.1n

* CHECK dout2_25 Vdout2_25ck15 = 1.8 time = 320
.meas tran vdout2_25ck15 FIND v(dout2_25) AT=320.1n

* CHECK dout2_26 Vdout2_26ck15 = 1.8 time = 320
.meas tran vdout2_26ck15 FIND v(dout2_26) AT=320.1n

* CHECK dout2_27 Vdout2_27ck15 = 1.8 time = 320
.meas tran vdout2_27ck15 FIND v(dout2_27) AT=320.1n

* CHECK dout2_28 Vdout2_28ck15 = 0 time = 320
.meas tran vdout2_28ck15 FIND v(dout2_28) AT=320.1n

* CHECK dout2_29 Vdout2_29ck15 = 0 time = 320
.meas tran vdout2_29ck15 FIND v(dout2_29) AT=320.1n

* CHECK dout2_30 Vdout2_30ck15 = 1.8 time = 320
.meas tran vdout2_30ck15 FIND v(dout2_30) AT=320.1n

* CHECK dout2_31 Vdout2_31ck15 = 1.8 time = 320
.meas tran vdout2_31ck15 FIND v(dout2_31) AT=320.1n

* CHECK dout1_0 Vdout1_0ck16 = 1.8 time = 340
.meas tran vdout1_0ck16 FIND v(dout1_0) AT=340.1n

* CHECK dout1_1 Vdout1_1ck16 = 1.8 time = 340
.meas tran vdout1_1ck16 FIND v(dout1_1) AT=340.1n

* CHECK dout1_2 Vdout1_2ck16 = 0 time = 340
.meas tran vdout1_2ck16 FIND v(dout1_2) AT=340.1n

* CHECK dout1_3 Vdout1_3ck16 = 1.8 time = 340
.meas tran vdout1_3ck16 FIND v(dout1_3) AT=340.1n

* CHECK dout1_4 Vdout1_4ck16 = 0 time = 340
.meas tran vdout1_4ck16 FIND v(dout1_4) AT=340.1n

* CHECK dout1_5 Vdout1_5ck16 = 1.8 time = 340
.meas tran vdout1_5ck16 FIND v(dout1_5) AT=340.1n

* CHECK dout1_6 Vdout1_6ck16 = 1.8 time = 340
.meas tran vdout1_6ck16 FIND v(dout1_6) AT=340.1n

* CHECK dout1_7 Vdout1_7ck16 = 1.8 time = 340
.meas tran vdout1_7ck16 FIND v(dout1_7) AT=340.1n

* CHECK dout1_8 Vdout1_8ck16 = 0 time = 340
.meas tran vdout1_8ck16 FIND v(dout1_8) AT=340.1n

* CHECK dout1_9 Vdout1_9ck16 = 0 time = 340
.meas tran vdout1_9ck16 FIND v(dout1_9) AT=340.1n

* CHECK dout1_10 Vdout1_10ck16 = 0 time = 340
.meas tran vdout1_10ck16 FIND v(dout1_10) AT=340.1n

* CHECK dout1_11 Vdout1_11ck16 = 0 time = 340
.meas tran vdout1_11ck16 FIND v(dout1_11) AT=340.1n

* CHECK dout1_12 Vdout1_12ck16 = 0 time = 340
.meas tran vdout1_12ck16 FIND v(dout1_12) AT=340.1n

* CHECK dout1_13 Vdout1_13ck16 = 1.8 time = 340
.meas tran vdout1_13ck16 FIND v(dout1_13) AT=340.1n

* CHECK dout1_14 Vdout1_14ck16 = 0 time = 340
.meas tran vdout1_14ck16 FIND v(dout1_14) AT=340.1n

* CHECK dout1_15 Vdout1_15ck16 = 1.8 time = 340
.meas tran vdout1_15ck16 FIND v(dout1_15) AT=340.1n

* CHECK dout1_16 Vdout1_16ck16 = 0 time = 340
.meas tran vdout1_16ck16 FIND v(dout1_16) AT=340.1n

* CHECK dout1_17 Vdout1_17ck16 = 1.8 time = 340
.meas tran vdout1_17ck16 FIND v(dout1_17) AT=340.1n

* CHECK dout1_18 Vdout1_18ck16 = 1.8 time = 340
.meas tran vdout1_18ck16 FIND v(dout1_18) AT=340.1n

* CHECK dout1_19 Vdout1_19ck16 = 0 time = 340
.meas tran vdout1_19ck16 FIND v(dout1_19) AT=340.1n

* CHECK dout1_20 Vdout1_20ck16 = 1.8 time = 340
.meas tran vdout1_20ck16 FIND v(dout1_20) AT=340.1n

* CHECK dout1_21 Vdout1_21ck16 = 1.8 time = 340
.meas tran vdout1_21ck16 FIND v(dout1_21) AT=340.1n

* CHECK dout1_22 Vdout1_22ck16 = 0 time = 340
.meas tran vdout1_22ck16 FIND v(dout1_22) AT=340.1n

* CHECK dout1_23 Vdout1_23ck16 = 0 time = 340
.meas tran vdout1_23ck16 FIND v(dout1_23) AT=340.1n

* CHECK dout1_24 Vdout1_24ck16 = 0 time = 340
.meas tran vdout1_24ck16 FIND v(dout1_24) AT=340.1n

* CHECK dout1_25 Vdout1_25ck16 = 0 time = 340
.meas tran vdout1_25ck16 FIND v(dout1_25) AT=340.1n

* CHECK dout1_26 Vdout1_26ck16 = 0 time = 340
.meas tran vdout1_26ck16 FIND v(dout1_26) AT=340.1n

* CHECK dout1_27 Vdout1_27ck16 = 1.8 time = 340
.meas tran vdout1_27ck16 FIND v(dout1_27) AT=340.1n

* CHECK dout1_28 Vdout1_28ck16 = 1.8 time = 340
.meas tran vdout1_28ck16 FIND v(dout1_28) AT=340.1n

* CHECK dout1_29 Vdout1_29ck16 = 1.8 time = 340
.meas tran vdout1_29ck16 FIND v(dout1_29) AT=340.1n

* CHECK dout1_30 Vdout1_30ck16 = 0 time = 340
.meas tran vdout1_30ck16 FIND v(dout1_30) AT=340.1n

* CHECK dout1_31 Vdout1_31ck16 = 0 time = 340
.meas tran vdout1_31ck16 FIND v(dout1_31) AT=340.1n

* CHECK dout1_0 Vdout1_0ck17 = 0 time = 360
.meas tran vdout1_0ck17 FIND v(dout1_0) AT=360.1n

* CHECK dout1_1 Vdout1_1ck17 = 0 time = 360
.meas tran vdout1_1ck17 FIND v(dout1_1) AT=360.1n

* CHECK dout1_2 Vdout1_2ck17 = 0 time = 360
.meas tran vdout1_2ck17 FIND v(dout1_2) AT=360.1n

* CHECK dout1_3 Vdout1_3ck17 = 1.8 time = 360
.meas tran vdout1_3ck17 FIND v(dout1_3) AT=360.1n

* CHECK dout1_4 Vdout1_4ck17 = 0 time = 360
.meas tran vdout1_4ck17 FIND v(dout1_4) AT=360.1n

* CHECK dout1_5 Vdout1_5ck17 = 1.8 time = 360
.meas tran vdout1_5ck17 FIND v(dout1_5) AT=360.1n

* CHECK dout1_6 Vdout1_6ck17 = 1.8 time = 360
.meas tran vdout1_6ck17 FIND v(dout1_6) AT=360.1n

* CHECK dout1_7 Vdout1_7ck17 = 1.8 time = 360
.meas tran vdout1_7ck17 FIND v(dout1_7) AT=360.1n

* CHECK dout1_8 Vdout1_8ck17 = 0 time = 360
.meas tran vdout1_8ck17 FIND v(dout1_8) AT=360.1n

* CHECK dout1_9 Vdout1_9ck17 = 0 time = 360
.meas tran vdout1_9ck17 FIND v(dout1_9) AT=360.1n

* CHECK dout1_10 Vdout1_10ck17 = 1.8 time = 360
.meas tran vdout1_10ck17 FIND v(dout1_10) AT=360.1n

* CHECK dout1_11 Vdout1_11ck17 = 0 time = 360
.meas tran vdout1_11ck17 FIND v(dout1_11) AT=360.1n

* CHECK dout1_12 Vdout1_12ck17 = 0 time = 360
.meas tran vdout1_12ck17 FIND v(dout1_12) AT=360.1n

* CHECK dout1_13 Vdout1_13ck17 = 0 time = 360
.meas tran vdout1_13ck17 FIND v(dout1_13) AT=360.1n

* CHECK dout1_14 Vdout1_14ck17 = 1.8 time = 360
.meas tran vdout1_14ck17 FIND v(dout1_14) AT=360.1n

* CHECK dout1_15 Vdout1_15ck17 = 1.8 time = 360
.meas tran vdout1_15ck17 FIND v(dout1_15) AT=360.1n

* CHECK dout1_16 Vdout1_16ck17 = 0 time = 360
.meas tran vdout1_16ck17 FIND v(dout1_16) AT=360.1n

* CHECK dout1_17 Vdout1_17ck17 = 1.8 time = 360
.meas tran vdout1_17ck17 FIND v(dout1_17) AT=360.1n

* CHECK dout1_18 Vdout1_18ck17 = 1.8 time = 360
.meas tran vdout1_18ck17 FIND v(dout1_18) AT=360.1n

* CHECK dout1_19 Vdout1_19ck17 = 0 time = 360
.meas tran vdout1_19ck17 FIND v(dout1_19) AT=360.1n

* CHECK dout1_20 Vdout1_20ck17 = 1.8 time = 360
.meas tran vdout1_20ck17 FIND v(dout1_20) AT=360.1n

* CHECK dout1_21 Vdout1_21ck17 = 0 time = 360
.meas tran vdout1_21ck17 FIND v(dout1_21) AT=360.1n

* CHECK dout1_22 Vdout1_22ck17 = 1.8 time = 360
.meas tran vdout1_22ck17 FIND v(dout1_22) AT=360.1n

* CHECK dout1_23 Vdout1_23ck17 = 1.8 time = 360
.meas tran vdout1_23ck17 FIND v(dout1_23) AT=360.1n

* CHECK dout1_24 Vdout1_24ck17 = 1.8 time = 360
.meas tran vdout1_24ck17 FIND v(dout1_24) AT=360.1n

* CHECK dout1_25 Vdout1_25ck17 = 1.8 time = 360
.meas tran vdout1_25ck17 FIND v(dout1_25) AT=360.1n

* CHECK dout1_26 Vdout1_26ck17 = 1.8 time = 360
.meas tran vdout1_26ck17 FIND v(dout1_26) AT=360.1n

* CHECK dout1_27 Vdout1_27ck17 = 1.8 time = 360
.meas tran vdout1_27ck17 FIND v(dout1_27) AT=360.1n

* CHECK dout1_28 Vdout1_28ck17 = 0 time = 360
.meas tran vdout1_28ck17 FIND v(dout1_28) AT=360.1n

* CHECK dout1_29 Vdout1_29ck17 = 1.8 time = 360
.meas tran vdout1_29ck17 FIND v(dout1_29) AT=360.1n

* CHECK dout1_30 Vdout1_30ck17 = 0 time = 360
.meas tran vdout1_30ck17 FIND v(dout1_30) AT=360.1n

* CHECK dout1_31 Vdout1_31ck17 = 0 time = 360
.meas tran vdout1_31ck17 FIND v(dout1_31) AT=360.1n

* CHECK dout2_0 Vdout2_0ck17 = 1.8 time = 360
.meas tran vdout2_0ck17 FIND v(dout2_0) AT=360.1n

* CHECK dout2_1 Vdout2_1ck17 = 1.8 time = 360
.meas tran vdout2_1ck17 FIND v(dout2_1) AT=360.1n

* CHECK dout2_2 Vdout2_2ck17 = 0 time = 360
.meas tran vdout2_2ck17 FIND v(dout2_2) AT=360.1n

* CHECK dout2_3 Vdout2_3ck17 = 1.8 time = 360
.meas tran vdout2_3ck17 FIND v(dout2_3) AT=360.1n

* CHECK dout2_4 Vdout2_4ck17 = 0 time = 360
.meas tran vdout2_4ck17 FIND v(dout2_4) AT=360.1n

* CHECK dout2_5 Vdout2_5ck17 = 1.8 time = 360
.meas tran vdout2_5ck17 FIND v(dout2_5) AT=360.1n

* CHECK dout2_6 Vdout2_6ck17 = 1.8 time = 360
.meas tran vdout2_6ck17 FIND v(dout2_6) AT=360.1n

* CHECK dout2_7 Vdout2_7ck17 = 1.8 time = 360
.meas tran vdout2_7ck17 FIND v(dout2_7) AT=360.1n

* CHECK dout2_8 Vdout2_8ck17 = 0 time = 360
.meas tran vdout2_8ck17 FIND v(dout2_8) AT=360.1n

* CHECK dout2_9 Vdout2_9ck17 = 0 time = 360
.meas tran vdout2_9ck17 FIND v(dout2_9) AT=360.1n

* CHECK dout2_10 Vdout2_10ck17 = 0 time = 360
.meas tran vdout2_10ck17 FIND v(dout2_10) AT=360.1n

* CHECK dout2_11 Vdout2_11ck17 = 0 time = 360
.meas tran vdout2_11ck17 FIND v(dout2_11) AT=360.1n

* CHECK dout2_12 Vdout2_12ck17 = 0 time = 360
.meas tran vdout2_12ck17 FIND v(dout2_12) AT=360.1n

* CHECK dout2_13 Vdout2_13ck17 = 1.8 time = 360
.meas tran vdout2_13ck17 FIND v(dout2_13) AT=360.1n

* CHECK dout2_14 Vdout2_14ck17 = 0 time = 360
.meas tran vdout2_14ck17 FIND v(dout2_14) AT=360.1n

* CHECK dout2_15 Vdout2_15ck17 = 1.8 time = 360
.meas tran vdout2_15ck17 FIND v(dout2_15) AT=360.1n

* CHECK dout2_16 Vdout2_16ck17 = 0 time = 360
.meas tran vdout2_16ck17 FIND v(dout2_16) AT=360.1n

* CHECK dout2_17 Vdout2_17ck17 = 1.8 time = 360
.meas tran vdout2_17ck17 FIND v(dout2_17) AT=360.1n

* CHECK dout2_18 Vdout2_18ck17 = 1.8 time = 360
.meas tran vdout2_18ck17 FIND v(dout2_18) AT=360.1n

* CHECK dout2_19 Vdout2_19ck17 = 0 time = 360
.meas tran vdout2_19ck17 FIND v(dout2_19) AT=360.1n

* CHECK dout2_20 Vdout2_20ck17 = 1.8 time = 360
.meas tran vdout2_20ck17 FIND v(dout2_20) AT=360.1n

* CHECK dout2_21 Vdout2_21ck17 = 1.8 time = 360
.meas tran vdout2_21ck17 FIND v(dout2_21) AT=360.1n

* CHECK dout2_22 Vdout2_22ck17 = 0 time = 360
.meas tran vdout2_22ck17 FIND v(dout2_22) AT=360.1n

* CHECK dout2_23 Vdout2_23ck17 = 0 time = 360
.meas tran vdout2_23ck17 FIND v(dout2_23) AT=360.1n

* CHECK dout2_24 Vdout2_24ck17 = 0 time = 360
.meas tran vdout2_24ck17 FIND v(dout2_24) AT=360.1n

* CHECK dout2_25 Vdout2_25ck17 = 0 time = 360
.meas tran vdout2_25ck17 FIND v(dout2_25) AT=360.1n

* CHECK dout2_26 Vdout2_26ck17 = 0 time = 360
.meas tran vdout2_26ck17 FIND v(dout2_26) AT=360.1n

* CHECK dout2_27 Vdout2_27ck17 = 1.8 time = 360
.meas tran vdout2_27ck17 FIND v(dout2_27) AT=360.1n

* CHECK dout2_28 Vdout2_28ck17 = 1.8 time = 360
.meas tran vdout2_28ck17 FIND v(dout2_28) AT=360.1n

* CHECK dout2_29 Vdout2_29ck17 = 1.8 time = 360
.meas tran vdout2_29ck17 FIND v(dout2_29) AT=360.1n

* CHECK dout2_30 Vdout2_30ck17 = 0 time = 360
.meas tran vdout2_30ck17 FIND v(dout2_30) AT=360.1n

* CHECK dout2_31 Vdout2_31ck17 = 0 time = 360
.meas tran vdout2_31ck17 FIND v(dout2_31) AT=360.1n

* CHECK dout1_0 Vdout1_0ck18 = 0 time = 380
.meas tran vdout1_0ck18 FIND v(dout1_0) AT=380.1n

* CHECK dout1_1 Vdout1_1ck18 = 0 time = 380
.meas tran vdout1_1ck18 FIND v(dout1_1) AT=380.1n

* CHECK dout1_2 Vdout1_2ck18 = 0 time = 380
.meas tran vdout1_2ck18 FIND v(dout1_2) AT=380.1n

* CHECK dout1_3 Vdout1_3ck18 = 1.8 time = 380
.meas tran vdout1_3ck18 FIND v(dout1_3) AT=380.1n

* CHECK dout1_4 Vdout1_4ck18 = 0 time = 380
.meas tran vdout1_4ck18 FIND v(dout1_4) AT=380.1n

* CHECK dout1_5 Vdout1_5ck18 = 1.8 time = 380
.meas tran vdout1_5ck18 FIND v(dout1_5) AT=380.1n

* CHECK dout1_6 Vdout1_6ck18 = 1.8 time = 380
.meas tran vdout1_6ck18 FIND v(dout1_6) AT=380.1n

* CHECK dout1_7 Vdout1_7ck18 = 1.8 time = 380
.meas tran vdout1_7ck18 FIND v(dout1_7) AT=380.1n

* CHECK dout1_8 Vdout1_8ck18 = 0 time = 380
.meas tran vdout1_8ck18 FIND v(dout1_8) AT=380.1n

* CHECK dout1_9 Vdout1_9ck18 = 0 time = 380
.meas tran vdout1_9ck18 FIND v(dout1_9) AT=380.1n

* CHECK dout1_10 Vdout1_10ck18 = 1.8 time = 380
.meas tran vdout1_10ck18 FIND v(dout1_10) AT=380.1n

* CHECK dout1_11 Vdout1_11ck18 = 0 time = 380
.meas tran vdout1_11ck18 FIND v(dout1_11) AT=380.1n

* CHECK dout1_12 Vdout1_12ck18 = 0 time = 380
.meas tran vdout1_12ck18 FIND v(dout1_12) AT=380.1n

* CHECK dout1_13 Vdout1_13ck18 = 0 time = 380
.meas tran vdout1_13ck18 FIND v(dout1_13) AT=380.1n

* CHECK dout1_14 Vdout1_14ck18 = 1.8 time = 380
.meas tran vdout1_14ck18 FIND v(dout1_14) AT=380.1n

* CHECK dout1_15 Vdout1_15ck18 = 1.8 time = 380
.meas tran vdout1_15ck18 FIND v(dout1_15) AT=380.1n

* CHECK dout1_16 Vdout1_16ck18 = 0 time = 380
.meas tran vdout1_16ck18 FIND v(dout1_16) AT=380.1n

* CHECK dout1_17 Vdout1_17ck18 = 1.8 time = 380
.meas tran vdout1_17ck18 FIND v(dout1_17) AT=380.1n

* CHECK dout1_18 Vdout1_18ck18 = 1.8 time = 380
.meas tran vdout1_18ck18 FIND v(dout1_18) AT=380.1n

* CHECK dout1_19 Vdout1_19ck18 = 0 time = 380
.meas tran vdout1_19ck18 FIND v(dout1_19) AT=380.1n

* CHECK dout1_20 Vdout1_20ck18 = 1.8 time = 380
.meas tran vdout1_20ck18 FIND v(dout1_20) AT=380.1n

* CHECK dout1_21 Vdout1_21ck18 = 0 time = 380
.meas tran vdout1_21ck18 FIND v(dout1_21) AT=380.1n

* CHECK dout1_22 Vdout1_22ck18 = 1.8 time = 380
.meas tran vdout1_22ck18 FIND v(dout1_22) AT=380.1n

* CHECK dout1_23 Vdout1_23ck18 = 1.8 time = 380
.meas tran vdout1_23ck18 FIND v(dout1_23) AT=380.1n

* CHECK dout1_24 Vdout1_24ck18 = 1.8 time = 380
.meas tran vdout1_24ck18 FIND v(dout1_24) AT=380.1n

* CHECK dout1_25 Vdout1_25ck18 = 1.8 time = 380
.meas tran vdout1_25ck18 FIND v(dout1_25) AT=380.1n

* CHECK dout1_26 Vdout1_26ck18 = 1.8 time = 380
.meas tran vdout1_26ck18 FIND v(dout1_26) AT=380.1n

* CHECK dout1_27 Vdout1_27ck18 = 1.8 time = 380
.meas tran vdout1_27ck18 FIND v(dout1_27) AT=380.1n

* CHECK dout1_28 Vdout1_28ck18 = 0 time = 380
.meas tran vdout1_28ck18 FIND v(dout1_28) AT=380.1n

* CHECK dout1_29 Vdout1_29ck18 = 1.8 time = 380
.meas tran vdout1_29ck18 FIND v(dout1_29) AT=380.1n

* CHECK dout1_30 Vdout1_30ck18 = 0 time = 380
.meas tran vdout1_30ck18 FIND v(dout1_30) AT=380.1n

* CHECK dout1_31 Vdout1_31ck18 = 0 time = 380
.meas tran vdout1_31ck18 FIND v(dout1_31) AT=380.1n

* CHECK dout2_0 Vdout2_0ck18 = 1.8 time = 380
.meas tran vdout2_0ck18 FIND v(dout2_0) AT=380.1n

* CHECK dout2_1 Vdout2_1ck18 = 1.8 time = 380
.meas tran vdout2_1ck18 FIND v(dout2_1) AT=380.1n

* CHECK dout2_2 Vdout2_2ck18 = 0 time = 380
.meas tran vdout2_2ck18 FIND v(dout2_2) AT=380.1n

* CHECK dout2_3 Vdout2_3ck18 = 1.8 time = 380
.meas tran vdout2_3ck18 FIND v(dout2_3) AT=380.1n

* CHECK dout2_4 Vdout2_4ck18 = 0 time = 380
.meas tran vdout2_4ck18 FIND v(dout2_4) AT=380.1n

* CHECK dout2_5 Vdout2_5ck18 = 1.8 time = 380
.meas tran vdout2_5ck18 FIND v(dout2_5) AT=380.1n

* CHECK dout2_6 Vdout2_6ck18 = 1.8 time = 380
.meas tran vdout2_6ck18 FIND v(dout2_6) AT=380.1n

* CHECK dout2_7 Vdout2_7ck18 = 1.8 time = 380
.meas tran vdout2_7ck18 FIND v(dout2_7) AT=380.1n

* CHECK dout2_8 Vdout2_8ck18 = 0 time = 380
.meas tran vdout2_8ck18 FIND v(dout2_8) AT=380.1n

* CHECK dout2_9 Vdout2_9ck18 = 0 time = 380
.meas tran vdout2_9ck18 FIND v(dout2_9) AT=380.1n

* CHECK dout2_10 Vdout2_10ck18 = 0 time = 380
.meas tran vdout2_10ck18 FIND v(dout2_10) AT=380.1n

* CHECK dout2_11 Vdout2_11ck18 = 0 time = 380
.meas tran vdout2_11ck18 FIND v(dout2_11) AT=380.1n

* CHECK dout2_12 Vdout2_12ck18 = 0 time = 380
.meas tran vdout2_12ck18 FIND v(dout2_12) AT=380.1n

* CHECK dout2_13 Vdout2_13ck18 = 1.8 time = 380
.meas tran vdout2_13ck18 FIND v(dout2_13) AT=380.1n

* CHECK dout2_14 Vdout2_14ck18 = 0 time = 380
.meas tran vdout2_14ck18 FIND v(dout2_14) AT=380.1n

* CHECK dout2_15 Vdout2_15ck18 = 1.8 time = 380
.meas tran vdout2_15ck18 FIND v(dout2_15) AT=380.1n

* CHECK dout2_16 Vdout2_16ck18 = 0 time = 380
.meas tran vdout2_16ck18 FIND v(dout2_16) AT=380.1n

* CHECK dout2_17 Vdout2_17ck18 = 1.8 time = 380
.meas tran vdout2_17ck18 FIND v(dout2_17) AT=380.1n

* CHECK dout2_18 Vdout2_18ck18 = 1.8 time = 380
.meas tran vdout2_18ck18 FIND v(dout2_18) AT=380.1n

* CHECK dout2_19 Vdout2_19ck18 = 0 time = 380
.meas tran vdout2_19ck18 FIND v(dout2_19) AT=380.1n

* CHECK dout2_20 Vdout2_20ck18 = 1.8 time = 380
.meas tran vdout2_20ck18 FIND v(dout2_20) AT=380.1n

* CHECK dout2_21 Vdout2_21ck18 = 1.8 time = 380
.meas tran vdout2_21ck18 FIND v(dout2_21) AT=380.1n

* CHECK dout2_22 Vdout2_22ck18 = 0 time = 380
.meas tran vdout2_22ck18 FIND v(dout2_22) AT=380.1n

* CHECK dout2_23 Vdout2_23ck18 = 0 time = 380
.meas tran vdout2_23ck18 FIND v(dout2_23) AT=380.1n

* CHECK dout2_24 Vdout2_24ck18 = 0 time = 380
.meas tran vdout2_24ck18 FIND v(dout2_24) AT=380.1n

* CHECK dout2_25 Vdout2_25ck18 = 0 time = 380
.meas tran vdout2_25ck18 FIND v(dout2_25) AT=380.1n

* CHECK dout2_26 Vdout2_26ck18 = 0 time = 380
.meas tran vdout2_26ck18 FIND v(dout2_26) AT=380.1n

* CHECK dout2_27 Vdout2_27ck18 = 1.8 time = 380
.meas tran vdout2_27ck18 FIND v(dout2_27) AT=380.1n

* CHECK dout2_28 Vdout2_28ck18 = 1.8 time = 380
.meas tran vdout2_28ck18 FIND v(dout2_28) AT=380.1n

* CHECK dout2_29 Vdout2_29ck18 = 1.8 time = 380
.meas tran vdout2_29ck18 FIND v(dout2_29) AT=380.1n

* CHECK dout2_30 Vdout2_30ck18 = 0 time = 380
.meas tran vdout2_30ck18 FIND v(dout2_30) AT=380.1n

* CHECK dout2_31 Vdout2_31ck18 = 0 time = 380
.meas tran vdout2_31ck18 FIND v(dout2_31) AT=380.1n

* CHECK dout1_0 Vdout1_0ck19 = 1.8 time = 400
.meas tran vdout1_0ck19 FIND v(dout1_0) AT=400.1n

* CHECK dout1_1 Vdout1_1ck19 = 1.8 time = 400
.meas tran vdout1_1ck19 FIND v(dout1_1) AT=400.1n

* CHECK dout1_2 Vdout1_2ck19 = 1.8 time = 400
.meas tran vdout1_2ck19 FIND v(dout1_2) AT=400.1n

* CHECK dout1_3 Vdout1_3ck19 = 1.8 time = 400
.meas tran vdout1_3ck19 FIND v(dout1_3) AT=400.1n

* CHECK dout1_4 Vdout1_4ck19 = 1.8 time = 400
.meas tran vdout1_4ck19 FIND v(dout1_4) AT=400.1n

* CHECK dout1_5 Vdout1_5ck19 = 0 time = 400
.meas tran vdout1_5ck19 FIND v(dout1_5) AT=400.1n

* CHECK dout1_6 Vdout1_6ck19 = 0 time = 400
.meas tran vdout1_6ck19 FIND v(dout1_6) AT=400.1n

* CHECK dout1_7 Vdout1_7ck19 = 1.8 time = 400
.meas tran vdout1_7ck19 FIND v(dout1_7) AT=400.1n

* CHECK dout1_8 Vdout1_8ck19 = 0 time = 400
.meas tran vdout1_8ck19 FIND v(dout1_8) AT=400.1n

* CHECK dout1_9 Vdout1_9ck19 = 0 time = 400
.meas tran vdout1_9ck19 FIND v(dout1_9) AT=400.1n

* CHECK dout1_10 Vdout1_10ck19 = 0 time = 400
.meas tran vdout1_10ck19 FIND v(dout1_10) AT=400.1n

* CHECK dout1_11 Vdout1_11ck19 = 0 time = 400
.meas tran vdout1_11ck19 FIND v(dout1_11) AT=400.1n

* CHECK dout1_12 Vdout1_12ck19 = 0 time = 400
.meas tran vdout1_12ck19 FIND v(dout1_12) AT=400.1n

* CHECK dout1_13 Vdout1_13ck19 = 1.8 time = 400
.meas tran vdout1_13ck19 FIND v(dout1_13) AT=400.1n

* CHECK dout1_14 Vdout1_14ck19 = 1.8 time = 400
.meas tran vdout1_14ck19 FIND v(dout1_14) AT=400.1n

* CHECK dout1_15 Vdout1_15ck19 = 0 time = 400
.meas tran vdout1_15ck19 FIND v(dout1_15) AT=400.1n

* CHECK dout1_16 Vdout1_16ck19 = 0 time = 400
.meas tran vdout1_16ck19 FIND v(dout1_16) AT=400.1n

* CHECK dout1_17 Vdout1_17ck19 = 0 time = 400
.meas tran vdout1_17ck19 FIND v(dout1_17) AT=400.1n

* CHECK dout1_18 Vdout1_18ck19 = 0 time = 400
.meas tran vdout1_18ck19 FIND v(dout1_18) AT=400.1n

* CHECK dout1_19 Vdout1_19ck19 = 0 time = 400
.meas tran vdout1_19ck19 FIND v(dout1_19) AT=400.1n

* CHECK dout1_20 Vdout1_20ck19 = 0 time = 400
.meas tran vdout1_20ck19 FIND v(dout1_20) AT=400.1n

* CHECK dout1_21 Vdout1_21ck19 = 0 time = 400
.meas tran vdout1_21ck19 FIND v(dout1_21) AT=400.1n

* CHECK dout1_22 Vdout1_22ck19 = 1.8 time = 400
.meas tran vdout1_22ck19 FIND v(dout1_22) AT=400.1n

* CHECK dout1_23 Vdout1_23ck19 = 0 time = 400
.meas tran vdout1_23ck19 FIND v(dout1_23) AT=400.1n

* CHECK dout1_24 Vdout1_24ck19 = 1.8 time = 400
.meas tran vdout1_24ck19 FIND v(dout1_24) AT=400.1n

* CHECK dout1_25 Vdout1_25ck19 = 0 time = 400
.meas tran vdout1_25ck19 FIND v(dout1_25) AT=400.1n

* CHECK dout1_26 Vdout1_26ck19 = 1.8 time = 400
.meas tran vdout1_26ck19 FIND v(dout1_26) AT=400.1n

* CHECK dout1_27 Vdout1_27ck19 = 1.8 time = 400
.meas tran vdout1_27ck19 FIND v(dout1_27) AT=400.1n

* CHECK dout1_28 Vdout1_28ck19 = 0 time = 400
.meas tran vdout1_28ck19 FIND v(dout1_28) AT=400.1n

* CHECK dout1_29 Vdout1_29ck19 = 0 time = 400
.meas tran vdout1_29ck19 FIND v(dout1_29) AT=400.1n

* CHECK dout1_30 Vdout1_30ck19 = 1.8 time = 400
.meas tran vdout1_30ck19 FIND v(dout1_30) AT=400.1n

* CHECK dout1_31 Vdout1_31ck19 = 1.8 time = 400
.meas tran vdout1_31ck19 FIND v(dout1_31) AT=400.1n

* CHECK dout2_0 Vdout2_0ck20 = 1.8 time = 420
.meas tran vdout2_0ck20 FIND v(dout2_0) AT=420.1n

* CHECK dout2_1 Vdout2_1ck20 = 1.8 time = 420
.meas tran vdout2_1ck20 FIND v(dout2_1) AT=420.1n

* CHECK dout2_2 Vdout2_2ck20 = 1.8 time = 420
.meas tran vdout2_2ck20 FIND v(dout2_2) AT=420.1n

* CHECK dout2_3 Vdout2_3ck20 = 1.8 time = 420
.meas tran vdout2_3ck20 FIND v(dout2_3) AT=420.1n

* CHECK dout2_4 Vdout2_4ck20 = 1.8 time = 420
.meas tran vdout2_4ck20 FIND v(dout2_4) AT=420.1n

* CHECK dout2_5 Vdout2_5ck20 = 0 time = 420
.meas tran vdout2_5ck20 FIND v(dout2_5) AT=420.1n

* CHECK dout2_6 Vdout2_6ck20 = 0 time = 420
.meas tran vdout2_6ck20 FIND v(dout2_6) AT=420.1n

* CHECK dout2_7 Vdout2_7ck20 = 1.8 time = 420
.meas tran vdout2_7ck20 FIND v(dout2_7) AT=420.1n

* CHECK dout2_8 Vdout2_8ck20 = 0 time = 420
.meas tran vdout2_8ck20 FIND v(dout2_8) AT=420.1n

* CHECK dout2_9 Vdout2_9ck20 = 0 time = 420
.meas tran vdout2_9ck20 FIND v(dout2_9) AT=420.1n

* CHECK dout2_10 Vdout2_10ck20 = 0 time = 420
.meas tran vdout2_10ck20 FIND v(dout2_10) AT=420.1n

* CHECK dout2_11 Vdout2_11ck20 = 0 time = 420
.meas tran vdout2_11ck20 FIND v(dout2_11) AT=420.1n

* CHECK dout2_12 Vdout2_12ck20 = 0 time = 420
.meas tran vdout2_12ck20 FIND v(dout2_12) AT=420.1n

* CHECK dout2_13 Vdout2_13ck20 = 1.8 time = 420
.meas tran vdout2_13ck20 FIND v(dout2_13) AT=420.1n

* CHECK dout2_14 Vdout2_14ck20 = 1.8 time = 420
.meas tran vdout2_14ck20 FIND v(dout2_14) AT=420.1n

* CHECK dout2_15 Vdout2_15ck20 = 0 time = 420
.meas tran vdout2_15ck20 FIND v(dout2_15) AT=420.1n

* CHECK dout2_16 Vdout2_16ck20 = 0 time = 420
.meas tran vdout2_16ck20 FIND v(dout2_16) AT=420.1n

* CHECK dout2_17 Vdout2_17ck20 = 0 time = 420
.meas tran vdout2_17ck20 FIND v(dout2_17) AT=420.1n

* CHECK dout2_18 Vdout2_18ck20 = 0 time = 420
.meas tran vdout2_18ck20 FIND v(dout2_18) AT=420.1n

* CHECK dout2_19 Vdout2_19ck20 = 0 time = 420
.meas tran vdout2_19ck20 FIND v(dout2_19) AT=420.1n

* CHECK dout2_20 Vdout2_20ck20 = 0 time = 420
.meas tran vdout2_20ck20 FIND v(dout2_20) AT=420.1n

* CHECK dout2_21 Vdout2_21ck20 = 0 time = 420
.meas tran vdout2_21ck20 FIND v(dout2_21) AT=420.1n

* CHECK dout2_22 Vdout2_22ck20 = 1.8 time = 420
.meas tran vdout2_22ck20 FIND v(dout2_22) AT=420.1n

* CHECK dout2_23 Vdout2_23ck20 = 0 time = 420
.meas tran vdout2_23ck20 FIND v(dout2_23) AT=420.1n

* CHECK dout2_24 Vdout2_24ck20 = 1.8 time = 420
.meas tran vdout2_24ck20 FIND v(dout2_24) AT=420.1n

* CHECK dout2_25 Vdout2_25ck20 = 0 time = 420
.meas tran vdout2_25ck20 FIND v(dout2_25) AT=420.1n

* CHECK dout2_26 Vdout2_26ck20 = 1.8 time = 420
.meas tran vdout2_26ck20 FIND v(dout2_26) AT=420.1n

* CHECK dout2_27 Vdout2_27ck20 = 1.8 time = 420
.meas tran vdout2_27ck20 FIND v(dout2_27) AT=420.1n

* CHECK dout2_28 Vdout2_28ck20 = 0 time = 420
.meas tran vdout2_28ck20 FIND v(dout2_28) AT=420.1n

* CHECK dout2_29 Vdout2_29ck20 = 0 time = 420
.meas tran vdout2_29ck20 FIND v(dout2_29) AT=420.1n

* CHECK dout2_30 Vdout2_30ck20 = 1.8 time = 420
.meas tran vdout2_30ck20 FIND v(dout2_30) AT=420.1n

* CHECK dout2_31 Vdout2_31ck20 = 1.8 time = 420
.meas tran vdout2_31ck20 FIND v(dout2_31) AT=420.1n

* CHECK dout1_0 Vdout1_0ck21 = 0 time = 440
.meas tran vdout1_0ck21 FIND v(dout1_0) AT=440.1n

* CHECK dout1_1 Vdout1_1ck21 = 0 time = 440
.meas tran vdout1_1ck21 FIND v(dout1_1) AT=440.1n

* CHECK dout1_2 Vdout1_2ck21 = 0 time = 440
.meas tran vdout1_2ck21 FIND v(dout1_2) AT=440.1n

* CHECK dout1_3 Vdout1_3ck21 = 0 time = 440
.meas tran vdout1_3ck21 FIND v(dout1_3) AT=440.1n

* CHECK dout1_4 Vdout1_4ck21 = 1.8 time = 440
.meas tran vdout1_4ck21 FIND v(dout1_4) AT=440.1n

* CHECK dout1_5 Vdout1_5ck21 = 0 time = 440
.meas tran vdout1_5ck21 FIND v(dout1_5) AT=440.1n

* CHECK dout1_6 Vdout1_6ck21 = 1.8 time = 440
.meas tran vdout1_6ck21 FIND v(dout1_6) AT=440.1n

* CHECK dout1_7 Vdout1_7ck21 = 1.8 time = 440
.meas tran vdout1_7ck21 FIND v(dout1_7) AT=440.1n

* CHECK dout1_8 Vdout1_8ck21 = 1.8 time = 440
.meas tran vdout1_8ck21 FIND v(dout1_8) AT=440.1n

* CHECK dout1_9 Vdout1_9ck21 = 1.8 time = 440
.meas tran vdout1_9ck21 FIND v(dout1_9) AT=440.1n

* CHECK dout1_10 Vdout1_10ck21 = 1.8 time = 440
.meas tran vdout1_10ck21 FIND v(dout1_10) AT=440.1n

* CHECK dout1_11 Vdout1_11ck21 = 0 time = 440
.meas tran vdout1_11ck21 FIND v(dout1_11) AT=440.1n

* CHECK dout1_12 Vdout1_12ck21 = 1.8 time = 440
.meas tran vdout1_12ck21 FIND v(dout1_12) AT=440.1n

* CHECK dout1_13 Vdout1_13ck21 = 1.8 time = 440
.meas tran vdout1_13ck21 FIND v(dout1_13) AT=440.1n

* CHECK dout1_14 Vdout1_14ck21 = 1.8 time = 440
.meas tran vdout1_14ck21 FIND v(dout1_14) AT=440.1n

* CHECK dout1_15 Vdout1_15ck21 = 1.8 time = 440
.meas tran vdout1_15ck21 FIND v(dout1_15) AT=440.1n

* CHECK dout1_16 Vdout1_16ck21 = 0 time = 440
.meas tran vdout1_16ck21 FIND v(dout1_16) AT=440.1n

* CHECK dout1_17 Vdout1_17ck21 = 0 time = 440
.meas tran vdout1_17ck21 FIND v(dout1_17) AT=440.1n

* CHECK dout1_18 Vdout1_18ck21 = 1.8 time = 440
.meas tran vdout1_18ck21 FIND v(dout1_18) AT=440.1n

* CHECK dout1_19 Vdout1_19ck21 = 0 time = 440
.meas tran vdout1_19ck21 FIND v(dout1_19) AT=440.1n

* CHECK dout1_20 Vdout1_20ck21 = 0 time = 440
.meas tran vdout1_20ck21 FIND v(dout1_20) AT=440.1n

* CHECK dout1_21 Vdout1_21ck21 = 1.8 time = 440
.meas tran vdout1_21ck21 FIND v(dout1_21) AT=440.1n

* CHECK dout1_22 Vdout1_22ck21 = 1.8 time = 440
.meas tran vdout1_22ck21 FIND v(dout1_22) AT=440.1n

* CHECK dout1_23 Vdout1_23ck21 = 0 time = 440
.meas tran vdout1_23ck21 FIND v(dout1_23) AT=440.1n

* CHECK dout1_24 Vdout1_24ck21 = 1.8 time = 440
.meas tran vdout1_24ck21 FIND v(dout1_24) AT=440.1n

* CHECK dout1_25 Vdout1_25ck21 = 0 time = 440
.meas tran vdout1_25ck21 FIND v(dout1_25) AT=440.1n

* CHECK dout1_26 Vdout1_26ck21 = 0 time = 440
.meas tran vdout1_26ck21 FIND v(dout1_26) AT=440.1n

* CHECK dout1_27 Vdout1_27ck21 = 0 time = 440
.meas tran vdout1_27ck21 FIND v(dout1_27) AT=440.1n

* CHECK dout1_28 Vdout1_28ck21 = 0 time = 440
.meas tran vdout1_28ck21 FIND v(dout1_28) AT=440.1n

* CHECK dout1_29 Vdout1_29ck21 = 0 time = 440
.meas tran vdout1_29ck21 FIND v(dout1_29) AT=440.1n

* CHECK dout1_30 Vdout1_30ck21 = 0 time = 440
.meas tran vdout1_30ck21 FIND v(dout1_30) AT=440.1n

* CHECK dout1_31 Vdout1_31ck21 = 0 time = 440
.meas tran vdout1_31ck21 FIND v(dout1_31) AT=440.1n

* CHECK dout2_0 Vdout2_0ck21 = 0 time = 440
.meas tran vdout2_0ck21 FIND v(dout2_0) AT=440.1n

* CHECK dout2_1 Vdout2_1ck21 = 0 time = 440
.meas tran vdout2_1ck21 FIND v(dout2_1) AT=440.1n

* CHECK dout2_2 Vdout2_2ck21 = 0 time = 440
.meas tran vdout2_2ck21 FIND v(dout2_2) AT=440.1n

* CHECK dout2_3 Vdout2_3ck21 = 0 time = 440
.meas tran vdout2_3ck21 FIND v(dout2_3) AT=440.1n

* CHECK dout2_4 Vdout2_4ck21 = 1.8 time = 440
.meas tran vdout2_4ck21 FIND v(dout2_4) AT=440.1n

* CHECK dout2_5 Vdout2_5ck21 = 0 time = 440
.meas tran vdout2_5ck21 FIND v(dout2_5) AT=440.1n

* CHECK dout2_6 Vdout2_6ck21 = 1.8 time = 440
.meas tran vdout2_6ck21 FIND v(dout2_6) AT=440.1n

* CHECK dout2_7 Vdout2_7ck21 = 1.8 time = 440
.meas tran vdout2_7ck21 FIND v(dout2_7) AT=440.1n

* CHECK dout2_8 Vdout2_8ck21 = 1.8 time = 440
.meas tran vdout2_8ck21 FIND v(dout2_8) AT=440.1n

* CHECK dout2_9 Vdout2_9ck21 = 1.8 time = 440
.meas tran vdout2_9ck21 FIND v(dout2_9) AT=440.1n

* CHECK dout2_10 Vdout2_10ck21 = 1.8 time = 440
.meas tran vdout2_10ck21 FIND v(dout2_10) AT=440.1n

* CHECK dout2_11 Vdout2_11ck21 = 0 time = 440
.meas tran vdout2_11ck21 FIND v(dout2_11) AT=440.1n

* CHECK dout2_12 Vdout2_12ck21 = 1.8 time = 440
.meas tran vdout2_12ck21 FIND v(dout2_12) AT=440.1n

* CHECK dout2_13 Vdout2_13ck21 = 1.8 time = 440
.meas tran vdout2_13ck21 FIND v(dout2_13) AT=440.1n

* CHECK dout2_14 Vdout2_14ck21 = 1.8 time = 440
.meas tran vdout2_14ck21 FIND v(dout2_14) AT=440.1n

* CHECK dout2_15 Vdout2_15ck21 = 1.8 time = 440
.meas tran vdout2_15ck21 FIND v(dout2_15) AT=440.1n

* CHECK dout2_16 Vdout2_16ck21 = 0 time = 440
.meas tran vdout2_16ck21 FIND v(dout2_16) AT=440.1n

* CHECK dout2_17 Vdout2_17ck21 = 0 time = 440
.meas tran vdout2_17ck21 FIND v(dout2_17) AT=440.1n

* CHECK dout2_18 Vdout2_18ck21 = 1.8 time = 440
.meas tran vdout2_18ck21 FIND v(dout2_18) AT=440.1n

* CHECK dout2_19 Vdout2_19ck21 = 0 time = 440
.meas tran vdout2_19ck21 FIND v(dout2_19) AT=440.1n

* CHECK dout2_20 Vdout2_20ck21 = 0 time = 440
.meas tran vdout2_20ck21 FIND v(dout2_20) AT=440.1n

* CHECK dout2_21 Vdout2_21ck21 = 1.8 time = 440
.meas tran vdout2_21ck21 FIND v(dout2_21) AT=440.1n

* CHECK dout2_22 Vdout2_22ck21 = 1.8 time = 440
.meas tran vdout2_22ck21 FIND v(dout2_22) AT=440.1n

* CHECK dout2_23 Vdout2_23ck21 = 0 time = 440
.meas tran vdout2_23ck21 FIND v(dout2_23) AT=440.1n

* CHECK dout2_24 Vdout2_24ck21 = 1.8 time = 440
.meas tran vdout2_24ck21 FIND v(dout2_24) AT=440.1n

* CHECK dout2_25 Vdout2_25ck21 = 0 time = 440
.meas tran vdout2_25ck21 FIND v(dout2_25) AT=440.1n

* CHECK dout2_26 Vdout2_26ck21 = 0 time = 440
.meas tran vdout2_26ck21 FIND v(dout2_26) AT=440.1n

* CHECK dout2_27 Vdout2_27ck21 = 0 time = 440
.meas tran vdout2_27ck21 FIND v(dout2_27) AT=440.1n

* CHECK dout2_28 Vdout2_28ck21 = 0 time = 440
.meas tran vdout2_28ck21 FIND v(dout2_28) AT=440.1n

* CHECK dout2_29 Vdout2_29ck21 = 0 time = 440
.meas tran vdout2_29ck21 FIND v(dout2_29) AT=440.1n

* CHECK dout2_30 Vdout2_30ck21 = 0 time = 440
.meas tran vdout2_30ck21 FIND v(dout2_30) AT=440.1n

* CHECK dout2_31 Vdout2_31ck21 = 0 time = 440
.meas tran vdout2_31ck21 FIND v(dout2_31) AT=440.1n

* CHECK dout2_0 Vdout2_0ck22 = 0 time = 460
.meas tran vdout2_0ck22 FIND v(dout2_0) AT=460.1n

* CHECK dout2_1 Vdout2_1ck22 = 1.8 time = 460
.meas tran vdout2_1ck22 FIND v(dout2_1) AT=460.1n

* CHECK dout2_2 Vdout2_2ck22 = 1.8 time = 460
.meas tran vdout2_2ck22 FIND v(dout2_2) AT=460.1n

* CHECK dout2_3 Vdout2_3ck22 = 1.8 time = 460
.meas tran vdout2_3ck22 FIND v(dout2_3) AT=460.1n

* CHECK dout2_4 Vdout2_4ck22 = 0 time = 460
.meas tran vdout2_4ck22 FIND v(dout2_4) AT=460.1n

* CHECK dout2_5 Vdout2_5ck22 = 0 time = 460
.meas tran vdout2_5ck22 FIND v(dout2_5) AT=460.1n

* CHECK dout2_6 Vdout2_6ck22 = 0 time = 460
.meas tran vdout2_6ck22 FIND v(dout2_6) AT=460.1n

* CHECK dout2_7 Vdout2_7ck22 = 0 time = 460
.meas tran vdout2_7ck22 FIND v(dout2_7) AT=460.1n

* CHECK dout2_8 Vdout2_8ck22 = 1.8 time = 460
.meas tran vdout2_8ck22 FIND v(dout2_8) AT=460.1n

* CHECK dout2_9 Vdout2_9ck22 = 1.8 time = 460
.meas tran vdout2_9ck22 FIND v(dout2_9) AT=460.1n

* CHECK dout2_10 Vdout2_10ck22 = 1.8 time = 460
.meas tran vdout2_10ck22 FIND v(dout2_10) AT=460.1n

* CHECK dout2_11 Vdout2_11ck22 = 0 time = 460
.meas tran vdout2_11ck22 FIND v(dout2_11) AT=460.1n

* CHECK dout2_12 Vdout2_12ck22 = 0 time = 460
.meas tran vdout2_12ck22 FIND v(dout2_12) AT=460.1n

* CHECK dout2_13 Vdout2_13ck22 = 1.8 time = 460
.meas tran vdout2_13ck22 FIND v(dout2_13) AT=460.1n

* CHECK dout2_14 Vdout2_14ck22 = 1.8 time = 460
.meas tran vdout2_14ck22 FIND v(dout2_14) AT=460.1n

* CHECK dout2_15 Vdout2_15ck22 = 1.8 time = 460
.meas tran vdout2_15ck22 FIND v(dout2_15) AT=460.1n

* CHECK dout2_16 Vdout2_16ck22 = 0 time = 460
.meas tran vdout2_16ck22 FIND v(dout2_16) AT=460.1n

* CHECK dout2_17 Vdout2_17ck22 = 1.8 time = 460
.meas tran vdout2_17ck22 FIND v(dout2_17) AT=460.1n

* CHECK dout2_18 Vdout2_18ck22 = 0 time = 460
.meas tran vdout2_18ck22 FIND v(dout2_18) AT=460.1n

* CHECK dout2_19 Vdout2_19ck22 = 1.8 time = 460
.meas tran vdout2_19ck22 FIND v(dout2_19) AT=460.1n

* CHECK dout2_20 Vdout2_20ck22 = 1.8 time = 460
.meas tran vdout2_20ck22 FIND v(dout2_20) AT=460.1n

* CHECK dout2_21 Vdout2_21ck22 = 0 time = 460
.meas tran vdout2_21ck22 FIND v(dout2_21) AT=460.1n

* CHECK dout2_22 Vdout2_22ck22 = 1.8 time = 460
.meas tran vdout2_22ck22 FIND v(dout2_22) AT=460.1n

* CHECK dout2_23 Vdout2_23ck22 = 0 time = 460
.meas tran vdout2_23ck22 FIND v(dout2_23) AT=460.1n

* CHECK dout2_24 Vdout2_24ck22 = 0 time = 460
.meas tran vdout2_24ck22 FIND v(dout2_24) AT=460.1n

* CHECK dout2_25 Vdout2_25ck22 = 0 time = 460
.meas tran vdout2_25ck22 FIND v(dout2_25) AT=460.1n

* CHECK dout2_26 Vdout2_26ck22 = 1.8 time = 460
.meas tran vdout2_26ck22 FIND v(dout2_26) AT=460.1n

* CHECK dout2_27 Vdout2_27ck22 = 1.8 time = 460
.meas tran vdout2_27ck22 FIND v(dout2_27) AT=460.1n

* CHECK dout2_28 Vdout2_28ck22 = 0 time = 460
.meas tran vdout2_28ck22 FIND v(dout2_28) AT=460.1n

* CHECK dout2_29 Vdout2_29ck22 = 1.8 time = 460
.meas tran vdout2_29ck22 FIND v(dout2_29) AT=460.1n

* CHECK dout2_30 Vdout2_30ck22 = 0 time = 460
.meas tran vdout2_30ck22 FIND v(dout2_30) AT=460.1n

* CHECK dout2_31 Vdout2_31ck22 = 0 time = 460
.meas tran vdout2_31ck22 FIND v(dout2_31) AT=460.1n

* CHECK dout2_0 Vdout2_0ck23 = 1.8 time = 480
.meas tran vdout2_0ck23 FIND v(dout2_0) AT=480.1n

* CHECK dout2_1 Vdout2_1ck23 = 1.8 time = 480
.meas tran vdout2_1ck23 FIND v(dout2_1) AT=480.1n

* CHECK dout2_2 Vdout2_2ck23 = 1.8 time = 480
.meas tran vdout2_2ck23 FIND v(dout2_2) AT=480.1n

* CHECK dout2_3 Vdout2_3ck23 = 1.8 time = 480
.meas tran vdout2_3ck23 FIND v(dout2_3) AT=480.1n

* CHECK dout2_4 Vdout2_4ck23 = 1.8 time = 480
.meas tran vdout2_4ck23 FIND v(dout2_4) AT=480.1n

* CHECK dout2_5 Vdout2_5ck23 = 0 time = 480
.meas tran vdout2_5ck23 FIND v(dout2_5) AT=480.1n

* CHECK dout2_6 Vdout2_6ck23 = 0 time = 480
.meas tran vdout2_6ck23 FIND v(dout2_6) AT=480.1n

* CHECK dout2_7 Vdout2_7ck23 = 1.8 time = 480
.meas tran vdout2_7ck23 FIND v(dout2_7) AT=480.1n

* CHECK dout2_8 Vdout2_8ck23 = 0 time = 480
.meas tran vdout2_8ck23 FIND v(dout2_8) AT=480.1n

* CHECK dout2_9 Vdout2_9ck23 = 0 time = 480
.meas tran vdout2_9ck23 FIND v(dout2_9) AT=480.1n

* CHECK dout2_10 Vdout2_10ck23 = 0 time = 480
.meas tran vdout2_10ck23 FIND v(dout2_10) AT=480.1n

* CHECK dout2_11 Vdout2_11ck23 = 0 time = 480
.meas tran vdout2_11ck23 FIND v(dout2_11) AT=480.1n

* CHECK dout2_12 Vdout2_12ck23 = 0 time = 480
.meas tran vdout2_12ck23 FIND v(dout2_12) AT=480.1n

* CHECK dout2_13 Vdout2_13ck23 = 1.8 time = 480
.meas tran vdout2_13ck23 FIND v(dout2_13) AT=480.1n

* CHECK dout2_14 Vdout2_14ck23 = 1.8 time = 480
.meas tran vdout2_14ck23 FIND v(dout2_14) AT=480.1n

* CHECK dout2_15 Vdout2_15ck23 = 0 time = 480
.meas tran vdout2_15ck23 FIND v(dout2_15) AT=480.1n

* CHECK dout2_16 Vdout2_16ck23 = 0 time = 480
.meas tran vdout2_16ck23 FIND v(dout2_16) AT=480.1n

* CHECK dout2_17 Vdout2_17ck23 = 0 time = 480
.meas tran vdout2_17ck23 FIND v(dout2_17) AT=480.1n

* CHECK dout2_18 Vdout2_18ck23 = 0 time = 480
.meas tran vdout2_18ck23 FIND v(dout2_18) AT=480.1n

* CHECK dout2_19 Vdout2_19ck23 = 0 time = 480
.meas tran vdout2_19ck23 FIND v(dout2_19) AT=480.1n

* CHECK dout2_20 Vdout2_20ck23 = 0 time = 480
.meas tran vdout2_20ck23 FIND v(dout2_20) AT=480.1n

* CHECK dout2_21 Vdout2_21ck23 = 0 time = 480
.meas tran vdout2_21ck23 FIND v(dout2_21) AT=480.1n

* CHECK dout2_22 Vdout2_22ck23 = 1.8 time = 480
.meas tran vdout2_22ck23 FIND v(dout2_22) AT=480.1n

* CHECK dout2_23 Vdout2_23ck23 = 0 time = 480
.meas tran vdout2_23ck23 FIND v(dout2_23) AT=480.1n

* CHECK dout2_24 Vdout2_24ck23 = 1.8 time = 480
.meas tran vdout2_24ck23 FIND v(dout2_24) AT=480.1n

* CHECK dout2_25 Vdout2_25ck23 = 0 time = 480
.meas tran vdout2_25ck23 FIND v(dout2_25) AT=480.1n

* CHECK dout2_26 Vdout2_26ck23 = 1.8 time = 480
.meas tran vdout2_26ck23 FIND v(dout2_26) AT=480.1n

* CHECK dout2_27 Vdout2_27ck23 = 1.8 time = 480
.meas tran vdout2_27ck23 FIND v(dout2_27) AT=480.1n

* CHECK dout2_28 Vdout2_28ck23 = 0 time = 480
.meas tran vdout2_28ck23 FIND v(dout2_28) AT=480.1n

* CHECK dout2_29 Vdout2_29ck23 = 0 time = 480
.meas tran vdout2_29ck23 FIND v(dout2_29) AT=480.1n

* CHECK dout2_30 Vdout2_30ck23 = 1.8 time = 480
.meas tran vdout2_30ck23 FIND v(dout2_30) AT=480.1n

* CHECK dout2_31 Vdout2_31ck23 = 1.8 time = 480
.meas tran vdout2_31ck23 FIND v(dout2_31) AT=480.1n

* CHECK dout2_0 Vdout2_0ck24 = 0 time = 500
.meas tran vdout2_0ck24 FIND v(dout2_0) AT=500.1n

* CHECK dout2_1 Vdout2_1ck24 = 0 time = 500
.meas tran vdout2_1ck24 FIND v(dout2_1) AT=500.1n

* CHECK dout2_2 Vdout2_2ck24 = 1.8 time = 500
.meas tran vdout2_2ck24 FIND v(dout2_2) AT=500.1n

* CHECK dout2_3 Vdout2_3ck24 = 0 time = 500
.meas tran vdout2_3ck24 FIND v(dout2_3) AT=500.1n

* CHECK dout2_4 Vdout2_4ck24 = 1.8 time = 500
.meas tran vdout2_4ck24 FIND v(dout2_4) AT=500.1n

* CHECK dout2_5 Vdout2_5ck24 = 1.8 time = 500
.meas tran vdout2_5ck24 FIND v(dout2_5) AT=500.1n

* CHECK dout2_6 Vdout2_6ck24 = 1.8 time = 500
.meas tran vdout2_6ck24 FIND v(dout2_6) AT=500.1n

* CHECK dout2_7 Vdout2_7ck24 = 0 time = 500
.meas tran vdout2_7ck24 FIND v(dout2_7) AT=500.1n

* CHECK dout2_8 Vdout2_8ck24 = 0 time = 500
.meas tran vdout2_8ck24 FIND v(dout2_8) AT=500.1n

* CHECK dout2_9 Vdout2_9ck24 = 0 time = 500
.meas tran vdout2_9ck24 FIND v(dout2_9) AT=500.1n

* CHECK dout2_10 Vdout2_10ck24 = 1.8 time = 500
.meas tran vdout2_10ck24 FIND v(dout2_10) AT=500.1n

* CHECK dout2_11 Vdout2_11ck24 = 1.8 time = 500
.meas tran vdout2_11ck24 FIND v(dout2_11) AT=500.1n

* CHECK dout2_12 Vdout2_12ck24 = 0 time = 500
.meas tran vdout2_12ck24 FIND v(dout2_12) AT=500.1n

* CHECK dout2_13 Vdout2_13ck24 = 1.8 time = 500
.meas tran vdout2_13ck24 FIND v(dout2_13) AT=500.1n

* CHECK dout2_14 Vdout2_14ck24 = 1.8 time = 500
.meas tran vdout2_14ck24 FIND v(dout2_14) AT=500.1n

* CHECK dout2_15 Vdout2_15ck24 = 1.8 time = 500
.meas tran vdout2_15ck24 FIND v(dout2_15) AT=500.1n

* CHECK dout2_16 Vdout2_16ck24 = 0 time = 500
.meas tran vdout2_16ck24 FIND v(dout2_16) AT=500.1n

* CHECK dout2_17 Vdout2_17ck24 = 0 time = 500
.meas tran vdout2_17ck24 FIND v(dout2_17) AT=500.1n

* CHECK dout2_18 Vdout2_18ck24 = 1.8 time = 500
.meas tran vdout2_18ck24 FIND v(dout2_18) AT=500.1n

* CHECK dout2_19 Vdout2_19ck24 = 0 time = 500
.meas tran vdout2_19ck24 FIND v(dout2_19) AT=500.1n

* CHECK dout2_20 Vdout2_20ck24 = 0 time = 500
.meas tran vdout2_20ck24 FIND v(dout2_20) AT=500.1n

* CHECK dout2_21 Vdout2_21ck24 = 1.8 time = 500
.meas tran vdout2_21ck24 FIND v(dout2_21) AT=500.1n

* CHECK dout2_22 Vdout2_22ck24 = 0 time = 500
.meas tran vdout2_22ck24 FIND v(dout2_22) AT=500.1n

* CHECK dout2_23 Vdout2_23ck24 = 1.8 time = 500
.meas tran vdout2_23ck24 FIND v(dout2_23) AT=500.1n

* CHECK dout2_24 Vdout2_24ck24 = 0 time = 500
.meas tran vdout2_24ck24 FIND v(dout2_24) AT=500.1n

* CHECK dout2_25 Vdout2_25ck24 = 0 time = 500
.meas tran vdout2_25ck24 FIND v(dout2_25) AT=500.1n

* CHECK dout2_26 Vdout2_26ck24 = 0 time = 500
.meas tran vdout2_26ck24 FIND v(dout2_26) AT=500.1n

* CHECK dout2_27 Vdout2_27ck24 = 1.8 time = 500
.meas tran vdout2_27ck24 FIND v(dout2_27) AT=500.1n

* CHECK dout2_28 Vdout2_28ck24 = 1.8 time = 500
.meas tran vdout2_28ck24 FIND v(dout2_28) AT=500.1n

* CHECK dout2_29 Vdout2_29ck24 = 1.8 time = 500
.meas tran vdout2_29ck24 FIND v(dout2_29) AT=500.1n

* CHECK dout2_30 Vdout2_30ck24 = 0 time = 500
.meas tran vdout2_30ck24 FIND v(dout2_30) AT=500.1n

* CHECK dout2_31 Vdout2_31ck24 = 1.8 time = 500
.meas tran vdout2_31ck24 FIND v(dout2_31) AT=500.1n

* CHECK dout1_0 Vdout1_0ck25 = 1.8 time = 520
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=520.1n

* CHECK dout1_1 Vdout1_1ck25 = 1.8 time = 520
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=520.1n

* CHECK dout1_2 Vdout1_2ck25 = 1.8 time = 520
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=520.1n

* CHECK dout1_3 Vdout1_3ck25 = 1.8 time = 520
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=520.1n

* CHECK dout1_4 Vdout1_4ck25 = 1.8 time = 520
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=520.1n

* CHECK dout1_5 Vdout1_5ck25 = 0 time = 520
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=520.1n

* CHECK dout1_6 Vdout1_6ck25 = 0 time = 520
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=520.1n

* CHECK dout1_7 Vdout1_7ck25 = 1.8 time = 520
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=520.1n

* CHECK dout1_8 Vdout1_8ck25 = 0 time = 520
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=520.1n

* CHECK dout1_9 Vdout1_9ck25 = 0 time = 520
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=520.1n

* CHECK dout1_10 Vdout1_10ck25 = 0 time = 520
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=520.1n

* CHECK dout1_11 Vdout1_11ck25 = 0 time = 520
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=520.1n

* CHECK dout1_12 Vdout1_12ck25 = 0 time = 520
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=520.1n

* CHECK dout1_13 Vdout1_13ck25 = 1.8 time = 520
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=520.1n

* CHECK dout1_14 Vdout1_14ck25 = 1.8 time = 520
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=520.1n

* CHECK dout1_15 Vdout1_15ck25 = 0 time = 520
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=520.1n

* CHECK dout1_16 Vdout1_16ck25 = 0 time = 520
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=520.1n

* CHECK dout1_17 Vdout1_17ck25 = 0 time = 520
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=520.1n

* CHECK dout1_18 Vdout1_18ck25 = 0 time = 520
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=520.1n

* CHECK dout1_19 Vdout1_19ck25 = 0 time = 520
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=520.1n

* CHECK dout1_20 Vdout1_20ck25 = 0 time = 520
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=520.1n

* CHECK dout1_21 Vdout1_21ck25 = 0 time = 520
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=520.1n

* CHECK dout1_22 Vdout1_22ck25 = 1.8 time = 520
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=520.1n

* CHECK dout1_23 Vdout1_23ck25 = 0 time = 520
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=520.1n

* CHECK dout1_24 Vdout1_24ck25 = 1.8 time = 520
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=520.1n

* CHECK dout1_25 Vdout1_25ck25 = 0 time = 520
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=520.1n

* CHECK dout1_26 Vdout1_26ck25 = 1.8 time = 520
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=520.1n

* CHECK dout1_27 Vdout1_27ck25 = 1.8 time = 520
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=520.1n

* CHECK dout1_28 Vdout1_28ck25 = 0 time = 520
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=520.1n

* CHECK dout1_29 Vdout1_29ck25 = 0 time = 520
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=520.1n

* CHECK dout1_30 Vdout1_30ck25 = 1.8 time = 520
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=520.1n

* CHECK dout1_31 Vdout1_31ck25 = 1.8 time = 520
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=520.1n

* CHECK dout2_0 Vdout2_0ck27 = 1.8 time = 560
.meas tran vdout2_0ck27 FIND v(dout2_0) AT=560.1n

* CHECK dout2_1 Vdout2_1ck27 = 0 time = 560
.meas tran vdout2_1ck27 FIND v(dout2_1) AT=560.1n

* CHECK dout2_2 Vdout2_2ck27 = 1.8 time = 560
.meas tran vdout2_2ck27 FIND v(dout2_2) AT=560.1n

* CHECK dout2_3 Vdout2_3ck27 = 1.8 time = 560
.meas tran vdout2_3ck27 FIND v(dout2_3) AT=560.1n

* CHECK dout2_4 Vdout2_4ck27 = 1.8 time = 560
.meas tran vdout2_4ck27 FIND v(dout2_4) AT=560.1n

* CHECK dout2_5 Vdout2_5ck27 = 0 time = 560
.meas tran vdout2_5ck27 FIND v(dout2_5) AT=560.1n

* CHECK dout2_6 Vdout2_6ck27 = 1.8 time = 560
.meas tran vdout2_6ck27 FIND v(dout2_6) AT=560.1n

* CHECK dout2_7 Vdout2_7ck27 = 0 time = 560
.meas tran vdout2_7ck27 FIND v(dout2_7) AT=560.1n

* CHECK dout2_8 Vdout2_8ck27 = 1.8 time = 560
.meas tran vdout2_8ck27 FIND v(dout2_8) AT=560.1n

* CHECK dout2_9 Vdout2_9ck27 = 1.8 time = 560
.meas tran vdout2_9ck27 FIND v(dout2_9) AT=560.1n

* CHECK dout2_10 Vdout2_10ck27 = 0 time = 560
.meas tran vdout2_10ck27 FIND v(dout2_10) AT=560.1n

* CHECK dout2_11 Vdout2_11ck27 = 1.8 time = 560
.meas tran vdout2_11ck27 FIND v(dout2_11) AT=560.1n

* CHECK dout2_12 Vdout2_12ck27 = 0 time = 560
.meas tran vdout2_12ck27 FIND v(dout2_12) AT=560.1n

* CHECK dout2_13 Vdout2_13ck27 = 1.8 time = 560
.meas tran vdout2_13ck27 FIND v(dout2_13) AT=560.1n

* CHECK dout2_14 Vdout2_14ck27 = 1.8 time = 560
.meas tran vdout2_14ck27 FIND v(dout2_14) AT=560.1n

* CHECK dout2_15 Vdout2_15ck27 = 1.8 time = 560
.meas tran vdout2_15ck27 FIND v(dout2_15) AT=560.1n

* CHECK dout2_16 Vdout2_16ck27 = 1.8 time = 560
.meas tran vdout2_16ck27 FIND v(dout2_16) AT=560.1n

* CHECK dout2_17 Vdout2_17ck27 = 1.8 time = 560
.meas tran vdout2_17ck27 FIND v(dout2_17) AT=560.1n

* CHECK dout2_18 Vdout2_18ck27 = 0 time = 560
.meas tran vdout2_18ck27 FIND v(dout2_18) AT=560.1n

* CHECK dout2_19 Vdout2_19ck27 = 1.8 time = 560
.meas tran vdout2_19ck27 FIND v(dout2_19) AT=560.1n

* CHECK dout2_20 Vdout2_20ck27 = 0 time = 560
.meas tran vdout2_20ck27 FIND v(dout2_20) AT=560.1n

* CHECK dout2_21 Vdout2_21ck27 = 0 time = 560
.meas tran vdout2_21ck27 FIND v(dout2_21) AT=560.1n

* CHECK dout2_22 Vdout2_22ck27 = 1.8 time = 560
.meas tran vdout2_22ck27 FIND v(dout2_22) AT=560.1n

* CHECK dout2_23 Vdout2_23ck27 = 0 time = 560
.meas tran vdout2_23ck27 FIND v(dout2_23) AT=560.1n

* CHECK dout2_24 Vdout2_24ck27 = 0 time = 560
.meas tran vdout2_24ck27 FIND v(dout2_24) AT=560.1n

* CHECK dout2_25 Vdout2_25ck27 = 1.8 time = 560
.meas tran vdout2_25ck27 FIND v(dout2_25) AT=560.1n

* CHECK dout2_26 Vdout2_26ck27 = 0 time = 560
.meas tran vdout2_26ck27 FIND v(dout2_26) AT=560.1n

* CHECK dout2_27 Vdout2_27ck27 = 0 time = 560
.meas tran vdout2_27ck27 FIND v(dout2_27) AT=560.1n

* CHECK dout2_28 Vdout2_28ck27 = 1.8 time = 560
.meas tran vdout2_28ck27 FIND v(dout2_28) AT=560.1n

* CHECK dout2_29 Vdout2_29ck27 = 1.8 time = 560
.meas tran vdout2_29ck27 FIND v(dout2_29) AT=560.1n

* CHECK dout2_30 Vdout2_30ck27 = 0 time = 560
.meas tran vdout2_30ck27 FIND v(dout2_30) AT=560.1n

* CHECK dout2_31 Vdout2_31ck27 = 0 time = 560
.meas tran vdout2_31ck27 FIND v(dout2_31) AT=560.1n

* CHECK dout2_0 Vdout2_0ck28 = 0 time = 580
.meas tran vdout2_0ck28 FIND v(dout2_0) AT=580.1n

* CHECK dout2_1 Vdout2_1ck28 = 0 time = 580
.meas tran vdout2_1ck28 FIND v(dout2_1) AT=580.1n

* CHECK dout2_2 Vdout2_2ck28 = 0 time = 580
.meas tran vdout2_2ck28 FIND v(dout2_2) AT=580.1n

* CHECK dout2_3 Vdout2_3ck28 = 1.8 time = 580
.meas tran vdout2_3ck28 FIND v(dout2_3) AT=580.1n

* CHECK dout2_4 Vdout2_4ck28 = 0 time = 580
.meas tran vdout2_4ck28 FIND v(dout2_4) AT=580.1n

* CHECK dout2_5 Vdout2_5ck28 = 1.8 time = 580
.meas tran vdout2_5ck28 FIND v(dout2_5) AT=580.1n

* CHECK dout2_6 Vdout2_6ck28 = 1.8 time = 580
.meas tran vdout2_6ck28 FIND v(dout2_6) AT=580.1n

* CHECK dout2_7 Vdout2_7ck28 = 1.8 time = 580
.meas tran vdout2_7ck28 FIND v(dout2_7) AT=580.1n

* CHECK dout2_8 Vdout2_8ck28 = 0 time = 580
.meas tran vdout2_8ck28 FIND v(dout2_8) AT=580.1n

* CHECK dout2_9 Vdout2_9ck28 = 0 time = 580
.meas tran vdout2_9ck28 FIND v(dout2_9) AT=580.1n

* CHECK dout2_10 Vdout2_10ck28 = 1.8 time = 580
.meas tran vdout2_10ck28 FIND v(dout2_10) AT=580.1n

* CHECK dout2_11 Vdout2_11ck28 = 0 time = 580
.meas tran vdout2_11ck28 FIND v(dout2_11) AT=580.1n

* CHECK dout2_12 Vdout2_12ck28 = 1.8 time = 580
.meas tran vdout2_12ck28 FIND v(dout2_12) AT=580.1n

* CHECK dout2_13 Vdout2_13ck28 = 0 time = 580
.meas tran vdout2_13ck28 FIND v(dout2_13) AT=580.1n

* CHECK dout2_14 Vdout2_14ck28 = 0 time = 580
.meas tran vdout2_14ck28 FIND v(dout2_14) AT=580.1n

* CHECK dout2_15 Vdout2_15ck28 = 0 time = 580
.meas tran vdout2_15ck28 FIND v(dout2_15) AT=580.1n

* CHECK dout2_16 Vdout2_16ck28 = 0 time = 580
.meas tran vdout2_16ck28 FIND v(dout2_16) AT=580.1n

* CHECK dout2_17 Vdout2_17ck28 = 1.8 time = 580
.meas tran vdout2_17ck28 FIND v(dout2_17) AT=580.1n

* CHECK dout2_18 Vdout2_18ck28 = 1.8 time = 580
.meas tran vdout2_18ck28 FIND v(dout2_18) AT=580.1n

* CHECK dout2_19 Vdout2_19ck28 = 0 time = 580
.meas tran vdout2_19ck28 FIND v(dout2_19) AT=580.1n

* CHECK dout2_20 Vdout2_20ck28 = 1.8 time = 580
.meas tran vdout2_20ck28 FIND v(dout2_20) AT=580.1n

* CHECK dout2_21 Vdout2_21ck28 = 1.8 time = 580
.meas tran vdout2_21ck28 FIND v(dout2_21) AT=580.1n

* CHECK dout2_22 Vdout2_22ck28 = 1.8 time = 580
.meas tran vdout2_22ck28 FIND v(dout2_22) AT=580.1n

* CHECK dout2_23 Vdout2_23ck28 = 1.8 time = 580
.meas tran vdout2_23ck28 FIND v(dout2_23) AT=580.1n

* CHECK dout2_24 Vdout2_24ck28 = 1.8 time = 580
.meas tran vdout2_24ck28 FIND v(dout2_24) AT=580.1n

* CHECK dout2_25 Vdout2_25ck28 = 0 time = 580
.meas tran vdout2_25ck28 FIND v(dout2_25) AT=580.1n

* CHECK dout2_26 Vdout2_26ck28 = 1.8 time = 580
.meas tran vdout2_26ck28 FIND v(dout2_26) AT=580.1n

* CHECK dout2_27 Vdout2_27ck28 = 0 time = 580
.meas tran vdout2_27ck28 FIND v(dout2_27) AT=580.1n

* CHECK dout2_28 Vdout2_28ck28 = 1.8 time = 580
.meas tran vdout2_28ck28 FIND v(dout2_28) AT=580.1n

* CHECK dout2_29 Vdout2_29ck28 = 0 time = 580
.meas tran vdout2_29ck28 FIND v(dout2_29) AT=580.1n

* CHECK dout2_30 Vdout2_30ck28 = 0 time = 580
.meas tran vdout2_30ck28 FIND v(dout2_30) AT=580.1n

* CHECK dout2_31 Vdout2_31ck28 = 1.8 time = 580
.meas tran vdout2_31ck28 FIND v(dout2_31) AT=580.1n

* CHECK dout2_0 Vdout2_0ck29 = 1.8 time = 600
.meas tran vdout2_0ck29 FIND v(dout2_0) AT=600.1n

* CHECK dout2_1 Vdout2_1ck29 = 1.8 time = 600
.meas tran vdout2_1ck29 FIND v(dout2_1) AT=600.1n

* CHECK dout2_2 Vdout2_2ck29 = 1.8 time = 600
.meas tran vdout2_2ck29 FIND v(dout2_2) AT=600.1n

* CHECK dout2_3 Vdout2_3ck29 = 1.8 time = 600
.meas tran vdout2_3ck29 FIND v(dout2_3) AT=600.1n

* CHECK dout2_4 Vdout2_4ck29 = 1.8 time = 600
.meas tran vdout2_4ck29 FIND v(dout2_4) AT=600.1n

* CHECK dout2_5 Vdout2_5ck29 = 0 time = 600
.meas tran vdout2_5ck29 FIND v(dout2_5) AT=600.1n

* CHECK dout2_6 Vdout2_6ck29 = 0 time = 600
.meas tran vdout2_6ck29 FIND v(dout2_6) AT=600.1n

* CHECK dout2_7 Vdout2_7ck29 = 1.8 time = 600
.meas tran vdout2_7ck29 FIND v(dout2_7) AT=600.1n

* CHECK dout2_8 Vdout2_8ck29 = 0 time = 600
.meas tran vdout2_8ck29 FIND v(dout2_8) AT=600.1n

* CHECK dout2_9 Vdout2_9ck29 = 0 time = 600
.meas tran vdout2_9ck29 FIND v(dout2_9) AT=600.1n

* CHECK dout2_10 Vdout2_10ck29 = 0 time = 600
.meas tran vdout2_10ck29 FIND v(dout2_10) AT=600.1n

* CHECK dout2_11 Vdout2_11ck29 = 0 time = 600
.meas tran vdout2_11ck29 FIND v(dout2_11) AT=600.1n

* CHECK dout2_12 Vdout2_12ck29 = 0 time = 600
.meas tran vdout2_12ck29 FIND v(dout2_12) AT=600.1n

* CHECK dout2_13 Vdout2_13ck29 = 1.8 time = 600
.meas tran vdout2_13ck29 FIND v(dout2_13) AT=600.1n

* CHECK dout2_14 Vdout2_14ck29 = 1.8 time = 600
.meas tran vdout2_14ck29 FIND v(dout2_14) AT=600.1n

* CHECK dout2_15 Vdout2_15ck29 = 0 time = 600
.meas tran vdout2_15ck29 FIND v(dout2_15) AT=600.1n

* CHECK dout2_16 Vdout2_16ck29 = 0 time = 600
.meas tran vdout2_16ck29 FIND v(dout2_16) AT=600.1n

* CHECK dout2_17 Vdout2_17ck29 = 0 time = 600
.meas tran vdout2_17ck29 FIND v(dout2_17) AT=600.1n

* CHECK dout2_18 Vdout2_18ck29 = 0 time = 600
.meas tran vdout2_18ck29 FIND v(dout2_18) AT=600.1n

* CHECK dout2_19 Vdout2_19ck29 = 0 time = 600
.meas tran vdout2_19ck29 FIND v(dout2_19) AT=600.1n

* CHECK dout2_20 Vdout2_20ck29 = 0 time = 600
.meas tran vdout2_20ck29 FIND v(dout2_20) AT=600.1n

* CHECK dout2_21 Vdout2_21ck29 = 0 time = 600
.meas tran vdout2_21ck29 FIND v(dout2_21) AT=600.1n

* CHECK dout2_22 Vdout2_22ck29 = 1.8 time = 600
.meas tran vdout2_22ck29 FIND v(dout2_22) AT=600.1n

* CHECK dout2_23 Vdout2_23ck29 = 0 time = 600
.meas tran vdout2_23ck29 FIND v(dout2_23) AT=600.1n

* CHECK dout2_24 Vdout2_24ck29 = 1.8 time = 600
.meas tran vdout2_24ck29 FIND v(dout2_24) AT=600.1n

* CHECK dout2_25 Vdout2_25ck29 = 0 time = 600
.meas tran vdout2_25ck29 FIND v(dout2_25) AT=600.1n

* CHECK dout2_26 Vdout2_26ck29 = 1.8 time = 600
.meas tran vdout2_26ck29 FIND v(dout2_26) AT=600.1n

* CHECK dout2_27 Vdout2_27ck29 = 1.8 time = 600
.meas tran vdout2_27ck29 FIND v(dout2_27) AT=600.1n

* CHECK dout2_28 Vdout2_28ck29 = 0 time = 600
.meas tran vdout2_28ck29 FIND v(dout2_28) AT=600.1n

* CHECK dout2_29 Vdout2_29ck29 = 0 time = 600
.meas tran vdout2_29ck29 FIND v(dout2_29) AT=600.1n

* CHECK dout2_30 Vdout2_30ck29 = 1.8 time = 600
.meas tran vdout2_30ck29 FIND v(dout2_30) AT=600.1n

* CHECK dout2_31 Vdout2_31ck29 = 1.8 time = 600
.meas tran vdout2_31ck29 FIND v(dout2_31) AT=600.1n

* CHECK dout1_0 Vdout1_0ck30 = 0 time = 620
.meas tran vdout1_0ck30 FIND v(dout1_0) AT=620.1n

* CHECK dout1_1 Vdout1_1ck30 = 1.8 time = 620
.meas tran vdout1_1ck30 FIND v(dout1_1) AT=620.1n

* CHECK dout1_2 Vdout1_2ck30 = 1.8 time = 620
.meas tran vdout1_2ck30 FIND v(dout1_2) AT=620.1n

* CHECK dout1_3 Vdout1_3ck30 = 0 time = 620
.meas tran vdout1_3ck30 FIND v(dout1_3) AT=620.1n

* CHECK dout1_4 Vdout1_4ck30 = 0 time = 620
.meas tran vdout1_4ck30 FIND v(dout1_4) AT=620.1n

* CHECK dout1_5 Vdout1_5ck30 = 1.8 time = 620
.meas tran vdout1_5ck30 FIND v(dout1_5) AT=620.1n

* CHECK dout1_6 Vdout1_6ck30 = 1.8 time = 620
.meas tran vdout1_6ck30 FIND v(dout1_6) AT=620.1n

* CHECK dout1_7 Vdout1_7ck30 = 1.8 time = 620
.meas tran vdout1_7ck30 FIND v(dout1_7) AT=620.1n

* CHECK dout1_8 Vdout1_8ck30 = 0 time = 620
.meas tran vdout1_8ck30 FIND v(dout1_8) AT=620.1n

* CHECK dout1_9 Vdout1_9ck30 = 0 time = 620
.meas tran vdout1_9ck30 FIND v(dout1_9) AT=620.1n

* CHECK dout1_10 Vdout1_10ck30 = 1.8 time = 620
.meas tran vdout1_10ck30 FIND v(dout1_10) AT=620.1n

* CHECK dout1_11 Vdout1_11ck30 = 1.8 time = 620
.meas tran vdout1_11ck30 FIND v(dout1_11) AT=620.1n

* CHECK dout1_12 Vdout1_12ck30 = 0 time = 620
.meas tran vdout1_12ck30 FIND v(dout1_12) AT=620.1n

* CHECK dout1_13 Vdout1_13ck30 = 1.8 time = 620
.meas tran vdout1_13ck30 FIND v(dout1_13) AT=620.1n

* CHECK dout1_14 Vdout1_14ck30 = 1.8 time = 620
.meas tran vdout1_14ck30 FIND v(dout1_14) AT=620.1n

* CHECK dout1_15 Vdout1_15ck30 = 0 time = 620
.meas tran vdout1_15ck30 FIND v(dout1_15) AT=620.1n

* CHECK dout1_16 Vdout1_16ck30 = 1.8 time = 620
.meas tran vdout1_16ck30 FIND v(dout1_16) AT=620.1n

* CHECK dout1_17 Vdout1_17ck30 = 0 time = 620
.meas tran vdout1_17ck30 FIND v(dout1_17) AT=620.1n

* CHECK dout1_18 Vdout1_18ck30 = 0 time = 620
.meas tran vdout1_18ck30 FIND v(dout1_18) AT=620.1n

* CHECK dout1_19 Vdout1_19ck30 = 0 time = 620
.meas tran vdout1_19ck30 FIND v(dout1_19) AT=620.1n

* CHECK dout1_20 Vdout1_20ck30 = 0 time = 620
.meas tran vdout1_20ck30 FIND v(dout1_20) AT=620.1n

* CHECK dout1_21 Vdout1_21ck30 = 0 time = 620
.meas tran vdout1_21ck30 FIND v(dout1_21) AT=620.1n

* CHECK dout1_22 Vdout1_22ck30 = 0 time = 620
.meas tran vdout1_22ck30 FIND v(dout1_22) AT=620.1n

* CHECK dout1_23 Vdout1_23ck30 = 0 time = 620
.meas tran vdout1_23ck30 FIND v(dout1_23) AT=620.1n

* CHECK dout1_24 Vdout1_24ck30 = 0 time = 620
.meas tran vdout1_24ck30 FIND v(dout1_24) AT=620.1n

* CHECK dout1_25 Vdout1_25ck30 = 0 time = 620
.meas tran vdout1_25ck30 FIND v(dout1_25) AT=620.1n

* CHECK dout1_26 Vdout1_26ck30 = 1.8 time = 620
.meas tran vdout1_26ck30 FIND v(dout1_26) AT=620.1n

* CHECK dout1_27 Vdout1_27ck30 = 0 time = 620
.meas tran vdout1_27ck30 FIND v(dout1_27) AT=620.1n

* CHECK dout1_28 Vdout1_28ck30 = 0 time = 620
.meas tran vdout1_28ck30 FIND v(dout1_28) AT=620.1n

* CHECK dout1_29 Vdout1_29ck30 = 0 time = 620
.meas tran vdout1_29ck30 FIND v(dout1_29) AT=620.1n

* CHECK dout1_30 Vdout1_30ck30 = 0 time = 620
.meas tran vdout1_30ck30 FIND v(dout1_30) AT=620.1n

* CHECK dout1_31 Vdout1_31ck30 = 1.8 time = 620
.meas tran vdout1_31ck30 FIND v(dout1_31) AT=620.1n

* CHECK dout2_0 Vdout2_0ck31 = 1.8 time = 640
.meas tran vdout2_0ck31 FIND v(dout2_0) AT=640.1n

* CHECK dout2_1 Vdout2_1ck31 = 1.8 time = 640
.meas tran vdout2_1ck31 FIND v(dout2_1) AT=640.1n

* CHECK dout2_2 Vdout2_2ck31 = 1.8 time = 640
.meas tran vdout2_2ck31 FIND v(dout2_2) AT=640.1n

* CHECK dout2_3 Vdout2_3ck31 = 1.8 time = 640
.meas tran vdout2_3ck31 FIND v(dout2_3) AT=640.1n

* CHECK dout2_4 Vdout2_4ck31 = 1.8 time = 640
.meas tran vdout2_4ck31 FIND v(dout2_4) AT=640.1n

* CHECK dout2_5 Vdout2_5ck31 = 0 time = 640
.meas tran vdout2_5ck31 FIND v(dout2_5) AT=640.1n

* CHECK dout2_6 Vdout2_6ck31 = 0 time = 640
.meas tran vdout2_6ck31 FIND v(dout2_6) AT=640.1n

* CHECK dout2_7 Vdout2_7ck31 = 1.8 time = 640
.meas tran vdout2_7ck31 FIND v(dout2_7) AT=640.1n

* CHECK dout2_8 Vdout2_8ck31 = 0 time = 640
.meas tran vdout2_8ck31 FIND v(dout2_8) AT=640.1n

* CHECK dout2_9 Vdout2_9ck31 = 0 time = 640
.meas tran vdout2_9ck31 FIND v(dout2_9) AT=640.1n

* CHECK dout2_10 Vdout2_10ck31 = 0 time = 640
.meas tran vdout2_10ck31 FIND v(dout2_10) AT=640.1n

* CHECK dout2_11 Vdout2_11ck31 = 0 time = 640
.meas tran vdout2_11ck31 FIND v(dout2_11) AT=640.1n

* CHECK dout2_12 Vdout2_12ck31 = 0 time = 640
.meas tran vdout2_12ck31 FIND v(dout2_12) AT=640.1n

* CHECK dout2_13 Vdout2_13ck31 = 1.8 time = 640
.meas tran vdout2_13ck31 FIND v(dout2_13) AT=640.1n

* CHECK dout2_14 Vdout2_14ck31 = 1.8 time = 640
.meas tran vdout2_14ck31 FIND v(dout2_14) AT=640.1n

* CHECK dout2_15 Vdout2_15ck31 = 0 time = 640
.meas tran vdout2_15ck31 FIND v(dout2_15) AT=640.1n

* CHECK dout2_16 Vdout2_16ck31 = 0 time = 640
.meas tran vdout2_16ck31 FIND v(dout2_16) AT=640.1n

* CHECK dout2_17 Vdout2_17ck31 = 0 time = 640
.meas tran vdout2_17ck31 FIND v(dout2_17) AT=640.1n

* CHECK dout2_18 Vdout2_18ck31 = 0 time = 640
.meas tran vdout2_18ck31 FIND v(dout2_18) AT=640.1n

* CHECK dout2_19 Vdout2_19ck31 = 0 time = 640
.meas tran vdout2_19ck31 FIND v(dout2_19) AT=640.1n

* CHECK dout2_20 Vdout2_20ck31 = 0 time = 640
.meas tran vdout2_20ck31 FIND v(dout2_20) AT=640.1n

* CHECK dout2_21 Vdout2_21ck31 = 0 time = 640
.meas tran vdout2_21ck31 FIND v(dout2_21) AT=640.1n

* CHECK dout2_22 Vdout2_22ck31 = 1.8 time = 640
.meas tran vdout2_22ck31 FIND v(dout2_22) AT=640.1n

* CHECK dout2_23 Vdout2_23ck31 = 0 time = 640
.meas tran vdout2_23ck31 FIND v(dout2_23) AT=640.1n

* CHECK dout2_24 Vdout2_24ck31 = 1.8 time = 640
.meas tran vdout2_24ck31 FIND v(dout2_24) AT=640.1n

* CHECK dout2_25 Vdout2_25ck31 = 0 time = 640
.meas tran vdout2_25ck31 FIND v(dout2_25) AT=640.1n

* CHECK dout2_26 Vdout2_26ck31 = 1.8 time = 640
.meas tran vdout2_26ck31 FIND v(dout2_26) AT=640.1n

* CHECK dout2_27 Vdout2_27ck31 = 1.8 time = 640
.meas tran vdout2_27ck31 FIND v(dout2_27) AT=640.1n

* CHECK dout2_28 Vdout2_28ck31 = 0 time = 640
.meas tran vdout2_28ck31 FIND v(dout2_28) AT=640.1n

* CHECK dout2_29 Vdout2_29ck31 = 0 time = 640
.meas tran vdout2_29ck31 FIND v(dout2_29) AT=640.1n

* CHECK dout2_30 Vdout2_30ck31 = 1.8 time = 640
.meas tran vdout2_30ck31 FIND v(dout2_30) AT=640.1n

* CHECK dout2_31 Vdout2_31ck31 = 1.8 time = 640
.meas tran vdout2_31ck31 FIND v(dout2_31) AT=640.1n

* CHECK dout1_0 Vdout1_0ck34 = 0 time = 700
.meas tran vdout1_0ck34 FIND v(dout1_0) AT=700.1n

* CHECK dout1_1 Vdout1_1ck34 = 0 time = 700
.meas tran vdout1_1ck34 FIND v(dout1_1) AT=700.1n

* CHECK dout1_2 Vdout1_2ck34 = 0 time = 700
.meas tran vdout1_2ck34 FIND v(dout1_2) AT=700.1n

* CHECK dout1_3 Vdout1_3ck34 = 0 time = 700
.meas tran vdout1_3ck34 FIND v(dout1_3) AT=700.1n

* CHECK dout1_4 Vdout1_4ck34 = 0 time = 700
.meas tran vdout1_4ck34 FIND v(dout1_4) AT=700.1n

* CHECK dout1_5 Vdout1_5ck34 = 1.8 time = 700
.meas tran vdout1_5ck34 FIND v(dout1_5) AT=700.1n

* CHECK dout1_6 Vdout1_6ck34 = 1.8 time = 700
.meas tran vdout1_6ck34 FIND v(dout1_6) AT=700.1n

* CHECK dout1_7 Vdout1_7ck34 = 0 time = 700
.meas tran vdout1_7ck34 FIND v(dout1_7) AT=700.1n

* CHECK dout1_8 Vdout1_8ck34 = 0 time = 700
.meas tran vdout1_8ck34 FIND v(dout1_8) AT=700.1n

* CHECK dout1_9 Vdout1_9ck34 = 1.8 time = 700
.meas tran vdout1_9ck34 FIND v(dout1_9) AT=700.1n

* CHECK dout1_10 Vdout1_10ck34 = 0 time = 700
.meas tran vdout1_10ck34 FIND v(dout1_10) AT=700.1n

* CHECK dout1_11 Vdout1_11ck34 = 1.8 time = 700
.meas tran vdout1_11ck34 FIND v(dout1_11) AT=700.1n

* CHECK dout1_12 Vdout1_12ck34 = 0 time = 700
.meas tran vdout1_12ck34 FIND v(dout1_12) AT=700.1n

* CHECK dout1_13 Vdout1_13ck34 = 1.8 time = 700
.meas tran vdout1_13ck34 FIND v(dout1_13) AT=700.1n

* CHECK dout1_14 Vdout1_14ck34 = 1.8 time = 700
.meas tran vdout1_14ck34 FIND v(dout1_14) AT=700.1n

* CHECK dout1_15 Vdout1_15ck34 = 1.8 time = 700
.meas tran vdout1_15ck34 FIND v(dout1_15) AT=700.1n

* CHECK dout1_16 Vdout1_16ck34 = 1.8 time = 700
.meas tran vdout1_16ck34 FIND v(dout1_16) AT=700.1n

* CHECK dout1_17 Vdout1_17ck34 = 0 time = 700
.meas tran vdout1_17ck34 FIND v(dout1_17) AT=700.1n

* CHECK dout1_18 Vdout1_18ck34 = 1.8 time = 700
.meas tran vdout1_18ck34 FIND v(dout1_18) AT=700.1n

* CHECK dout1_19 Vdout1_19ck34 = 1.8 time = 700
.meas tran vdout1_19ck34 FIND v(dout1_19) AT=700.1n

* CHECK dout1_20 Vdout1_20ck34 = 1.8 time = 700
.meas tran vdout1_20ck34 FIND v(dout1_20) AT=700.1n

* CHECK dout1_21 Vdout1_21ck34 = 1.8 time = 700
.meas tran vdout1_21ck34 FIND v(dout1_21) AT=700.1n

* CHECK dout1_22 Vdout1_22ck34 = 1.8 time = 700
.meas tran vdout1_22ck34 FIND v(dout1_22) AT=700.1n

* CHECK dout1_23 Vdout1_23ck34 = 1.8 time = 700
.meas tran vdout1_23ck34 FIND v(dout1_23) AT=700.1n

* CHECK dout1_24 Vdout1_24ck34 = 1.8 time = 700
.meas tran vdout1_24ck34 FIND v(dout1_24) AT=700.1n

* CHECK dout1_25 Vdout1_25ck34 = 1.8 time = 700
.meas tran vdout1_25ck34 FIND v(dout1_25) AT=700.1n

* CHECK dout1_26 Vdout1_26ck34 = 0 time = 700
.meas tran vdout1_26ck34 FIND v(dout1_26) AT=700.1n

* CHECK dout1_27 Vdout1_27ck34 = 0 time = 700
.meas tran vdout1_27ck34 FIND v(dout1_27) AT=700.1n

* CHECK dout1_28 Vdout1_28ck34 = 0 time = 700
.meas tran vdout1_28ck34 FIND v(dout1_28) AT=700.1n

* CHECK dout1_29 Vdout1_29ck34 = 0 time = 700
.meas tran vdout1_29ck34 FIND v(dout1_29) AT=700.1n

* CHECK dout1_30 Vdout1_30ck34 = 0 time = 700
.meas tran vdout1_30ck34 FIND v(dout1_30) AT=700.1n

* CHECK dout1_31 Vdout1_31ck34 = 0 time = 700
.meas tran vdout1_31ck34 FIND v(dout1_31) AT=700.1n

* CHECK dout2_0 Vdout2_0ck34 = 0 time = 700
.meas tran vdout2_0ck34 FIND v(dout2_0) AT=700.1n

* CHECK dout2_1 Vdout2_1ck34 = 0 time = 700
.meas tran vdout2_1ck34 FIND v(dout2_1) AT=700.1n

* CHECK dout2_2 Vdout2_2ck34 = 0 time = 700
.meas tran vdout2_2ck34 FIND v(dout2_2) AT=700.1n

* CHECK dout2_3 Vdout2_3ck34 = 0 time = 700
.meas tran vdout2_3ck34 FIND v(dout2_3) AT=700.1n

* CHECK dout2_4 Vdout2_4ck34 = 0 time = 700
.meas tran vdout2_4ck34 FIND v(dout2_4) AT=700.1n

* CHECK dout2_5 Vdout2_5ck34 = 1.8 time = 700
.meas tran vdout2_5ck34 FIND v(dout2_5) AT=700.1n

* CHECK dout2_6 Vdout2_6ck34 = 1.8 time = 700
.meas tran vdout2_6ck34 FIND v(dout2_6) AT=700.1n

* CHECK dout2_7 Vdout2_7ck34 = 0 time = 700
.meas tran vdout2_7ck34 FIND v(dout2_7) AT=700.1n

* CHECK dout2_8 Vdout2_8ck34 = 0 time = 700
.meas tran vdout2_8ck34 FIND v(dout2_8) AT=700.1n

* CHECK dout2_9 Vdout2_9ck34 = 1.8 time = 700
.meas tran vdout2_9ck34 FIND v(dout2_9) AT=700.1n

* CHECK dout2_10 Vdout2_10ck34 = 0 time = 700
.meas tran vdout2_10ck34 FIND v(dout2_10) AT=700.1n

* CHECK dout2_11 Vdout2_11ck34 = 1.8 time = 700
.meas tran vdout2_11ck34 FIND v(dout2_11) AT=700.1n

* CHECK dout2_12 Vdout2_12ck34 = 0 time = 700
.meas tran vdout2_12ck34 FIND v(dout2_12) AT=700.1n

* CHECK dout2_13 Vdout2_13ck34 = 1.8 time = 700
.meas tran vdout2_13ck34 FIND v(dout2_13) AT=700.1n

* CHECK dout2_14 Vdout2_14ck34 = 1.8 time = 700
.meas tran vdout2_14ck34 FIND v(dout2_14) AT=700.1n

* CHECK dout2_15 Vdout2_15ck34 = 1.8 time = 700
.meas tran vdout2_15ck34 FIND v(dout2_15) AT=700.1n

* CHECK dout2_16 Vdout2_16ck34 = 1.8 time = 700
.meas tran vdout2_16ck34 FIND v(dout2_16) AT=700.1n

* CHECK dout2_17 Vdout2_17ck34 = 0 time = 700
.meas tran vdout2_17ck34 FIND v(dout2_17) AT=700.1n

* CHECK dout2_18 Vdout2_18ck34 = 1.8 time = 700
.meas tran vdout2_18ck34 FIND v(dout2_18) AT=700.1n

* CHECK dout2_19 Vdout2_19ck34 = 1.8 time = 700
.meas tran vdout2_19ck34 FIND v(dout2_19) AT=700.1n

* CHECK dout2_20 Vdout2_20ck34 = 1.8 time = 700
.meas tran vdout2_20ck34 FIND v(dout2_20) AT=700.1n

* CHECK dout2_21 Vdout2_21ck34 = 1.8 time = 700
.meas tran vdout2_21ck34 FIND v(dout2_21) AT=700.1n

* CHECK dout2_22 Vdout2_22ck34 = 1.8 time = 700
.meas tran vdout2_22ck34 FIND v(dout2_22) AT=700.1n

* CHECK dout2_23 Vdout2_23ck34 = 1.8 time = 700
.meas tran vdout2_23ck34 FIND v(dout2_23) AT=700.1n

* CHECK dout2_24 Vdout2_24ck34 = 1.8 time = 700
.meas tran vdout2_24ck34 FIND v(dout2_24) AT=700.1n

* CHECK dout2_25 Vdout2_25ck34 = 1.8 time = 700
.meas tran vdout2_25ck34 FIND v(dout2_25) AT=700.1n

* CHECK dout2_26 Vdout2_26ck34 = 0 time = 700
.meas tran vdout2_26ck34 FIND v(dout2_26) AT=700.1n

* CHECK dout2_27 Vdout2_27ck34 = 0 time = 700
.meas tran vdout2_27ck34 FIND v(dout2_27) AT=700.1n

* CHECK dout2_28 Vdout2_28ck34 = 0 time = 700
.meas tran vdout2_28ck34 FIND v(dout2_28) AT=700.1n

* CHECK dout2_29 Vdout2_29ck34 = 0 time = 700
.meas tran vdout2_29ck34 FIND v(dout2_29) AT=700.1n

* CHECK dout2_30 Vdout2_30ck34 = 0 time = 700
.meas tran vdout2_30ck34 FIND v(dout2_30) AT=700.1n

* CHECK dout2_31 Vdout2_31ck34 = 0 time = 700
.meas tran vdout2_31ck34 FIND v(dout2_31) AT=700.1n

* CHECK dout1_0 Vdout1_0ck35 = 0 time = 720
.meas tran vdout1_0ck35 FIND v(dout1_0) AT=720.1n

* CHECK dout1_1 Vdout1_1ck35 = 1.8 time = 720
.meas tran vdout1_1ck35 FIND v(dout1_1) AT=720.1n

* CHECK dout1_2 Vdout1_2ck35 = 0 time = 720
.meas tran vdout1_2ck35 FIND v(dout1_2) AT=720.1n

* CHECK dout1_3 Vdout1_3ck35 = 0 time = 720
.meas tran vdout1_3ck35 FIND v(dout1_3) AT=720.1n

* CHECK dout1_4 Vdout1_4ck35 = 0 time = 720
.meas tran vdout1_4ck35 FIND v(dout1_4) AT=720.1n

* CHECK dout1_5 Vdout1_5ck35 = 0 time = 720
.meas tran vdout1_5ck35 FIND v(dout1_5) AT=720.1n

* CHECK dout1_6 Vdout1_6ck35 = 1.8 time = 720
.meas tran vdout1_6ck35 FIND v(dout1_6) AT=720.1n

* CHECK dout1_7 Vdout1_7ck35 = 1.8 time = 720
.meas tran vdout1_7ck35 FIND v(dout1_7) AT=720.1n

* CHECK dout1_8 Vdout1_8ck35 = 0 time = 720
.meas tran vdout1_8ck35 FIND v(dout1_8) AT=720.1n

* CHECK dout1_9 Vdout1_9ck35 = 0 time = 720
.meas tran vdout1_9ck35 FIND v(dout1_9) AT=720.1n

* CHECK dout1_10 Vdout1_10ck35 = 1.8 time = 720
.meas tran vdout1_10ck35 FIND v(dout1_10) AT=720.1n

* CHECK dout1_11 Vdout1_11ck35 = 0 time = 720
.meas tran vdout1_11ck35 FIND v(dout1_11) AT=720.1n

* CHECK dout1_12 Vdout1_12ck35 = 1.8 time = 720
.meas tran vdout1_12ck35 FIND v(dout1_12) AT=720.1n

* CHECK dout1_13 Vdout1_13ck35 = 1.8 time = 720
.meas tran vdout1_13ck35 FIND v(dout1_13) AT=720.1n

* CHECK dout1_14 Vdout1_14ck35 = 1.8 time = 720
.meas tran vdout1_14ck35 FIND v(dout1_14) AT=720.1n

* CHECK dout1_15 Vdout1_15ck35 = 0 time = 720
.meas tran vdout1_15ck35 FIND v(dout1_15) AT=720.1n

* CHECK dout1_16 Vdout1_16ck35 = 1.8 time = 720
.meas tran vdout1_16ck35 FIND v(dout1_16) AT=720.1n

* CHECK dout1_17 Vdout1_17ck35 = 0 time = 720
.meas tran vdout1_17ck35 FIND v(dout1_17) AT=720.1n

* CHECK dout1_18 Vdout1_18ck35 = 1.8 time = 720
.meas tran vdout1_18ck35 FIND v(dout1_18) AT=720.1n

* CHECK dout1_19 Vdout1_19ck35 = 0 time = 720
.meas tran vdout1_19ck35 FIND v(dout1_19) AT=720.1n

* CHECK dout1_20 Vdout1_20ck35 = 0 time = 720
.meas tran vdout1_20ck35 FIND v(dout1_20) AT=720.1n

* CHECK dout1_21 Vdout1_21ck35 = 1.8 time = 720
.meas tran vdout1_21ck35 FIND v(dout1_21) AT=720.1n

* CHECK dout1_22 Vdout1_22ck35 = 0 time = 720
.meas tran vdout1_22ck35 FIND v(dout1_22) AT=720.1n

* CHECK dout1_23 Vdout1_23ck35 = 1.8 time = 720
.meas tran vdout1_23ck35 FIND v(dout1_23) AT=720.1n

* CHECK dout1_24 Vdout1_24ck35 = 0 time = 720
.meas tran vdout1_24ck35 FIND v(dout1_24) AT=720.1n

* CHECK dout1_25 Vdout1_25ck35 = 0 time = 720
.meas tran vdout1_25ck35 FIND v(dout1_25) AT=720.1n

* CHECK dout1_26 Vdout1_26ck35 = 0 time = 720
.meas tran vdout1_26ck35 FIND v(dout1_26) AT=720.1n

* CHECK dout1_27 Vdout1_27ck35 = 1.8 time = 720
.meas tran vdout1_27ck35 FIND v(dout1_27) AT=720.1n

* CHECK dout1_28 Vdout1_28ck35 = 0 time = 720
.meas tran vdout1_28ck35 FIND v(dout1_28) AT=720.1n

* CHECK dout1_29 Vdout1_29ck35 = 1.8 time = 720
.meas tran vdout1_29ck35 FIND v(dout1_29) AT=720.1n

* CHECK dout1_30 Vdout1_30ck35 = 1.8 time = 720
.meas tran vdout1_30ck35 FIND v(dout1_30) AT=720.1n

* CHECK dout1_31 Vdout1_31ck35 = 0 time = 720
.meas tran vdout1_31ck35 FIND v(dout1_31) AT=720.1n

* CHECK dout2_0 Vdout2_0ck35 = 0 time = 720
.meas tran vdout2_0ck35 FIND v(dout2_0) AT=720.1n

* CHECK dout2_1 Vdout2_1ck35 = 1.8 time = 720
.meas tran vdout2_1ck35 FIND v(dout2_1) AT=720.1n

* CHECK dout2_2 Vdout2_2ck35 = 0 time = 720
.meas tran vdout2_2ck35 FIND v(dout2_2) AT=720.1n

* CHECK dout2_3 Vdout2_3ck35 = 0 time = 720
.meas tran vdout2_3ck35 FIND v(dout2_3) AT=720.1n

* CHECK dout2_4 Vdout2_4ck35 = 0 time = 720
.meas tran vdout2_4ck35 FIND v(dout2_4) AT=720.1n

* CHECK dout2_5 Vdout2_5ck35 = 1.8 time = 720
.meas tran vdout2_5ck35 FIND v(dout2_5) AT=720.1n

* CHECK dout2_6 Vdout2_6ck35 = 1.8 time = 720
.meas tran vdout2_6ck35 FIND v(dout2_6) AT=720.1n

* CHECK dout2_7 Vdout2_7ck35 = 1.8 time = 720
.meas tran vdout2_7ck35 FIND v(dout2_7) AT=720.1n

* CHECK dout2_8 Vdout2_8ck35 = 0 time = 720
.meas tran vdout2_8ck35 FIND v(dout2_8) AT=720.1n

* CHECK dout2_9 Vdout2_9ck35 = 0 time = 720
.meas tran vdout2_9ck35 FIND v(dout2_9) AT=720.1n

* CHECK dout2_10 Vdout2_10ck35 = 0 time = 720
.meas tran vdout2_10ck35 FIND v(dout2_10) AT=720.1n

* CHECK dout2_11 Vdout2_11ck35 = 1.8 time = 720
.meas tran vdout2_11ck35 FIND v(dout2_11) AT=720.1n

* CHECK dout2_12 Vdout2_12ck35 = 1.8 time = 720
.meas tran vdout2_12ck35 FIND v(dout2_12) AT=720.1n

* CHECK dout2_13 Vdout2_13ck35 = 1.8 time = 720
.meas tran vdout2_13ck35 FIND v(dout2_13) AT=720.1n

* CHECK dout2_14 Vdout2_14ck35 = 1.8 time = 720
.meas tran vdout2_14ck35 FIND v(dout2_14) AT=720.1n

* CHECK dout2_15 Vdout2_15ck35 = 1.8 time = 720
.meas tran vdout2_15ck35 FIND v(dout2_15) AT=720.1n

* CHECK dout2_16 Vdout2_16ck35 = 0 time = 720
.meas tran vdout2_16ck35 FIND v(dout2_16) AT=720.1n

* CHECK dout2_17 Vdout2_17ck35 = 1.8 time = 720
.meas tran vdout2_17ck35 FIND v(dout2_17) AT=720.1n

* CHECK dout2_18 Vdout2_18ck35 = 0 time = 720
.meas tran vdout2_18ck35 FIND v(dout2_18) AT=720.1n

* CHECK dout2_19 Vdout2_19ck35 = 1.8 time = 720
.meas tran vdout2_19ck35 FIND v(dout2_19) AT=720.1n

* CHECK dout2_20 Vdout2_20ck35 = 1.8 time = 720
.meas tran vdout2_20ck35 FIND v(dout2_20) AT=720.1n

* CHECK dout2_21 Vdout2_21ck35 = 1.8 time = 720
.meas tran vdout2_21ck35 FIND v(dout2_21) AT=720.1n

* CHECK dout2_22 Vdout2_22ck35 = 0 time = 720
.meas tran vdout2_22ck35 FIND v(dout2_22) AT=720.1n

* CHECK dout2_23 Vdout2_23ck35 = 1.8 time = 720
.meas tran vdout2_23ck35 FIND v(dout2_23) AT=720.1n

* CHECK dout2_24 Vdout2_24ck35 = 1.8 time = 720
.meas tran vdout2_24ck35 FIND v(dout2_24) AT=720.1n

* CHECK dout2_25 Vdout2_25ck35 = 0 time = 720
.meas tran vdout2_25ck35 FIND v(dout2_25) AT=720.1n

* CHECK dout2_26 Vdout2_26ck35 = 1.8 time = 720
.meas tran vdout2_26ck35 FIND v(dout2_26) AT=720.1n

* CHECK dout2_27 Vdout2_27ck35 = 0 time = 720
.meas tran vdout2_27ck35 FIND v(dout2_27) AT=720.1n

* CHECK dout2_28 Vdout2_28ck35 = 1.8 time = 720
.meas tran vdout2_28ck35 FIND v(dout2_28) AT=720.1n

* CHECK dout2_29 Vdout2_29ck35 = 1.8 time = 720
.meas tran vdout2_29ck35 FIND v(dout2_29) AT=720.1n

* CHECK dout2_30 Vdout2_30ck35 = 1.8 time = 720
.meas tran vdout2_30ck35 FIND v(dout2_30) AT=720.1n

* CHECK dout2_31 Vdout2_31ck35 = 1.8 time = 720
.meas tran vdout2_31ck35 FIND v(dout2_31) AT=720.1n

* CHECK dout1_0 Vdout1_0ck36 = 0 time = 740
.meas tran vdout1_0ck36 FIND v(dout1_0) AT=740.1n

* CHECK dout1_1 Vdout1_1ck36 = 1.8 time = 740
.meas tran vdout1_1ck36 FIND v(dout1_1) AT=740.1n

* CHECK dout1_2 Vdout1_2ck36 = 0 time = 740
.meas tran vdout1_2ck36 FIND v(dout1_2) AT=740.1n

* CHECK dout1_3 Vdout1_3ck36 = 0 time = 740
.meas tran vdout1_3ck36 FIND v(dout1_3) AT=740.1n

* CHECK dout1_4 Vdout1_4ck36 = 0 time = 740
.meas tran vdout1_4ck36 FIND v(dout1_4) AT=740.1n

* CHECK dout1_5 Vdout1_5ck36 = 1.8 time = 740
.meas tran vdout1_5ck36 FIND v(dout1_5) AT=740.1n

* CHECK dout1_6 Vdout1_6ck36 = 1.8 time = 740
.meas tran vdout1_6ck36 FIND v(dout1_6) AT=740.1n

* CHECK dout1_7 Vdout1_7ck36 = 1.8 time = 740
.meas tran vdout1_7ck36 FIND v(dout1_7) AT=740.1n

* CHECK dout1_8 Vdout1_8ck36 = 0 time = 740
.meas tran vdout1_8ck36 FIND v(dout1_8) AT=740.1n

* CHECK dout1_9 Vdout1_9ck36 = 0 time = 740
.meas tran vdout1_9ck36 FIND v(dout1_9) AT=740.1n

* CHECK dout1_10 Vdout1_10ck36 = 0 time = 740
.meas tran vdout1_10ck36 FIND v(dout1_10) AT=740.1n

* CHECK dout1_11 Vdout1_11ck36 = 1.8 time = 740
.meas tran vdout1_11ck36 FIND v(dout1_11) AT=740.1n

* CHECK dout1_12 Vdout1_12ck36 = 1.8 time = 740
.meas tran vdout1_12ck36 FIND v(dout1_12) AT=740.1n

* CHECK dout1_13 Vdout1_13ck36 = 1.8 time = 740
.meas tran vdout1_13ck36 FIND v(dout1_13) AT=740.1n

* CHECK dout1_14 Vdout1_14ck36 = 1.8 time = 740
.meas tran vdout1_14ck36 FIND v(dout1_14) AT=740.1n

* CHECK dout1_15 Vdout1_15ck36 = 1.8 time = 740
.meas tran vdout1_15ck36 FIND v(dout1_15) AT=740.1n

* CHECK dout1_16 Vdout1_16ck36 = 0 time = 740
.meas tran vdout1_16ck36 FIND v(dout1_16) AT=740.1n

* CHECK dout1_17 Vdout1_17ck36 = 1.8 time = 740
.meas tran vdout1_17ck36 FIND v(dout1_17) AT=740.1n

* CHECK dout1_18 Vdout1_18ck36 = 0 time = 740
.meas tran vdout1_18ck36 FIND v(dout1_18) AT=740.1n

* CHECK dout1_19 Vdout1_19ck36 = 1.8 time = 740
.meas tran vdout1_19ck36 FIND v(dout1_19) AT=740.1n

* CHECK dout1_20 Vdout1_20ck36 = 1.8 time = 740
.meas tran vdout1_20ck36 FIND v(dout1_20) AT=740.1n

* CHECK dout1_21 Vdout1_21ck36 = 1.8 time = 740
.meas tran vdout1_21ck36 FIND v(dout1_21) AT=740.1n

* CHECK dout1_22 Vdout1_22ck36 = 0 time = 740
.meas tran vdout1_22ck36 FIND v(dout1_22) AT=740.1n

* CHECK dout1_23 Vdout1_23ck36 = 1.8 time = 740
.meas tran vdout1_23ck36 FIND v(dout1_23) AT=740.1n

* CHECK dout1_24 Vdout1_24ck36 = 1.8 time = 740
.meas tran vdout1_24ck36 FIND v(dout1_24) AT=740.1n

* CHECK dout1_25 Vdout1_25ck36 = 0 time = 740
.meas tran vdout1_25ck36 FIND v(dout1_25) AT=740.1n

* CHECK dout1_26 Vdout1_26ck36 = 1.8 time = 740
.meas tran vdout1_26ck36 FIND v(dout1_26) AT=740.1n

* CHECK dout1_27 Vdout1_27ck36 = 0 time = 740
.meas tran vdout1_27ck36 FIND v(dout1_27) AT=740.1n

* CHECK dout1_28 Vdout1_28ck36 = 1.8 time = 740
.meas tran vdout1_28ck36 FIND v(dout1_28) AT=740.1n

* CHECK dout1_29 Vdout1_29ck36 = 1.8 time = 740
.meas tran vdout1_29ck36 FIND v(dout1_29) AT=740.1n

* CHECK dout1_30 Vdout1_30ck36 = 1.8 time = 740
.meas tran vdout1_30ck36 FIND v(dout1_30) AT=740.1n

* CHECK dout1_31 Vdout1_31ck36 = 1.8 time = 740
.meas tran vdout1_31ck36 FIND v(dout1_31) AT=740.1n

* CHECK dout2_0 Vdout2_0ck36 = 0 time = 740
.meas tran vdout2_0ck36 FIND v(dout2_0) AT=740.1n

* CHECK dout2_1 Vdout2_1ck36 = 1.8 time = 740
.meas tran vdout2_1ck36 FIND v(dout2_1) AT=740.1n

* CHECK dout2_2 Vdout2_2ck36 = 0 time = 740
.meas tran vdout2_2ck36 FIND v(dout2_2) AT=740.1n

* CHECK dout2_3 Vdout2_3ck36 = 1.8 time = 740
.meas tran vdout2_3ck36 FIND v(dout2_3) AT=740.1n

* CHECK dout2_4 Vdout2_4ck36 = 0 time = 740
.meas tran vdout2_4ck36 FIND v(dout2_4) AT=740.1n

* CHECK dout2_5 Vdout2_5ck36 = 0 time = 740
.meas tran vdout2_5ck36 FIND v(dout2_5) AT=740.1n

* CHECK dout2_6 Vdout2_6ck36 = 1.8 time = 740
.meas tran vdout2_6ck36 FIND v(dout2_6) AT=740.1n

* CHECK dout2_7 Vdout2_7ck36 = 1.8 time = 740
.meas tran vdout2_7ck36 FIND v(dout2_7) AT=740.1n

* CHECK dout2_8 Vdout2_8ck36 = 0 time = 740
.meas tran vdout2_8ck36 FIND v(dout2_8) AT=740.1n

* CHECK dout2_9 Vdout2_9ck36 = 0 time = 740
.meas tran vdout2_9ck36 FIND v(dout2_9) AT=740.1n

* CHECK dout2_10 Vdout2_10ck36 = 1.8 time = 740
.meas tran vdout2_10ck36 FIND v(dout2_10) AT=740.1n

* CHECK dout2_11 Vdout2_11ck36 = 1.8 time = 740
.meas tran vdout2_11ck36 FIND v(dout2_11) AT=740.1n

* CHECK dout2_12 Vdout2_12ck36 = 0 time = 740
.meas tran vdout2_12ck36 FIND v(dout2_12) AT=740.1n

* CHECK dout2_13 Vdout2_13ck36 = 0 time = 740
.meas tran vdout2_13ck36 FIND v(dout2_13) AT=740.1n

* CHECK dout2_14 Vdout2_14ck36 = 0 time = 740
.meas tran vdout2_14ck36 FIND v(dout2_14) AT=740.1n

* CHECK dout2_15 Vdout2_15ck36 = 0 time = 740
.meas tran vdout2_15ck36 FIND v(dout2_15) AT=740.1n

* CHECK dout2_16 Vdout2_16ck36 = 0 time = 740
.meas tran vdout2_16ck36 FIND v(dout2_16) AT=740.1n

* CHECK dout2_17 Vdout2_17ck36 = 0 time = 740
.meas tran vdout2_17ck36 FIND v(dout2_17) AT=740.1n

* CHECK dout2_18 Vdout2_18ck36 = 0 time = 740
.meas tran vdout2_18ck36 FIND v(dout2_18) AT=740.1n

* CHECK dout2_19 Vdout2_19ck36 = 1.8 time = 740
.meas tran vdout2_19ck36 FIND v(dout2_19) AT=740.1n

* CHECK dout2_20 Vdout2_20ck36 = 1.8 time = 740
.meas tran vdout2_20ck36 FIND v(dout2_20) AT=740.1n

* CHECK dout2_21 Vdout2_21ck36 = 1.8 time = 740
.meas tran vdout2_21ck36 FIND v(dout2_21) AT=740.1n

* CHECK dout2_22 Vdout2_22ck36 = 0 time = 740
.meas tran vdout2_22ck36 FIND v(dout2_22) AT=740.1n

* CHECK dout2_23 Vdout2_23ck36 = 1.8 time = 740
.meas tran vdout2_23ck36 FIND v(dout2_23) AT=740.1n

* CHECK dout2_24 Vdout2_24ck36 = 1.8 time = 740
.meas tran vdout2_24ck36 FIND v(dout2_24) AT=740.1n

* CHECK dout2_25 Vdout2_25ck36 = 0 time = 740
.meas tran vdout2_25ck36 FIND v(dout2_25) AT=740.1n

* CHECK dout2_26 Vdout2_26ck36 = 0 time = 740
.meas tran vdout2_26ck36 FIND v(dout2_26) AT=740.1n

* CHECK dout2_27 Vdout2_27ck36 = 0 time = 740
.meas tran vdout2_27ck36 FIND v(dout2_27) AT=740.1n

* CHECK dout2_28 Vdout2_28ck36 = 0 time = 740
.meas tran vdout2_28ck36 FIND v(dout2_28) AT=740.1n

* CHECK dout2_29 Vdout2_29ck36 = 1.8 time = 740
.meas tran vdout2_29ck36 FIND v(dout2_29) AT=740.1n

* CHECK dout2_30 Vdout2_30ck36 = 0 time = 740
.meas tran vdout2_30ck36 FIND v(dout2_30) AT=740.1n

* CHECK dout2_31 Vdout2_31ck36 = 1.8 time = 740
.meas tran vdout2_31ck36 FIND v(dout2_31) AT=740.1n

* CHECK dout1_0 Vdout1_0ck37 = 0 time = 760
.meas tran vdout1_0ck37 FIND v(dout1_0) AT=760.1n

* CHECK dout1_1 Vdout1_1ck37 = 1.8 time = 760
.meas tran vdout1_1ck37 FIND v(dout1_1) AT=760.1n

* CHECK dout1_2 Vdout1_2ck37 = 0 time = 760
.meas tran vdout1_2ck37 FIND v(dout1_2) AT=760.1n

* CHECK dout1_3 Vdout1_3ck37 = 0 time = 760
.meas tran vdout1_3ck37 FIND v(dout1_3) AT=760.1n

* CHECK dout1_4 Vdout1_4ck37 = 0 time = 760
.meas tran vdout1_4ck37 FIND v(dout1_4) AT=760.1n

* CHECK dout1_5 Vdout1_5ck37 = 0 time = 760
.meas tran vdout1_5ck37 FIND v(dout1_5) AT=760.1n

* CHECK dout1_6 Vdout1_6ck37 = 1.8 time = 760
.meas tran vdout1_6ck37 FIND v(dout1_6) AT=760.1n

* CHECK dout1_7 Vdout1_7ck37 = 1.8 time = 760
.meas tran vdout1_7ck37 FIND v(dout1_7) AT=760.1n

* CHECK dout1_8 Vdout1_8ck37 = 0 time = 760
.meas tran vdout1_8ck37 FIND v(dout1_8) AT=760.1n

* CHECK dout1_9 Vdout1_9ck37 = 0 time = 760
.meas tran vdout1_9ck37 FIND v(dout1_9) AT=760.1n

* CHECK dout1_10 Vdout1_10ck37 = 1.8 time = 760
.meas tran vdout1_10ck37 FIND v(dout1_10) AT=760.1n

* CHECK dout1_11 Vdout1_11ck37 = 0 time = 760
.meas tran vdout1_11ck37 FIND v(dout1_11) AT=760.1n

* CHECK dout1_12 Vdout1_12ck37 = 1.8 time = 760
.meas tran vdout1_12ck37 FIND v(dout1_12) AT=760.1n

* CHECK dout1_13 Vdout1_13ck37 = 1.8 time = 760
.meas tran vdout1_13ck37 FIND v(dout1_13) AT=760.1n

* CHECK dout1_14 Vdout1_14ck37 = 1.8 time = 760
.meas tran vdout1_14ck37 FIND v(dout1_14) AT=760.1n

* CHECK dout1_15 Vdout1_15ck37 = 0 time = 760
.meas tran vdout1_15ck37 FIND v(dout1_15) AT=760.1n

* CHECK dout1_16 Vdout1_16ck37 = 1.8 time = 760
.meas tran vdout1_16ck37 FIND v(dout1_16) AT=760.1n

* CHECK dout1_17 Vdout1_17ck37 = 0 time = 760
.meas tran vdout1_17ck37 FIND v(dout1_17) AT=760.1n

* CHECK dout1_18 Vdout1_18ck37 = 1.8 time = 760
.meas tran vdout1_18ck37 FIND v(dout1_18) AT=760.1n

* CHECK dout1_19 Vdout1_19ck37 = 0 time = 760
.meas tran vdout1_19ck37 FIND v(dout1_19) AT=760.1n

* CHECK dout1_20 Vdout1_20ck37 = 0 time = 760
.meas tran vdout1_20ck37 FIND v(dout1_20) AT=760.1n

* CHECK dout1_21 Vdout1_21ck37 = 1.8 time = 760
.meas tran vdout1_21ck37 FIND v(dout1_21) AT=760.1n

* CHECK dout1_22 Vdout1_22ck37 = 0 time = 760
.meas tran vdout1_22ck37 FIND v(dout1_22) AT=760.1n

* CHECK dout1_23 Vdout1_23ck37 = 1.8 time = 760
.meas tran vdout1_23ck37 FIND v(dout1_23) AT=760.1n

* CHECK dout1_24 Vdout1_24ck37 = 0 time = 760
.meas tran vdout1_24ck37 FIND v(dout1_24) AT=760.1n

* CHECK dout1_25 Vdout1_25ck37 = 0 time = 760
.meas tran vdout1_25ck37 FIND v(dout1_25) AT=760.1n

* CHECK dout1_26 Vdout1_26ck37 = 0 time = 760
.meas tran vdout1_26ck37 FIND v(dout1_26) AT=760.1n

* CHECK dout1_27 Vdout1_27ck37 = 1.8 time = 760
.meas tran vdout1_27ck37 FIND v(dout1_27) AT=760.1n

* CHECK dout1_28 Vdout1_28ck37 = 0 time = 760
.meas tran vdout1_28ck37 FIND v(dout1_28) AT=760.1n

* CHECK dout1_29 Vdout1_29ck37 = 1.8 time = 760
.meas tran vdout1_29ck37 FIND v(dout1_29) AT=760.1n

* CHECK dout1_30 Vdout1_30ck37 = 1.8 time = 760
.meas tran vdout1_30ck37 FIND v(dout1_30) AT=760.1n

* CHECK dout1_31 Vdout1_31ck37 = 0 time = 760
.meas tran vdout1_31ck37 FIND v(dout1_31) AT=760.1n

* CHECK dout2_0 Vdout2_0ck37 = 0 time = 760
.meas tran vdout2_0ck37 FIND v(dout2_0) AT=760.1n

* CHECK dout2_1 Vdout2_1ck37 = 1.8 time = 760
.meas tran vdout2_1ck37 FIND v(dout2_1) AT=760.1n

* CHECK dout2_2 Vdout2_2ck37 = 0 time = 760
.meas tran vdout2_2ck37 FIND v(dout2_2) AT=760.1n

* CHECK dout2_3 Vdout2_3ck37 = 0 time = 760
.meas tran vdout2_3ck37 FIND v(dout2_3) AT=760.1n

* CHECK dout2_4 Vdout2_4ck37 = 0 time = 760
.meas tran vdout2_4ck37 FIND v(dout2_4) AT=760.1n

* CHECK dout2_5 Vdout2_5ck37 = 0 time = 760
.meas tran vdout2_5ck37 FIND v(dout2_5) AT=760.1n

* CHECK dout2_6 Vdout2_6ck37 = 1.8 time = 760
.meas tran vdout2_6ck37 FIND v(dout2_6) AT=760.1n

* CHECK dout2_7 Vdout2_7ck37 = 1.8 time = 760
.meas tran vdout2_7ck37 FIND v(dout2_7) AT=760.1n

* CHECK dout2_8 Vdout2_8ck37 = 0 time = 760
.meas tran vdout2_8ck37 FIND v(dout2_8) AT=760.1n

* CHECK dout2_9 Vdout2_9ck37 = 0 time = 760
.meas tran vdout2_9ck37 FIND v(dout2_9) AT=760.1n

* CHECK dout2_10 Vdout2_10ck37 = 1.8 time = 760
.meas tran vdout2_10ck37 FIND v(dout2_10) AT=760.1n

* CHECK dout2_11 Vdout2_11ck37 = 0 time = 760
.meas tran vdout2_11ck37 FIND v(dout2_11) AT=760.1n

* CHECK dout2_12 Vdout2_12ck37 = 1.8 time = 760
.meas tran vdout2_12ck37 FIND v(dout2_12) AT=760.1n

* CHECK dout2_13 Vdout2_13ck37 = 1.8 time = 760
.meas tran vdout2_13ck37 FIND v(dout2_13) AT=760.1n

* CHECK dout2_14 Vdout2_14ck37 = 1.8 time = 760
.meas tran vdout2_14ck37 FIND v(dout2_14) AT=760.1n

* CHECK dout2_15 Vdout2_15ck37 = 0 time = 760
.meas tran vdout2_15ck37 FIND v(dout2_15) AT=760.1n

* CHECK dout2_16 Vdout2_16ck37 = 1.8 time = 760
.meas tran vdout2_16ck37 FIND v(dout2_16) AT=760.1n

* CHECK dout2_17 Vdout2_17ck37 = 0 time = 760
.meas tran vdout2_17ck37 FIND v(dout2_17) AT=760.1n

* CHECK dout2_18 Vdout2_18ck37 = 1.8 time = 760
.meas tran vdout2_18ck37 FIND v(dout2_18) AT=760.1n

* CHECK dout2_19 Vdout2_19ck37 = 0 time = 760
.meas tran vdout2_19ck37 FIND v(dout2_19) AT=760.1n

* CHECK dout2_20 Vdout2_20ck37 = 0 time = 760
.meas tran vdout2_20ck37 FIND v(dout2_20) AT=760.1n

* CHECK dout2_21 Vdout2_21ck37 = 1.8 time = 760
.meas tran vdout2_21ck37 FIND v(dout2_21) AT=760.1n

* CHECK dout2_22 Vdout2_22ck37 = 0 time = 760
.meas tran vdout2_22ck37 FIND v(dout2_22) AT=760.1n

* CHECK dout2_23 Vdout2_23ck37 = 1.8 time = 760
.meas tran vdout2_23ck37 FIND v(dout2_23) AT=760.1n

* CHECK dout2_24 Vdout2_24ck37 = 0 time = 760
.meas tran vdout2_24ck37 FIND v(dout2_24) AT=760.1n

* CHECK dout2_25 Vdout2_25ck37 = 0 time = 760
.meas tran vdout2_25ck37 FIND v(dout2_25) AT=760.1n

* CHECK dout2_26 Vdout2_26ck37 = 0 time = 760
.meas tran vdout2_26ck37 FIND v(dout2_26) AT=760.1n

* CHECK dout2_27 Vdout2_27ck37 = 1.8 time = 760
.meas tran vdout2_27ck37 FIND v(dout2_27) AT=760.1n

* CHECK dout2_28 Vdout2_28ck37 = 0 time = 760
.meas tran vdout2_28ck37 FIND v(dout2_28) AT=760.1n

* CHECK dout2_29 Vdout2_29ck37 = 1.8 time = 760
.meas tran vdout2_29ck37 FIND v(dout2_29) AT=760.1n

* CHECK dout2_30 Vdout2_30ck37 = 1.8 time = 760
.meas tran vdout2_30ck37 FIND v(dout2_30) AT=760.1n

* CHECK dout2_31 Vdout2_31ck37 = 0 time = 760
.meas tran vdout2_31ck37 FIND v(dout2_31) AT=760.1n

* CHECK dout1_0 Vdout1_0ck38 = 1.8 time = 780
.meas tran vdout1_0ck38 FIND v(dout1_0) AT=780.1n

* CHECK dout1_1 Vdout1_1ck38 = 0 time = 780
.meas tran vdout1_1ck38 FIND v(dout1_1) AT=780.1n

* CHECK dout1_2 Vdout1_2ck38 = 1.8 time = 780
.meas tran vdout1_2ck38 FIND v(dout1_2) AT=780.1n

* CHECK dout1_3 Vdout1_3ck38 = 0 time = 780
.meas tran vdout1_3ck38 FIND v(dout1_3) AT=780.1n

* CHECK dout1_4 Vdout1_4ck38 = 0 time = 780
.meas tran vdout1_4ck38 FIND v(dout1_4) AT=780.1n

* CHECK dout1_5 Vdout1_5ck38 = 1.8 time = 780
.meas tran vdout1_5ck38 FIND v(dout1_5) AT=780.1n

* CHECK dout1_6 Vdout1_6ck38 = 0 time = 780
.meas tran vdout1_6ck38 FIND v(dout1_6) AT=780.1n

* CHECK dout1_7 Vdout1_7ck38 = 1.8 time = 780
.meas tran vdout1_7ck38 FIND v(dout1_7) AT=780.1n

* CHECK dout1_8 Vdout1_8ck38 = 1.8 time = 780
.meas tran vdout1_8ck38 FIND v(dout1_8) AT=780.1n

* CHECK dout1_9 Vdout1_9ck38 = 0 time = 780
.meas tran vdout1_9ck38 FIND v(dout1_9) AT=780.1n

* CHECK dout1_10 Vdout1_10ck38 = 1.8 time = 780
.meas tran vdout1_10ck38 FIND v(dout1_10) AT=780.1n

* CHECK dout1_11 Vdout1_11ck38 = 1.8 time = 780
.meas tran vdout1_11ck38 FIND v(dout1_11) AT=780.1n

* CHECK dout1_12 Vdout1_12ck38 = 0 time = 780
.meas tran vdout1_12ck38 FIND v(dout1_12) AT=780.1n

* CHECK dout1_13 Vdout1_13ck38 = 0 time = 780
.meas tran vdout1_13ck38 FIND v(dout1_13) AT=780.1n

* CHECK dout1_14 Vdout1_14ck38 = 1.8 time = 780
.meas tran vdout1_14ck38 FIND v(dout1_14) AT=780.1n

* CHECK dout1_15 Vdout1_15ck38 = 0 time = 780
.meas tran vdout1_15ck38 FIND v(dout1_15) AT=780.1n

* CHECK dout1_16 Vdout1_16ck38 = 1.8 time = 780
.meas tran vdout1_16ck38 FIND v(dout1_16) AT=780.1n

* CHECK dout1_17 Vdout1_17ck38 = 0 time = 780
.meas tran vdout1_17ck38 FIND v(dout1_17) AT=780.1n

* CHECK dout1_18 Vdout1_18ck38 = 0 time = 780
.meas tran vdout1_18ck38 FIND v(dout1_18) AT=780.1n

* CHECK dout1_19 Vdout1_19ck38 = 1.8 time = 780
.meas tran vdout1_19ck38 FIND v(dout1_19) AT=780.1n

* CHECK dout1_20 Vdout1_20ck38 = 1.8 time = 780
.meas tran vdout1_20ck38 FIND v(dout1_20) AT=780.1n

* CHECK dout1_21 Vdout1_21ck38 = 0 time = 780
.meas tran vdout1_21ck38 FIND v(dout1_21) AT=780.1n

* CHECK dout1_22 Vdout1_22ck38 = 1.8 time = 780
.meas tran vdout1_22ck38 FIND v(dout1_22) AT=780.1n

* CHECK dout1_23 Vdout1_23ck38 = 1.8 time = 780
.meas tran vdout1_23ck38 FIND v(dout1_23) AT=780.1n

* CHECK dout1_24 Vdout1_24ck38 = 0 time = 780
.meas tran vdout1_24ck38 FIND v(dout1_24) AT=780.1n

* CHECK dout1_25 Vdout1_25ck38 = 0 time = 780
.meas tran vdout1_25ck38 FIND v(dout1_25) AT=780.1n

* CHECK dout1_26 Vdout1_26ck38 = 0 time = 780
.meas tran vdout1_26ck38 FIND v(dout1_26) AT=780.1n

* CHECK dout1_27 Vdout1_27ck38 = 0 time = 780
.meas tran vdout1_27ck38 FIND v(dout1_27) AT=780.1n

* CHECK dout1_28 Vdout1_28ck38 = 1.8 time = 780
.meas tran vdout1_28ck38 FIND v(dout1_28) AT=780.1n

* CHECK dout1_29 Vdout1_29ck38 = 0 time = 780
.meas tran vdout1_29ck38 FIND v(dout1_29) AT=780.1n

* CHECK dout1_30 Vdout1_30ck38 = 0 time = 780
.meas tran vdout1_30ck38 FIND v(dout1_30) AT=780.1n

* CHECK dout1_31 Vdout1_31ck38 = 0 time = 780
.meas tran vdout1_31ck38 FIND v(dout1_31) AT=780.1n

* CHECK dout2_0 Vdout2_0ck38 = 1.8 time = 780
.meas tran vdout2_0ck38 FIND v(dout2_0) AT=780.1n

* CHECK dout2_1 Vdout2_1ck38 = 0 time = 780
.meas tran vdout2_1ck38 FIND v(dout2_1) AT=780.1n

* CHECK dout2_2 Vdout2_2ck38 = 1.8 time = 780
.meas tran vdout2_2ck38 FIND v(dout2_2) AT=780.1n

* CHECK dout2_3 Vdout2_3ck38 = 0 time = 780
.meas tran vdout2_3ck38 FIND v(dout2_3) AT=780.1n

* CHECK dout2_4 Vdout2_4ck38 = 0 time = 780
.meas tran vdout2_4ck38 FIND v(dout2_4) AT=780.1n

* CHECK dout2_5 Vdout2_5ck38 = 1.8 time = 780
.meas tran vdout2_5ck38 FIND v(dout2_5) AT=780.1n

* CHECK dout2_6 Vdout2_6ck38 = 0 time = 780
.meas tran vdout2_6ck38 FIND v(dout2_6) AT=780.1n

* CHECK dout2_7 Vdout2_7ck38 = 1.8 time = 780
.meas tran vdout2_7ck38 FIND v(dout2_7) AT=780.1n

* CHECK dout2_8 Vdout2_8ck38 = 1.8 time = 780
.meas tran vdout2_8ck38 FIND v(dout2_8) AT=780.1n

* CHECK dout2_9 Vdout2_9ck38 = 0 time = 780
.meas tran vdout2_9ck38 FIND v(dout2_9) AT=780.1n

* CHECK dout2_10 Vdout2_10ck38 = 1.8 time = 780
.meas tran vdout2_10ck38 FIND v(dout2_10) AT=780.1n

* CHECK dout2_11 Vdout2_11ck38 = 1.8 time = 780
.meas tran vdout2_11ck38 FIND v(dout2_11) AT=780.1n

* CHECK dout2_12 Vdout2_12ck38 = 0 time = 780
.meas tran vdout2_12ck38 FIND v(dout2_12) AT=780.1n

* CHECK dout2_13 Vdout2_13ck38 = 0 time = 780
.meas tran vdout2_13ck38 FIND v(dout2_13) AT=780.1n

* CHECK dout2_14 Vdout2_14ck38 = 1.8 time = 780
.meas tran vdout2_14ck38 FIND v(dout2_14) AT=780.1n

* CHECK dout2_15 Vdout2_15ck38 = 0 time = 780
.meas tran vdout2_15ck38 FIND v(dout2_15) AT=780.1n

* CHECK dout2_16 Vdout2_16ck38 = 1.8 time = 780
.meas tran vdout2_16ck38 FIND v(dout2_16) AT=780.1n

* CHECK dout2_17 Vdout2_17ck38 = 0 time = 780
.meas tran vdout2_17ck38 FIND v(dout2_17) AT=780.1n

* CHECK dout2_18 Vdout2_18ck38 = 0 time = 780
.meas tran vdout2_18ck38 FIND v(dout2_18) AT=780.1n

* CHECK dout2_19 Vdout2_19ck38 = 1.8 time = 780
.meas tran vdout2_19ck38 FIND v(dout2_19) AT=780.1n

* CHECK dout2_20 Vdout2_20ck38 = 1.8 time = 780
.meas tran vdout2_20ck38 FIND v(dout2_20) AT=780.1n

* CHECK dout2_21 Vdout2_21ck38 = 0 time = 780
.meas tran vdout2_21ck38 FIND v(dout2_21) AT=780.1n

* CHECK dout2_22 Vdout2_22ck38 = 1.8 time = 780
.meas tran vdout2_22ck38 FIND v(dout2_22) AT=780.1n

* CHECK dout2_23 Vdout2_23ck38 = 1.8 time = 780
.meas tran vdout2_23ck38 FIND v(dout2_23) AT=780.1n

* CHECK dout2_24 Vdout2_24ck38 = 0 time = 780
.meas tran vdout2_24ck38 FIND v(dout2_24) AT=780.1n

* CHECK dout2_25 Vdout2_25ck38 = 0 time = 780
.meas tran vdout2_25ck38 FIND v(dout2_25) AT=780.1n

* CHECK dout2_26 Vdout2_26ck38 = 0 time = 780
.meas tran vdout2_26ck38 FIND v(dout2_26) AT=780.1n

* CHECK dout2_27 Vdout2_27ck38 = 0 time = 780
.meas tran vdout2_27ck38 FIND v(dout2_27) AT=780.1n

* CHECK dout2_28 Vdout2_28ck38 = 1.8 time = 780
.meas tran vdout2_28ck38 FIND v(dout2_28) AT=780.1n

* CHECK dout2_29 Vdout2_29ck38 = 0 time = 780
.meas tran vdout2_29ck38 FIND v(dout2_29) AT=780.1n

* CHECK dout2_30 Vdout2_30ck38 = 0 time = 780
.meas tran vdout2_30ck38 FIND v(dout2_30) AT=780.1n

* CHECK dout2_31 Vdout2_31ck38 = 0 time = 780
.meas tran vdout2_31ck38 FIND v(dout2_31) AT=780.1n

* CHECK dout1_0 Vdout1_0ck39 = 1.8 time = 800
.meas tran vdout1_0ck39 FIND v(dout1_0) AT=800.1n

* CHECK dout1_1 Vdout1_1ck39 = 0 time = 800
.meas tran vdout1_1ck39 FIND v(dout1_1) AT=800.1n

* CHECK dout1_2 Vdout1_2ck39 = 1.8 time = 800
.meas tran vdout1_2ck39 FIND v(dout1_2) AT=800.1n

* CHECK dout1_3 Vdout1_3ck39 = 0 time = 800
.meas tran vdout1_3ck39 FIND v(dout1_3) AT=800.1n

* CHECK dout1_4 Vdout1_4ck39 = 0 time = 800
.meas tran vdout1_4ck39 FIND v(dout1_4) AT=800.1n

* CHECK dout1_5 Vdout1_5ck39 = 1.8 time = 800
.meas tran vdout1_5ck39 FIND v(dout1_5) AT=800.1n

* CHECK dout1_6 Vdout1_6ck39 = 0 time = 800
.meas tran vdout1_6ck39 FIND v(dout1_6) AT=800.1n

* CHECK dout1_7 Vdout1_7ck39 = 1.8 time = 800
.meas tran vdout1_7ck39 FIND v(dout1_7) AT=800.1n

* CHECK dout1_8 Vdout1_8ck39 = 1.8 time = 800
.meas tran vdout1_8ck39 FIND v(dout1_8) AT=800.1n

* CHECK dout1_9 Vdout1_9ck39 = 0 time = 800
.meas tran vdout1_9ck39 FIND v(dout1_9) AT=800.1n

* CHECK dout1_10 Vdout1_10ck39 = 1.8 time = 800
.meas tran vdout1_10ck39 FIND v(dout1_10) AT=800.1n

* CHECK dout1_11 Vdout1_11ck39 = 1.8 time = 800
.meas tran vdout1_11ck39 FIND v(dout1_11) AT=800.1n

* CHECK dout1_12 Vdout1_12ck39 = 0 time = 800
.meas tran vdout1_12ck39 FIND v(dout1_12) AT=800.1n

* CHECK dout1_13 Vdout1_13ck39 = 0 time = 800
.meas tran vdout1_13ck39 FIND v(dout1_13) AT=800.1n

* CHECK dout1_14 Vdout1_14ck39 = 1.8 time = 800
.meas tran vdout1_14ck39 FIND v(dout1_14) AT=800.1n

* CHECK dout1_15 Vdout1_15ck39 = 0 time = 800
.meas tran vdout1_15ck39 FIND v(dout1_15) AT=800.1n

* CHECK dout1_16 Vdout1_16ck39 = 1.8 time = 800
.meas tran vdout1_16ck39 FIND v(dout1_16) AT=800.1n

* CHECK dout1_17 Vdout1_17ck39 = 0 time = 800
.meas tran vdout1_17ck39 FIND v(dout1_17) AT=800.1n

* CHECK dout1_18 Vdout1_18ck39 = 0 time = 800
.meas tran vdout1_18ck39 FIND v(dout1_18) AT=800.1n

* CHECK dout1_19 Vdout1_19ck39 = 1.8 time = 800
.meas tran vdout1_19ck39 FIND v(dout1_19) AT=800.1n

* CHECK dout1_20 Vdout1_20ck39 = 1.8 time = 800
.meas tran vdout1_20ck39 FIND v(dout1_20) AT=800.1n

* CHECK dout1_21 Vdout1_21ck39 = 0 time = 800
.meas tran vdout1_21ck39 FIND v(dout1_21) AT=800.1n

* CHECK dout1_22 Vdout1_22ck39 = 1.8 time = 800
.meas tran vdout1_22ck39 FIND v(dout1_22) AT=800.1n

* CHECK dout1_23 Vdout1_23ck39 = 1.8 time = 800
.meas tran vdout1_23ck39 FIND v(dout1_23) AT=800.1n

* CHECK dout1_24 Vdout1_24ck39 = 0 time = 800
.meas tran vdout1_24ck39 FIND v(dout1_24) AT=800.1n

* CHECK dout1_25 Vdout1_25ck39 = 0 time = 800
.meas tran vdout1_25ck39 FIND v(dout1_25) AT=800.1n

* CHECK dout1_26 Vdout1_26ck39 = 0 time = 800
.meas tran vdout1_26ck39 FIND v(dout1_26) AT=800.1n

* CHECK dout1_27 Vdout1_27ck39 = 0 time = 800
.meas tran vdout1_27ck39 FIND v(dout1_27) AT=800.1n

* CHECK dout1_28 Vdout1_28ck39 = 1.8 time = 800
.meas tran vdout1_28ck39 FIND v(dout1_28) AT=800.1n

* CHECK dout1_29 Vdout1_29ck39 = 0 time = 800
.meas tran vdout1_29ck39 FIND v(dout1_29) AT=800.1n

* CHECK dout1_30 Vdout1_30ck39 = 0 time = 800
.meas tran vdout1_30ck39 FIND v(dout1_30) AT=800.1n

* CHECK dout1_31 Vdout1_31ck39 = 0 time = 800
.meas tran vdout1_31ck39 FIND v(dout1_31) AT=800.1n

* CHECK dout2_0 Vdout2_0ck40 = 0 time = 820
.meas tran vdout2_0ck40 FIND v(dout2_0) AT=820.1n

* CHECK dout2_1 Vdout2_1ck40 = 1.8 time = 820
.meas tran vdout2_1ck40 FIND v(dout2_1) AT=820.1n

* CHECK dout2_2 Vdout2_2ck40 = 0 time = 820
.meas tran vdout2_2ck40 FIND v(dout2_2) AT=820.1n

* CHECK dout2_3 Vdout2_3ck40 = 1.8 time = 820
.meas tran vdout2_3ck40 FIND v(dout2_3) AT=820.1n

* CHECK dout2_4 Vdout2_4ck40 = 0 time = 820
.meas tran vdout2_4ck40 FIND v(dout2_4) AT=820.1n

* CHECK dout2_5 Vdout2_5ck40 = 0 time = 820
.meas tran vdout2_5ck40 FIND v(dout2_5) AT=820.1n

* CHECK dout2_6 Vdout2_6ck40 = 1.8 time = 820
.meas tran vdout2_6ck40 FIND v(dout2_6) AT=820.1n

* CHECK dout2_7 Vdout2_7ck40 = 1.8 time = 820
.meas tran vdout2_7ck40 FIND v(dout2_7) AT=820.1n

* CHECK dout2_8 Vdout2_8ck40 = 0 time = 820
.meas tran vdout2_8ck40 FIND v(dout2_8) AT=820.1n

* CHECK dout2_9 Vdout2_9ck40 = 0 time = 820
.meas tran vdout2_9ck40 FIND v(dout2_9) AT=820.1n

* CHECK dout2_10 Vdout2_10ck40 = 1.8 time = 820
.meas tran vdout2_10ck40 FIND v(dout2_10) AT=820.1n

* CHECK dout2_11 Vdout2_11ck40 = 1.8 time = 820
.meas tran vdout2_11ck40 FIND v(dout2_11) AT=820.1n

* CHECK dout2_12 Vdout2_12ck40 = 0 time = 820
.meas tran vdout2_12ck40 FIND v(dout2_12) AT=820.1n

* CHECK dout2_13 Vdout2_13ck40 = 0 time = 820
.meas tran vdout2_13ck40 FIND v(dout2_13) AT=820.1n

* CHECK dout2_14 Vdout2_14ck40 = 0 time = 820
.meas tran vdout2_14ck40 FIND v(dout2_14) AT=820.1n

* CHECK dout2_15 Vdout2_15ck40 = 0 time = 820
.meas tran vdout2_15ck40 FIND v(dout2_15) AT=820.1n

* CHECK dout2_16 Vdout2_16ck40 = 0 time = 820
.meas tran vdout2_16ck40 FIND v(dout2_16) AT=820.1n

* CHECK dout2_17 Vdout2_17ck40 = 0 time = 820
.meas tran vdout2_17ck40 FIND v(dout2_17) AT=820.1n

* CHECK dout2_18 Vdout2_18ck40 = 0 time = 820
.meas tran vdout2_18ck40 FIND v(dout2_18) AT=820.1n

* CHECK dout2_19 Vdout2_19ck40 = 1.8 time = 820
.meas tran vdout2_19ck40 FIND v(dout2_19) AT=820.1n

* CHECK dout2_20 Vdout2_20ck40 = 1.8 time = 820
.meas tran vdout2_20ck40 FIND v(dout2_20) AT=820.1n

* CHECK dout2_21 Vdout2_21ck40 = 1.8 time = 820
.meas tran vdout2_21ck40 FIND v(dout2_21) AT=820.1n

* CHECK dout2_22 Vdout2_22ck40 = 0 time = 820
.meas tran vdout2_22ck40 FIND v(dout2_22) AT=820.1n

* CHECK dout2_23 Vdout2_23ck40 = 1.8 time = 820
.meas tran vdout2_23ck40 FIND v(dout2_23) AT=820.1n

* CHECK dout2_24 Vdout2_24ck40 = 1.8 time = 820
.meas tran vdout2_24ck40 FIND v(dout2_24) AT=820.1n

* CHECK dout2_25 Vdout2_25ck40 = 0 time = 820
.meas tran vdout2_25ck40 FIND v(dout2_25) AT=820.1n

* CHECK dout2_26 Vdout2_26ck40 = 0 time = 820
.meas tran vdout2_26ck40 FIND v(dout2_26) AT=820.1n

* CHECK dout2_27 Vdout2_27ck40 = 0 time = 820
.meas tran vdout2_27ck40 FIND v(dout2_27) AT=820.1n

* CHECK dout2_28 Vdout2_28ck40 = 0 time = 820
.meas tran vdout2_28ck40 FIND v(dout2_28) AT=820.1n

* CHECK dout2_29 Vdout2_29ck40 = 1.8 time = 820
.meas tran vdout2_29ck40 FIND v(dout2_29) AT=820.1n

* CHECK dout2_30 Vdout2_30ck40 = 0 time = 820
.meas tran vdout2_30ck40 FIND v(dout2_30) AT=820.1n

* CHECK dout2_31 Vdout2_31ck40 = 1.8 time = 820
.meas tran vdout2_31ck40 FIND v(dout2_31) AT=820.1n

* CHECK dout1_0 Vdout1_0ck41 = 0 time = 840
.meas tran vdout1_0ck41 FIND v(dout1_0) AT=840.1n

* CHECK dout1_1 Vdout1_1ck41 = 0 time = 840
.meas tran vdout1_1ck41 FIND v(dout1_1) AT=840.1n

* CHECK dout1_2 Vdout1_2ck41 = 0 time = 840
.meas tran vdout1_2ck41 FIND v(dout1_2) AT=840.1n

* CHECK dout1_3 Vdout1_3ck41 = 0 time = 840
.meas tran vdout1_3ck41 FIND v(dout1_3) AT=840.1n

* CHECK dout1_4 Vdout1_4ck41 = 0 time = 840
.meas tran vdout1_4ck41 FIND v(dout1_4) AT=840.1n

* CHECK dout1_5 Vdout1_5ck41 = 1.8 time = 840
.meas tran vdout1_5ck41 FIND v(dout1_5) AT=840.1n

* CHECK dout1_6 Vdout1_6ck41 = 0 time = 840
.meas tran vdout1_6ck41 FIND v(dout1_6) AT=840.1n

* CHECK dout1_7 Vdout1_7ck41 = 0 time = 840
.meas tran vdout1_7ck41 FIND v(dout1_7) AT=840.1n

* CHECK dout1_8 Vdout1_8ck41 = 0 time = 840
.meas tran vdout1_8ck41 FIND v(dout1_8) AT=840.1n

* CHECK dout1_9 Vdout1_9ck41 = 0 time = 840
.meas tran vdout1_9ck41 FIND v(dout1_9) AT=840.1n

* CHECK dout1_10 Vdout1_10ck41 = 0 time = 840
.meas tran vdout1_10ck41 FIND v(dout1_10) AT=840.1n

* CHECK dout1_11 Vdout1_11ck41 = 1.8 time = 840
.meas tran vdout1_11ck41 FIND v(dout1_11) AT=840.1n

* CHECK dout1_12 Vdout1_12ck41 = 0 time = 840
.meas tran vdout1_12ck41 FIND v(dout1_12) AT=840.1n

* CHECK dout1_13 Vdout1_13ck41 = 1.8 time = 840
.meas tran vdout1_13ck41 FIND v(dout1_13) AT=840.1n

* CHECK dout1_14 Vdout1_14ck41 = 0 time = 840
.meas tran vdout1_14ck41 FIND v(dout1_14) AT=840.1n

* CHECK dout1_15 Vdout1_15ck41 = 1.8 time = 840
.meas tran vdout1_15ck41 FIND v(dout1_15) AT=840.1n

* CHECK dout1_16 Vdout1_16ck41 = 0 time = 840
.meas tran vdout1_16ck41 FIND v(dout1_16) AT=840.1n

* CHECK dout1_17 Vdout1_17ck41 = 1.8 time = 840
.meas tran vdout1_17ck41 FIND v(dout1_17) AT=840.1n

* CHECK dout1_18 Vdout1_18ck41 = 1.8 time = 840
.meas tran vdout1_18ck41 FIND v(dout1_18) AT=840.1n

* CHECK dout1_19 Vdout1_19ck41 = 1.8 time = 840
.meas tran vdout1_19ck41 FIND v(dout1_19) AT=840.1n

* CHECK dout1_20 Vdout1_20ck41 = 0 time = 840
.meas tran vdout1_20ck41 FIND v(dout1_20) AT=840.1n

* CHECK dout1_21 Vdout1_21ck41 = 1.8 time = 840
.meas tran vdout1_21ck41 FIND v(dout1_21) AT=840.1n

* CHECK dout1_22 Vdout1_22ck41 = 1.8 time = 840
.meas tran vdout1_22ck41 FIND v(dout1_22) AT=840.1n

* CHECK dout1_23 Vdout1_23ck41 = 0 time = 840
.meas tran vdout1_23ck41 FIND v(dout1_23) AT=840.1n

* CHECK dout1_24 Vdout1_24ck41 = 0 time = 840
.meas tran vdout1_24ck41 FIND v(dout1_24) AT=840.1n

* CHECK dout1_25 Vdout1_25ck41 = 1.8 time = 840
.meas tran vdout1_25ck41 FIND v(dout1_25) AT=840.1n

* CHECK dout1_26 Vdout1_26ck41 = 1.8 time = 840
.meas tran vdout1_26ck41 FIND v(dout1_26) AT=840.1n

* CHECK dout1_27 Vdout1_27ck41 = 1.8 time = 840
.meas tran vdout1_27ck41 FIND v(dout1_27) AT=840.1n

* CHECK dout1_28 Vdout1_28ck41 = 0 time = 840
.meas tran vdout1_28ck41 FIND v(dout1_28) AT=840.1n

* CHECK dout1_29 Vdout1_29ck41 = 0 time = 840
.meas tran vdout1_29ck41 FIND v(dout1_29) AT=840.1n

* CHECK dout1_30 Vdout1_30ck41 = 0 time = 840
.meas tran vdout1_30ck41 FIND v(dout1_30) AT=840.1n

* CHECK dout1_31 Vdout1_31ck41 = 0 time = 840
.meas tran vdout1_31ck41 FIND v(dout1_31) AT=840.1n

* CHECK dout2_0 Vdout2_0ck41 = 0 time = 840
.meas tran vdout2_0ck41 FIND v(dout2_0) AT=840.1n

* CHECK dout2_1 Vdout2_1ck41 = 1.8 time = 840
.meas tran vdout2_1ck41 FIND v(dout2_1) AT=840.1n

* CHECK dout2_2 Vdout2_2ck41 = 1.8 time = 840
.meas tran vdout2_2ck41 FIND v(dout2_2) AT=840.1n

* CHECK dout2_3 Vdout2_3ck41 = 0 time = 840
.meas tran vdout2_3ck41 FIND v(dout2_3) AT=840.1n

* CHECK dout2_4 Vdout2_4ck41 = 1.8 time = 840
.meas tran vdout2_4ck41 FIND v(dout2_4) AT=840.1n

* CHECK dout2_5 Vdout2_5ck41 = 0 time = 840
.meas tran vdout2_5ck41 FIND v(dout2_5) AT=840.1n

* CHECK dout2_6 Vdout2_6ck41 = 0 time = 840
.meas tran vdout2_6ck41 FIND v(dout2_6) AT=840.1n

* CHECK dout2_7 Vdout2_7ck41 = 0 time = 840
.meas tran vdout2_7ck41 FIND v(dout2_7) AT=840.1n

* CHECK dout2_8 Vdout2_8ck41 = 0 time = 840
.meas tran vdout2_8ck41 FIND v(dout2_8) AT=840.1n

* CHECK dout2_9 Vdout2_9ck41 = 0 time = 840
.meas tran vdout2_9ck41 FIND v(dout2_9) AT=840.1n

* CHECK dout2_10 Vdout2_10ck41 = 0 time = 840
.meas tran vdout2_10ck41 FIND v(dout2_10) AT=840.1n

* CHECK dout2_11 Vdout2_11ck41 = 0 time = 840
.meas tran vdout2_11ck41 FIND v(dout2_11) AT=840.1n

* CHECK dout2_12 Vdout2_12ck41 = 1.8 time = 840
.meas tran vdout2_12ck41 FIND v(dout2_12) AT=840.1n

* CHECK dout2_13 Vdout2_13ck41 = 0 time = 840
.meas tran vdout2_13ck41 FIND v(dout2_13) AT=840.1n

* CHECK dout2_14 Vdout2_14ck41 = 1.8 time = 840
.meas tran vdout2_14ck41 FIND v(dout2_14) AT=840.1n

* CHECK dout2_15 Vdout2_15ck41 = 0 time = 840
.meas tran vdout2_15ck41 FIND v(dout2_15) AT=840.1n

* CHECK dout2_16 Vdout2_16ck41 = 1.8 time = 840
.meas tran vdout2_16ck41 FIND v(dout2_16) AT=840.1n

* CHECK dout2_17 Vdout2_17ck41 = 1.8 time = 840
.meas tran vdout2_17ck41 FIND v(dout2_17) AT=840.1n

* CHECK dout2_18 Vdout2_18ck41 = 0 time = 840
.meas tran vdout2_18ck41 FIND v(dout2_18) AT=840.1n

* CHECK dout2_19 Vdout2_19ck41 = 0 time = 840
.meas tran vdout2_19ck41 FIND v(dout2_19) AT=840.1n

* CHECK dout2_20 Vdout2_20ck41 = 0 time = 840
.meas tran vdout2_20ck41 FIND v(dout2_20) AT=840.1n

* CHECK dout2_21 Vdout2_21ck41 = 1.8 time = 840
.meas tran vdout2_21ck41 FIND v(dout2_21) AT=840.1n

* CHECK dout2_22 Vdout2_22ck41 = 0 time = 840
.meas tran vdout2_22ck41 FIND v(dout2_22) AT=840.1n

* CHECK dout2_23 Vdout2_23ck41 = 0 time = 840
.meas tran vdout2_23ck41 FIND v(dout2_23) AT=840.1n

* CHECK dout2_24 Vdout2_24ck41 = 1.8 time = 840
.meas tran vdout2_24ck41 FIND v(dout2_24) AT=840.1n

* CHECK dout2_25 Vdout2_25ck41 = 0 time = 840
.meas tran vdout2_25ck41 FIND v(dout2_25) AT=840.1n

* CHECK dout2_26 Vdout2_26ck41 = 0 time = 840
.meas tran vdout2_26ck41 FIND v(dout2_26) AT=840.1n

* CHECK dout2_27 Vdout2_27ck41 = 0 time = 840
.meas tran vdout2_27ck41 FIND v(dout2_27) AT=840.1n

* CHECK dout2_28 Vdout2_28ck41 = 0 time = 840
.meas tran vdout2_28ck41 FIND v(dout2_28) AT=840.1n

* CHECK dout2_29 Vdout2_29ck41 = 1.8 time = 840
.meas tran vdout2_29ck41 FIND v(dout2_29) AT=840.1n

* CHECK dout2_30 Vdout2_30ck41 = 0 time = 840
.meas tran vdout2_30ck41 FIND v(dout2_30) AT=840.1n

* CHECK dout2_31 Vdout2_31ck41 = 1.8 time = 840
.meas tran vdout2_31ck41 FIND v(dout2_31) AT=840.1n

* CHECK dout1_0 Vdout1_0ck42 = 0 time = 860
.meas tran vdout1_0ck42 FIND v(dout1_0) AT=860.1n

* CHECK dout1_1 Vdout1_1ck42 = 1.8 time = 860
.meas tran vdout1_1ck42 FIND v(dout1_1) AT=860.1n

* CHECK dout1_2 Vdout1_2ck42 = 1.8 time = 860
.meas tran vdout1_2ck42 FIND v(dout1_2) AT=860.1n

* CHECK dout1_3 Vdout1_3ck42 = 1.8 time = 860
.meas tran vdout1_3ck42 FIND v(dout1_3) AT=860.1n

* CHECK dout1_4 Vdout1_4ck42 = 0 time = 860
.meas tran vdout1_4ck42 FIND v(dout1_4) AT=860.1n

* CHECK dout1_5 Vdout1_5ck42 = 0 time = 860
.meas tran vdout1_5ck42 FIND v(dout1_5) AT=860.1n

* CHECK dout1_6 Vdout1_6ck42 = 0 time = 860
.meas tran vdout1_6ck42 FIND v(dout1_6) AT=860.1n

* CHECK dout1_7 Vdout1_7ck42 = 0 time = 860
.meas tran vdout1_7ck42 FIND v(dout1_7) AT=860.1n

* CHECK dout1_8 Vdout1_8ck42 = 1.8 time = 860
.meas tran vdout1_8ck42 FIND v(dout1_8) AT=860.1n

* CHECK dout1_9 Vdout1_9ck42 = 1.8 time = 860
.meas tran vdout1_9ck42 FIND v(dout1_9) AT=860.1n

* CHECK dout1_10 Vdout1_10ck42 = 0 time = 860
.meas tran vdout1_10ck42 FIND v(dout1_10) AT=860.1n

* CHECK dout1_11 Vdout1_11ck42 = 1.8 time = 860
.meas tran vdout1_11ck42 FIND v(dout1_11) AT=860.1n

* CHECK dout1_12 Vdout1_12ck42 = 0 time = 860
.meas tran vdout1_12ck42 FIND v(dout1_12) AT=860.1n

* CHECK dout1_13 Vdout1_13ck42 = 1.8 time = 860
.meas tran vdout1_13ck42 FIND v(dout1_13) AT=860.1n

* CHECK dout1_14 Vdout1_14ck42 = 1.8 time = 860
.meas tran vdout1_14ck42 FIND v(dout1_14) AT=860.1n

* CHECK dout1_15 Vdout1_15ck42 = 0 time = 860
.meas tran vdout1_15ck42 FIND v(dout1_15) AT=860.1n

* CHECK dout1_16 Vdout1_16ck42 = 0 time = 860
.meas tran vdout1_16ck42 FIND v(dout1_16) AT=860.1n

* CHECK dout1_17 Vdout1_17ck42 = 1.8 time = 860
.meas tran vdout1_17ck42 FIND v(dout1_17) AT=860.1n

* CHECK dout1_18 Vdout1_18ck42 = 1.8 time = 860
.meas tran vdout1_18ck42 FIND v(dout1_18) AT=860.1n

* CHECK dout1_19 Vdout1_19ck42 = 0 time = 860
.meas tran vdout1_19ck42 FIND v(dout1_19) AT=860.1n

* CHECK dout1_20 Vdout1_20ck42 = 0 time = 860
.meas tran vdout1_20ck42 FIND v(dout1_20) AT=860.1n

* CHECK dout1_21 Vdout1_21ck42 = 0 time = 860
.meas tran vdout1_21ck42 FIND v(dout1_21) AT=860.1n

* CHECK dout1_22 Vdout1_22ck42 = 1.8 time = 860
.meas tran vdout1_22ck42 FIND v(dout1_22) AT=860.1n

* CHECK dout1_23 Vdout1_23ck42 = 0 time = 860
.meas tran vdout1_23ck42 FIND v(dout1_23) AT=860.1n

* CHECK dout1_24 Vdout1_24ck42 = 0 time = 860
.meas tran vdout1_24ck42 FIND v(dout1_24) AT=860.1n

* CHECK dout1_25 Vdout1_25ck42 = 0 time = 860
.meas tran vdout1_25ck42 FIND v(dout1_25) AT=860.1n

* CHECK dout1_26 Vdout1_26ck42 = 0 time = 860
.meas tran vdout1_26ck42 FIND v(dout1_26) AT=860.1n

* CHECK dout1_27 Vdout1_27ck42 = 1.8 time = 860
.meas tran vdout1_27ck42 FIND v(dout1_27) AT=860.1n

* CHECK dout1_28 Vdout1_28ck42 = 1.8 time = 860
.meas tran vdout1_28ck42 FIND v(dout1_28) AT=860.1n

* CHECK dout1_29 Vdout1_29ck42 = 0 time = 860
.meas tran vdout1_29ck42 FIND v(dout1_29) AT=860.1n

* CHECK dout1_30 Vdout1_30ck42 = 1.8 time = 860
.meas tran vdout1_30ck42 FIND v(dout1_30) AT=860.1n

* CHECK dout1_31 Vdout1_31ck42 = 1.8 time = 860
.meas tran vdout1_31ck42 FIND v(dout1_31) AT=860.1n

* CHECK dout1_0 Vdout1_0ck43 = 1.8 time = 880
.meas tran vdout1_0ck43 FIND v(dout1_0) AT=880.1n

* CHECK dout1_1 Vdout1_1ck43 = 1.8 time = 880
.meas tran vdout1_1ck43 FIND v(dout1_1) AT=880.1n

* CHECK dout1_2 Vdout1_2ck43 = 0 time = 880
.meas tran vdout1_2ck43 FIND v(dout1_2) AT=880.1n

* CHECK dout1_3 Vdout1_3ck43 = 1.8 time = 880
.meas tran vdout1_3ck43 FIND v(dout1_3) AT=880.1n

* CHECK dout1_4 Vdout1_4ck43 = 0 time = 880
.meas tran vdout1_4ck43 FIND v(dout1_4) AT=880.1n

* CHECK dout1_5 Vdout1_5ck43 = 0 time = 880
.meas tran vdout1_5ck43 FIND v(dout1_5) AT=880.1n

* CHECK dout1_6 Vdout1_6ck43 = 1.8 time = 880
.meas tran vdout1_6ck43 FIND v(dout1_6) AT=880.1n

* CHECK dout1_7 Vdout1_7ck43 = 1.8 time = 880
.meas tran vdout1_7ck43 FIND v(dout1_7) AT=880.1n

* CHECK dout1_8 Vdout1_8ck43 = 1.8 time = 880
.meas tran vdout1_8ck43 FIND v(dout1_8) AT=880.1n

* CHECK dout1_9 Vdout1_9ck43 = 0 time = 880
.meas tran vdout1_9ck43 FIND v(dout1_9) AT=880.1n

* CHECK dout1_10 Vdout1_10ck43 = 1.8 time = 880
.meas tran vdout1_10ck43 FIND v(dout1_10) AT=880.1n

* CHECK dout1_11 Vdout1_11ck43 = 0 time = 880
.meas tran vdout1_11ck43 FIND v(dout1_11) AT=880.1n

* CHECK dout1_12 Vdout1_12ck43 = 1.8 time = 880
.meas tran vdout1_12ck43 FIND v(dout1_12) AT=880.1n

* CHECK dout1_13 Vdout1_13ck43 = 1.8 time = 880
.meas tran vdout1_13ck43 FIND v(dout1_13) AT=880.1n

* CHECK dout1_14 Vdout1_14ck43 = 0 time = 880
.meas tran vdout1_14ck43 FIND v(dout1_14) AT=880.1n

* CHECK dout1_15 Vdout1_15ck43 = 0 time = 880
.meas tran vdout1_15ck43 FIND v(dout1_15) AT=880.1n

* CHECK dout1_16 Vdout1_16ck43 = 0 time = 880
.meas tran vdout1_16ck43 FIND v(dout1_16) AT=880.1n

* CHECK dout1_17 Vdout1_17ck43 = 0 time = 880
.meas tran vdout1_17ck43 FIND v(dout1_17) AT=880.1n

* CHECK dout1_18 Vdout1_18ck43 = 0 time = 880
.meas tran vdout1_18ck43 FIND v(dout1_18) AT=880.1n

* CHECK dout1_19 Vdout1_19ck43 = 1.8 time = 880
.meas tran vdout1_19ck43 FIND v(dout1_19) AT=880.1n

* CHECK dout1_20 Vdout1_20ck43 = 1.8 time = 880
.meas tran vdout1_20ck43 FIND v(dout1_20) AT=880.1n

* CHECK dout1_21 Vdout1_21ck43 = 1.8 time = 880
.meas tran vdout1_21ck43 FIND v(dout1_21) AT=880.1n

* CHECK dout1_22 Vdout1_22ck43 = 1.8 time = 880
.meas tran vdout1_22ck43 FIND v(dout1_22) AT=880.1n

* CHECK dout1_23 Vdout1_23ck43 = 1.8 time = 880
.meas tran vdout1_23ck43 FIND v(dout1_23) AT=880.1n

* CHECK dout1_24 Vdout1_24ck43 = 1.8 time = 880
.meas tran vdout1_24ck43 FIND v(dout1_24) AT=880.1n

* CHECK dout1_25 Vdout1_25ck43 = 1.8 time = 880
.meas tran vdout1_25ck43 FIND v(dout1_25) AT=880.1n

* CHECK dout1_26 Vdout1_26ck43 = 0 time = 880
.meas tran vdout1_26ck43 FIND v(dout1_26) AT=880.1n

* CHECK dout1_27 Vdout1_27ck43 = 1.8 time = 880
.meas tran vdout1_27ck43 FIND v(dout1_27) AT=880.1n

* CHECK dout1_28 Vdout1_28ck43 = 0 time = 880
.meas tran vdout1_28ck43 FIND v(dout1_28) AT=880.1n

* CHECK dout1_29 Vdout1_29ck43 = 1.8 time = 880
.meas tran vdout1_29ck43 FIND v(dout1_29) AT=880.1n

* CHECK dout1_30 Vdout1_30ck43 = 1.8 time = 880
.meas tran vdout1_30ck43 FIND v(dout1_30) AT=880.1n

* CHECK dout1_31 Vdout1_31ck43 = 0 time = 880
.meas tran vdout1_31ck43 FIND v(dout1_31) AT=880.1n

* CHECK dout2_0 Vdout2_0ck43 = 0 time = 880
.meas tran vdout2_0ck43 FIND v(dout2_0) AT=880.1n

* CHECK dout2_1 Vdout2_1ck43 = 0 time = 880
.meas tran vdout2_1ck43 FIND v(dout2_1) AT=880.1n

* CHECK dout2_2 Vdout2_2ck43 = 0 time = 880
.meas tran vdout2_2ck43 FIND v(dout2_2) AT=880.1n

* CHECK dout2_3 Vdout2_3ck43 = 0 time = 880
.meas tran vdout2_3ck43 FIND v(dout2_3) AT=880.1n

* CHECK dout2_4 Vdout2_4ck43 = 0 time = 880
.meas tran vdout2_4ck43 FIND v(dout2_4) AT=880.1n

* CHECK dout2_5 Vdout2_5ck43 = 1.8 time = 880
.meas tran vdout2_5ck43 FIND v(dout2_5) AT=880.1n

* CHECK dout2_6 Vdout2_6ck43 = 0 time = 880
.meas tran vdout2_6ck43 FIND v(dout2_6) AT=880.1n

* CHECK dout2_7 Vdout2_7ck43 = 0 time = 880
.meas tran vdout2_7ck43 FIND v(dout2_7) AT=880.1n

* CHECK dout2_8 Vdout2_8ck43 = 0 time = 880
.meas tran vdout2_8ck43 FIND v(dout2_8) AT=880.1n

* CHECK dout2_9 Vdout2_9ck43 = 0 time = 880
.meas tran vdout2_9ck43 FIND v(dout2_9) AT=880.1n

* CHECK dout2_10 Vdout2_10ck43 = 0 time = 880
.meas tran vdout2_10ck43 FIND v(dout2_10) AT=880.1n

* CHECK dout2_11 Vdout2_11ck43 = 1.8 time = 880
.meas tran vdout2_11ck43 FIND v(dout2_11) AT=880.1n

* CHECK dout2_12 Vdout2_12ck43 = 0 time = 880
.meas tran vdout2_12ck43 FIND v(dout2_12) AT=880.1n

* CHECK dout2_13 Vdout2_13ck43 = 1.8 time = 880
.meas tran vdout2_13ck43 FIND v(dout2_13) AT=880.1n

* CHECK dout2_14 Vdout2_14ck43 = 0 time = 880
.meas tran vdout2_14ck43 FIND v(dout2_14) AT=880.1n

* CHECK dout2_15 Vdout2_15ck43 = 1.8 time = 880
.meas tran vdout2_15ck43 FIND v(dout2_15) AT=880.1n

* CHECK dout2_16 Vdout2_16ck43 = 0 time = 880
.meas tran vdout2_16ck43 FIND v(dout2_16) AT=880.1n

* CHECK dout2_17 Vdout2_17ck43 = 1.8 time = 880
.meas tran vdout2_17ck43 FIND v(dout2_17) AT=880.1n

* CHECK dout2_18 Vdout2_18ck43 = 1.8 time = 880
.meas tran vdout2_18ck43 FIND v(dout2_18) AT=880.1n

* CHECK dout2_19 Vdout2_19ck43 = 1.8 time = 880
.meas tran vdout2_19ck43 FIND v(dout2_19) AT=880.1n

* CHECK dout2_20 Vdout2_20ck43 = 0 time = 880
.meas tran vdout2_20ck43 FIND v(dout2_20) AT=880.1n

* CHECK dout2_21 Vdout2_21ck43 = 1.8 time = 880
.meas tran vdout2_21ck43 FIND v(dout2_21) AT=880.1n

* CHECK dout2_22 Vdout2_22ck43 = 1.8 time = 880
.meas tran vdout2_22ck43 FIND v(dout2_22) AT=880.1n

* CHECK dout2_23 Vdout2_23ck43 = 0 time = 880
.meas tran vdout2_23ck43 FIND v(dout2_23) AT=880.1n

* CHECK dout2_24 Vdout2_24ck43 = 0 time = 880
.meas tran vdout2_24ck43 FIND v(dout2_24) AT=880.1n

* CHECK dout2_25 Vdout2_25ck43 = 1.8 time = 880
.meas tran vdout2_25ck43 FIND v(dout2_25) AT=880.1n

* CHECK dout2_26 Vdout2_26ck43 = 1.8 time = 880
.meas tran vdout2_26ck43 FIND v(dout2_26) AT=880.1n

* CHECK dout2_27 Vdout2_27ck43 = 1.8 time = 880
.meas tran vdout2_27ck43 FIND v(dout2_27) AT=880.1n

* CHECK dout2_28 Vdout2_28ck43 = 0 time = 880
.meas tran vdout2_28ck43 FIND v(dout2_28) AT=880.1n

* CHECK dout2_29 Vdout2_29ck43 = 0 time = 880
.meas tran vdout2_29ck43 FIND v(dout2_29) AT=880.1n

* CHECK dout2_30 Vdout2_30ck43 = 0 time = 880
.meas tran vdout2_30ck43 FIND v(dout2_30) AT=880.1n

* CHECK dout2_31 Vdout2_31ck43 = 0 time = 880
.meas tran vdout2_31ck43 FIND v(dout2_31) AT=880.1n

* CHECK dout1_0 Vdout1_0ck44 = 1.8 time = 900
.meas tran vdout1_0ck44 FIND v(dout1_0) AT=900.1n

* CHECK dout1_1 Vdout1_1ck44 = 1.8 time = 900
.meas tran vdout1_1ck44 FIND v(dout1_1) AT=900.1n

* CHECK dout1_2 Vdout1_2ck44 = 0 time = 900
.meas tran vdout1_2ck44 FIND v(dout1_2) AT=900.1n

* CHECK dout1_3 Vdout1_3ck44 = 1.8 time = 900
.meas tran vdout1_3ck44 FIND v(dout1_3) AT=900.1n

* CHECK dout1_4 Vdout1_4ck44 = 0 time = 900
.meas tran vdout1_4ck44 FIND v(dout1_4) AT=900.1n

* CHECK dout1_5 Vdout1_5ck44 = 0 time = 900
.meas tran vdout1_5ck44 FIND v(dout1_5) AT=900.1n

* CHECK dout1_6 Vdout1_6ck44 = 1.8 time = 900
.meas tran vdout1_6ck44 FIND v(dout1_6) AT=900.1n

* CHECK dout1_7 Vdout1_7ck44 = 1.8 time = 900
.meas tran vdout1_7ck44 FIND v(dout1_7) AT=900.1n

* CHECK dout1_8 Vdout1_8ck44 = 1.8 time = 900
.meas tran vdout1_8ck44 FIND v(dout1_8) AT=900.1n

* CHECK dout1_9 Vdout1_9ck44 = 0 time = 900
.meas tran vdout1_9ck44 FIND v(dout1_9) AT=900.1n

* CHECK dout1_10 Vdout1_10ck44 = 1.8 time = 900
.meas tran vdout1_10ck44 FIND v(dout1_10) AT=900.1n

* CHECK dout1_11 Vdout1_11ck44 = 0 time = 900
.meas tran vdout1_11ck44 FIND v(dout1_11) AT=900.1n

* CHECK dout1_12 Vdout1_12ck44 = 1.8 time = 900
.meas tran vdout1_12ck44 FIND v(dout1_12) AT=900.1n

* CHECK dout1_13 Vdout1_13ck44 = 1.8 time = 900
.meas tran vdout1_13ck44 FIND v(dout1_13) AT=900.1n

* CHECK dout1_14 Vdout1_14ck44 = 0 time = 900
.meas tran vdout1_14ck44 FIND v(dout1_14) AT=900.1n

* CHECK dout1_15 Vdout1_15ck44 = 0 time = 900
.meas tran vdout1_15ck44 FIND v(dout1_15) AT=900.1n

* CHECK dout1_16 Vdout1_16ck44 = 0 time = 900
.meas tran vdout1_16ck44 FIND v(dout1_16) AT=900.1n

* CHECK dout1_17 Vdout1_17ck44 = 0 time = 900
.meas tran vdout1_17ck44 FIND v(dout1_17) AT=900.1n

* CHECK dout1_18 Vdout1_18ck44 = 0 time = 900
.meas tran vdout1_18ck44 FIND v(dout1_18) AT=900.1n

* CHECK dout1_19 Vdout1_19ck44 = 1.8 time = 900
.meas tran vdout1_19ck44 FIND v(dout1_19) AT=900.1n

* CHECK dout1_20 Vdout1_20ck44 = 1.8 time = 900
.meas tran vdout1_20ck44 FIND v(dout1_20) AT=900.1n

* CHECK dout1_21 Vdout1_21ck44 = 1.8 time = 900
.meas tran vdout1_21ck44 FIND v(dout1_21) AT=900.1n

* CHECK dout1_22 Vdout1_22ck44 = 1.8 time = 900
.meas tran vdout1_22ck44 FIND v(dout1_22) AT=900.1n

* CHECK dout1_23 Vdout1_23ck44 = 1.8 time = 900
.meas tran vdout1_23ck44 FIND v(dout1_23) AT=900.1n

* CHECK dout1_24 Vdout1_24ck44 = 1.8 time = 900
.meas tran vdout1_24ck44 FIND v(dout1_24) AT=900.1n

* CHECK dout1_25 Vdout1_25ck44 = 1.8 time = 900
.meas tran vdout1_25ck44 FIND v(dout1_25) AT=900.1n

* CHECK dout1_26 Vdout1_26ck44 = 0 time = 900
.meas tran vdout1_26ck44 FIND v(dout1_26) AT=900.1n

* CHECK dout1_27 Vdout1_27ck44 = 1.8 time = 900
.meas tran vdout1_27ck44 FIND v(dout1_27) AT=900.1n

* CHECK dout1_28 Vdout1_28ck44 = 0 time = 900
.meas tran vdout1_28ck44 FIND v(dout1_28) AT=900.1n

* CHECK dout1_29 Vdout1_29ck44 = 1.8 time = 900
.meas tran vdout1_29ck44 FIND v(dout1_29) AT=900.1n

* CHECK dout1_30 Vdout1_30ck44 = 1.8 time = 900
.meas tran vdout1_30ck44 FIND v(dout1_30) AT=900.1n

* CHECK dout1_31 Vdout1_31ck44 = 0 time = 900
.meas tran vdout1_31ck44 FIND v(dout1_31) AT=900.1n

* CHECK dout1_0 Vdout1_0ck45 = 0 time = 920
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=920.1n

* CHECK dout1_1 Vdout1_1ck45 = 1.8 time = 920
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=920.1n

* CHECK dout1_2 Vdout1_2ck45 = 1.8 time = 920
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=920.1n

* CHECK dout1_3 Vdout1_3ck45 = 1.8 time = 920
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=920.1n

* CHECK dout1_4 Vdout1_4ck45 = 0 time = 920
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=920.1n

* CHECK dout1_5 Vdout1_5ck45 = 0 time = 920
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=920.1n

* CHECK dout1_6 Vdout1_6ck45 = 0 time = 920
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=920.1n

* CHECK dout1_7 Vdout1_7ck45 = 0 time = 920
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=920.1n

* CHECK dout1_8 Vdout1_8ck45 = 1.8 time = 920
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=920.1n

* CHECK dout1_9 Vdout1_9ck45 = 1.8 time = 920
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=920.1n

* CHECK dout1_10 Vdout1_10ck45 = 0 time = 920
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=920.1n

* CHECK dout1_11 Vdout1_11ck45 = 1.8 time = 920
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=920.1n

* CHECK dout1_12 Vdout1_12ck45 = 0 time = 920
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=920.1n

* CHECK dout1_13 Vdout1_13ck45 = 1.8 time = 920
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=920.1n

* CHECK dout1_14 Vdout1_14ck45 = 1.8 time = 920
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=920.1n

* CHECK dout1_15 Vdout1_15ck45 = 0 time = 920
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=920.1n

* CHECK dout1_16 Vdout1_16ck45 = 0 time = 920
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=920.1n

* CHECK dout1_17 Vdout1_17ck45 = 1.8 time = 920
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=920.1n

* CHECK dout1_18 Vdout1_18ck45 = 1.8 time = 920
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=920.1n

* CHECK dout1_19 Vdout1_19ck45 = 0 time = 920
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=920.1n

* CHECK dout1_20 Vdout1_20ck45 = 0 time = 920
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=920.1n

* CHECK dout1_21 Vdout1_21ck45 = 0 time = 920
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=920.1n

* CHECK dout1_22 Vdout1_22ck45 = 1.8 time = 920
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=920.1n

* CHECK dout1_23 Vdout1_23ck45 = 0 time = 920
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=920.1n

* CHECK dout1_24 Vdout1_24ck45 = 0 time = 920
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=920.1n

* CHECK dout1_25 Vdout1_25ck45 = 0 time = 920
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=920.1n

* CHECK dout1_26 Vdout1_26ck45 = 0 time = 920
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=920.1n

* CHECK dout1_27 Vdout1_27ck45 = 1.8 time = 920
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=920.1n

* CHECK dout1_28 Vdout1_28ck45 = 1.8 time = 920
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=920.1n

* CHECK dout1_29 Vdout1_29ck45 = 0 time = 920
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=920.1n

* CHECK dout1_30 Vdout1_30ck45 = 1.8 time = 920
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=920.1n

* CHECK dout1_31 Vdout1_31ck45 = 1.8 time = 920
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=920.1n

* CHECK dout2_0 Vdout2_0ck45 = 1.8 time = 920
.meas tran vdout2_0ck45 FIND v(dout2_0) AT=920.1n

* CHECK dout2_1 Vdout2_1ck45 = 1.8 time = 920
.meas tran vdout2_1ck45 FIND v(dout2_1) AT=920.1n

* CHECK dout2_2 Vdout2_2ck45 = 0 time = 920
.meas tran vdout2_2ck45 FIND v(dout2_2) AT=920.1n

* CHECK dout2_3 Vdout2_3ck45 = 1.8 time = 920
.meas tran vdout2_3ck45 FIND v(dout2_3) AT=920.1n

* CHECK dout2_4 Vdout2_4ck45 = 0 time = 920
.meas tran vdout2_4ck45 FIND v(dout2_4) AT=920.1n

* CHECK dout2_5 Vdout2_5ck45 = 0 time = 920
.meas tran vdout2_5ck45 FIND v(dout2_5) AT=920.1n

* CHECK dout2_6 Vdout2_6ck45 = 1.8 time = 920
.meas tran vdout2_6ck45 FIND v(dout2_6) AT=920.1n

* CHECK dout2_7 Vdout2_7ck45 = 1.8 time = 920
.meas tran vdout2_7ck45 FIND v(dout2_7) AT=920.1n

* CHECK dout2_8 Vdout2_8ck45 = 1.8 time = 920
.meas tran vdout2_8ck45 FIND v(dout2_8) AT=920.1n

* CHECK dout2_9 Vdout2_9ck45 = 0 time = 920
.meas tran vdout2_9ck45 FIND v(dout2_9) AT=920.1n

* CHECK dout2_10 Vdout2_10ck45 = 1.8 time = 920
.meas tran vdout2_10ck45 FIND v(dout2_10) AT=920.1n

* CHECK dout2_11 Vdout2_11ck45 = 0 time = 920
.meas tran vdout2_11ck45 FIND v(dout2_11) AT=920.1n

* CHECK dout2_12 Vdout2_12ck45 = 1.8 time = 920
.meas tran vdout2_12ck45 FIND v(dout2_12) AT=920.1n

* CHECK dout2_13 Vdout2_13ck45 = 1.8 time = 920
.meas tran vdout2_13ck45 FIND v(dout2_13) AT=920.1n

* CHECK dout2_14 Vdout2_14ck45 = 0 time = 920
.meas tran vdout2_14ck45 FIND v(dout2_14) AT=920.1n

* CHECK dout2_15 Vdout2_15ck45 = 0 time = 920
.meas tran vdout2_15ck45 FIND v(dout2_15) AT=920.1n

* CHECK dout2_16 Vdout2_16ck45 = 0 time = 920
.meas tran vdout2_16ck45 FIND v(dout2_16) AT=920.1n

* CHECK dout2_17 Vdout2_17ck45 = 0 time = 920
.meas tran vdout2_17ck45 FIND v(dout2_17) AT=920.1n

* CHECK dout2_18 Vdout2_18ck45 = 0 time = 920
.meas tran vdout2_18ck45 FIND v(dout2_18) AT=920.1n

* CHECK dout2_19 Vdout2_19ck45 = 1.8 time = 920
.meas tran vdout2_19ck45 FIND v(dout2_19) AT=920.1n

* CHECK dout2_20 Vdout2_20ck45 = 1.8 time = 920
.meas tran vdout2_20ck45 FIND v(dout2_20) AT=920.1n

* CHECK dout2_21 Vdout2_21ck45 = 1.8 time = 920
.meas tran vdout2_21ck45 FIND v(dout2_21) AT=920.1n

* CHECK dout2_22 Vdout2_22ck45 = 1.8 time = 920
.meas tran vdout2_22ck45 FIND v(dout2_22) AT=920.1n

* CHECK dout2_23 Vdout2_23ck45 = 1.8 time = 920
.meas tran vdout2_23ck45 FIND v(dout2_23) AT=920.1n

* CHECK dout2_24 Vdout2_24ck45 = 1.8 time = 920
.meas tran vdout2_24ck45 FIND v(dout2_24) AT=920.1n

* CHECK dout2_25 Vdout2_25ck45 = 1.8 time = 920
.meas tran vdout2_25ck45 FIND v(dout2_25) AT=920.1n

* CHECK dout2_26 Vdout2_26ck45 = 0 time = 920
.meas tran vdout2_26ck45 FIND v(dout2_26) AT=920.1n

* CHECK dout2_27 Vdout2_27ck45 = 1.8 time = 920
.meas tran vdout2_27ck45 FIND v(dout2_27) AT=920.1n

* CHECK dout2_28 Vdout2_28ck45 = 0 time = 920
.meas tran vdout2_28ck45 FIND v(dout2_28) AT=920.1n

* CHECK dout2_29 Vdout2_29ck45 = 1.8 time = 920
.meas tran vdout2_29ck45 FIND v(dout2_29) AT=920.1n

* CHECK dout2_30 Vdout2_30ck45 = 1.8 time = 920
.meas tran vdout2_30ck45 FIND v(dout2_30) AT=920.1n

* CHECK dout2_31 Vdout2_31ck45 = 0 time = 920
.meas tran vdout2_31ck45 FIND v(dout2_31) AT=920.1n

* CHECK dout2_0 Vdout2_0ck46 = 0 time = 940
.meas tran vdout2_0ck46 FIND v(dout2_0) AT=940.1n

* CHECK dout2_1 Vdout2_1ck46 = 1.8 time = 940
.meas tran vdout2_1ck46 FIND v(dout2_1) AT=940.1n

* CHECK dout2_2 Vdout2_2ck46 = 1.8 time = 940
.meas tran vdout2_2ck46 FIND v(dout2_2) AT=940.1n

* CHECK dout2_3 Vdout2_3ck46 = 1.8 time = 940
.meas tran vdout2_3ck46 FIND v(dout2_3) AT=940.1n

* CHECK dout2_4 Vdout2_4ck46 = 0 time = 940
.meas tran vdout2_4ck46 FIND v(dout2_4) AT=940.1n

* CHECK dout2_5 Vdout2_5ck46 = 0 time = 940
.meas tran vdout2_5ck46 FIND v(dout2_5) AT=940.1n

* CHECK dout2_6 Vdout2_6ck46 = 0 time = 940
.meas tran vdout2_6ck46 FIND v(dout2_6) AT=940.1n

* CHECK dout2_7 Vdout2_7ck46 = 0 time = 940
.meas tran vdout2_7ck46 FIND v(dout2_7) AT=940.1n

* CHECK dout2_8 Vdout2_8ck46 = 1.8 time = 940
.meas tran vdout2_8ck46 FIND v(dout2_8) AT=940.1n

* CHECK dout2_9 Vdout2_9ck46 = 1.8 time = 940
.meas tran vdout2_9ck46 FIND v(dout2_9) AT=940.1n

* CHECK dout2_10 Vdout2_10ck46 = 0 time = 940
.meas tran vdout2_10ck46 FIND v(dout2_10) AT=940.1n

* CHECK dout2_11 Vdout2_11ck46 = 1.8 time = 940
.meas tran vdout2_11ck46 FIND v(dout2_11) AT=940.1n

* CHECK dout2_12 Vdout2_12ck46 = 0 time = 940
.meas tran vdout2_12ck46 FIND v(dout2_12) AT=940.1n

* CHECK dout2_13 Vdout2_13ck46 = 1.8 time = 940
.meas tran vdout2_13ck46 FIND v(dout2_13) AT=940.1n

* CHECK dout2_14 Vdout2_14ck46 = 1.8 time = 940
.meas tran vdout2_14ck46 FIND v(dout2_14) AT=940.1n

* CHECK dout2_15 Vdout2_15ck46 = 0 time = 940
.meas tran vdout2_15ck46 FIND v(dout2_15) AT=940.1n

* CHECK dout2_16 Vdout2_16ck46 = 0 time = 940
.meas tran vdout2_16ck46 FIND v(dout2_16) AT=940.1n

* CHECK dout2_17 Vdout2_17ck46 = 1.8 time = 940
.meas tran vdout2_17ck46 FIND v(dout2_17) AT=940.1n

* CHECK dout2_18 Vdout2_18ck46 = 1.8 time = 940
.meas tran vdout2_18ck46 FIND v(dout2_18) AT=940.1n

* CHECK dout2_19 Vdout2_19ck46 = 0 time = 940
.meas tran vdout2_19ck46 FIND v(dout2_19) AT=940.1n

* CHECK dout2_20 Vdout2_20ck46 = 0 time = 940
.meas tran vdout2_20ck46 FIND v(dout2_20) AT=940.1n

* CHECK dout2_21 Vdout2_21ck46 = 0 time = 940
.meas tran vdout2_21ck46 FIND v(dout2_21) AT=940.1n

* CHECK dout2_22 Vdout2_22ck46 = 1.8 time = 940
.meas tran vdout2_22ck46 FIND v(dout2_22) AT=940.1n

* CHECK dout2_23 Vdout2_23ck46 = 0 time = 940
.meas tran vdout2_23ck46 FIND v(dout2_23) AT=940.1n

* CHECK dout2_24 Vdout2_24ck46 = 0 time = 940
.meas tran vdout2_24ck46 FIND v(dout2_24) AT=940.1n

* CHECK dout2_25 Vdout2_25ck46 = 0 time = 940
.meas tran vdout2_25ck46 FIND v(dout2_25) AT=940.1n

* CHECK dout2_26 Vdout2_26ck46 = 0 time = 940
.meas tran vdout2_26ck46 FIND v(dout2_26) AT=940.1n

* CHECK dout2_27 Vdout2_27ck46 = 1.8 time = 940
.meas tran vdout2_27ck46 FIND v(dout2_27) AT=940.1n

* CHECK dout2_28 Vdout2_28ck46 = 1.8 time = 940
.meas tran vdout2_28ck46 FIND v(dout2_28) AT=940.1n

* CHECK dout2_29 Vdout2_29ck46 = 0 time = 940
.meas tran vdout2_29ck46 FIND v(dout2_29) AT=940.1n

* CHECK dout2_30 Vdout2_30ck46 = 1.8 time = 940
.meas tran vdout2_30ck46 FIND v(dout2_30) AT=940.1n

* CHECK dout2_31 Vdout2_31ck46 = 1.8 time = 940
.meas tran vdout2_31ck46 FIND v(dout2_31) AT=940.1n

* CHECK dout1_0 Vdout1_0ck47 = 1.8 time = 960
.meas tran vdout1_0ck47 FIND v(dout1_0) AT=960.1n

* CHECK dout1_1 Vdout1_1ck47 = 1.8 time = 960
.meas tran vdout1_1ck47 FIND v(dout1_1) AT=960.1n

* CHECK dout1_2 Vdout1_2ck47 = 0 time = 960
.meas tran vdout1_2ck47 FIND v(dout1_2) AT=960.1n

* CHECK dout1_3 Vdout1_3ck47 = 1.8 time = 960
.meas tran vdout1_3ck47 FIND v(dout1_3) AT=960.1n

* CHECK dout1_4 Vdout1_4ck47 = 0 time = 960
.meas tran vdout1_4ck47 FIND v(dout1_4) AT=960.1n

* CHECK dout1_5 Vdout1_5ck47 = 0 time = 960
.meas tran vdout1_5ck47 FIND v(dout1_5) AT=960.1n

* CHECK dout1_6 Vdout1_6ck47 = 1.8 time = 960
.meas tran vdout1_6ck47 FIND v(dout1_6) AT=960.1n

* CHECK dout1_7 Vdout1_7ck47 = 1.8 time = 960
.meas tran vdout1_7ck47 FIND v(dout1_7) AT=960.1n

* CHECK dout1_8 Vdout1_8ck47 = 1.8 time = 960
.meas tran vdout1_8ck47 FIND v(dout1_8) AT=960.1n

* CHECK dout1_9 Vdout1_9ck47 = 0 time = 960
.meas tran vdout1_9ck47 FIND v(dout1_9) AT=960.1n

* CHECK dout1_10 Vdout1_10ck47 = 1.8 time = 960
.meas tran vdout1_10ck47 FIND v(dout1_10) AT=960.1n

* CHECK dout1_11 Vdout1_11ck47 = 0 time = 960
.meas tran vdout1_11ck47 FIND v(dout1_11) AT=960.1n

* CHECK dout1_12 Vdout1_12ck47 = 1.8 time = 960
.meas tran vdout1_12ck47 FIND v(dout1_12) AT=960.1n

* CHECK dout1_13 Vdout1_13ck47 = 1.8 time = 960
.meas tran vdout1_13ck47 FIND v(dout1_13) AT=960.1n

* CHECK dout1_14 Vdout1_14ck47 = 0 time = 960
.meas tran vdout1_14ck47 FIND v(dout1_14) AT=960.1n

* CHECK dout1_15 Vdout1_15ck47 = 0 time = 960
.meas tran vdout1_15ck47 FIND v(dout1_15) AT=960.1n

* CHECK dout1_16 Vdout1_16ck47 = 0 time = 960
.meas tran vdout1_16ck47 FIND v(dout1_16) AT=960.1n

* CHECK dout1_17 Vdout1_17ck47 = 0 time = 960
.meas tran vdout1_17ck47 FIND v(dout1_17) AT=960.1n

* CHECK dout1_18 Vdout1_18ck47 = 0 time = 960
.meas tran vdout1_18ck47 FIND v(dout1_18) AT=960.1n

* CHECK dout1_19 Vdout1_19ck47 = 1.8 time = 960
.meas tran vdout1_19ck47 FIND v(dout1_19) AT=960.1n

* CHECK dout1_20 Vdout1_20ck47 = 1.8 time = 960
.meas tran vdout1_20ck47 FIND v(dout1_20) AT=960.1n

* CHECK dout1_21 Vdout1_21ck47 = 1.8 time = 960
.meas tran vdout1_21ck47 FIND v(dout1_21) AT=960.1n

* CHECK dout1_22 Vdout1_22ck47 = 1.8 time = 960
.meas tran vdout1_22ck47 FIND v(dout1_22) AT=960.1n

* CHECK dout1_23 Vdout1_23ck47 = 1.8 time = 960
.meas tran vdout1_23ck47 FIND v(dout1_23) AT=960.1n

* CHECK dout1_24 Vdout1_24ck47 = 1.8 time = 960
.meas tran vdout1_24ck47 FIND v(dout1_24) AT=960.1n

* CHECK dout1_25 Vdout1_25ck47 = 1.8 time = 960
.meas tran vdout1_25ck47 FIND v(dout1_25) AT=960.1n

* CHECK dout1_26 Vdout1_26ck47 = 0 time = 960
.meas tran vdout1_26ck47 FIND v(dout1_26) AT=960.1n

* CHECK dout1_27 Vdout1_27ck47 = 1.8 time = 960
.meas tran vdout1_27ck47 FIND v(dout1_27) AT=960.1n

* CHECK dout1_28 Vdout1_28ck47 = 0 time = 960
.meas tran vdout1_28ck47 FIND v(dout1_28) AT=960.1n

* CHECK dout1_29 Vdout1_29ck47 = 1.8 time = 960
.meas tran vdout1_29ck47 FIND v(dout1_29) AT=960.1n

* CHECK dout1_30 Vdout1_30ck47 = 1.8 time = 960
.meas tran vdout1_30ck47 FIND v(dout1_30) AT=960.1n

* CHECK dout1_31 Vdout1_31ck47 = 0 time = 960
.meas tran vdout1_31ck47 FIND v(dout1_31) AT=960.1n

* CHECK dout2_0 Vdout2_0ck47 = 0 time = 960
.meas tran vdout2_0ck47 FIND v(dout2_0) AT=960.1n

* CHECK dout2_1 Vdout2_1ck47 = 0 time = 960
.meas tran vdout2_1ck47 FIND v(dout2_1) AT=960.1n

* CHECK dout2_2 Vdout2_2ck47 = 1.8 time = 960
.meas tran vdout2_2ck47 FIND v(dout2_2) AT=960.1n

* CHECK dout2_3 Vdout2_3ck47 = 0 time = 960
.meas tran vdout2_3ck47 FIND v(dout2_3) AT=960.1n

* CHECK dout2_4 Vdout2_4ck47 = 0 time = 960
.meas tran vdout2_4ck47 FIND v(dout2_4) AT=960.1n

* CHECK dout2_5 Vdout2_5ck47 = 0 time = 960
.meas tran vdout2_5ck47 FIND v(dout2_5) AT=960.1n

* CHECK dout2_6 Vdout2_6ck47 = 1.8 time = 960
.meas tran vdout2_6ck47 FIND v(dout2_6) AT=960.1n

* CHECK dout2_7 Vdout2_7ck47 = 0 time = 960
.meas tran vdout2_7ck47 FIND v(dout2_7) AT=960.1n

* CHECK dout2_8 Vdout2_8ck47 = 1.8 time = 960
.meas tran vdout2_8ck47 FIND v(dout2_8) AT=960.1n

* CHECK dout2_9 Vdout2_9ck47 = 0 time = 960
.meas tran vdout2_9ck47 FIND v(dout2_9) AT=960.1n

* CHECK dout2_10 Vdout2_10ck47 = 0 time = 960
.meas tran vdout2_10ck47 FIND v(dout2_10) AT=960.1n

* CHECK dout2_11 Vdout2_11ck47 = 1.8 time = 960
.meas tran vdout2_11ck47 FIND v(dout2_11) AT=960.1n

* CHECK dout2_12 Vdout2_12ck47 = 0 time = 960
.meas tran vdout2_12ck47 FIND v(dout2_12) AT=960.1n

* CHECK dout2_13 Vdout2_13ck47 = 1.8 time = 960
.meas tran vdout2_13ck47 FIND v(dout2_13) AT=960.1n

* CHECK dout2_14 Vdout2_14ck47 = 1.8 time = 960
.meas tran vdout2_14ck47 FIND v(dout2_14) AT=960.1n

* CHECK dout2_15 Vdout2_15ck47 = 1.8 time = 960
.meas tran vdout2_15ck47 FIND v(dout2_15) AT=960.1n

* CHECK dout2_16 Vdout2_16ck47 = 0 time = 960
.meas tran vdout2_16ck47 FIND v(dout2_16) AT=960.1n

* CHECK dout2_17 Vdout2_17ck47 = 0 time = 960
.meas tran vdout2_17ck47 FIND v(dout2_17) AT=960.1n

* CHECK dout2_18 Vdout2_18ck47 = 1.8 time = 960
.meas tran vdout2_18ck47 FIND v(dout2_18) AT=960.1n

* CHECK dout2_19 Vdout2_19ck47 = 1.8 time = 960
.meas tran vdout2_19ck47 FIND v(dout2_19) AT=960.1n

* CHECK dout2_20 Vdout2_20ck47 = 1.8 time = 960
.meas tran vdout2_20ck47 FIND v(dout2_20) AT=960.1n

* CHECK dout2_21 Vdout2_21ck47 = 1.8 time = 960
.meas tran vdout2_21ck47 FIND v(dout2_21) AT=960.1n

* CHECK dout2_22 Vdout2_22ck47 = 0 time = 960
.meas tran vdout2_22ck47 FIND v(dout2_22) AT=960.1n

* CHECK dout2_23 Vdout2_23ck47 = 0 time = 960
.meas tran vdout2_23ck47 FIND v(dout2_23) AT=960.1n

* CHECK dout2_24 Vdout2_24ck47 = 0 time = 960
.meas tran vdout2_24ck47 FIND v(dout2_24) AT=960.1n

* CHECK dout2_25 Vdout2_25ck47 = 0 time = 960
.meas tran vdout2_25ck47 FIND v(dout2_25) AT=960.1n

* CHECK dout2_26 Vdout2_26ck47 = 1.8 time = 960
.meas tran vdout2_26ck47 FIND v(dout2_26) AT=960.1n

* CHECK dout2_27 Vdout2_27ck47 = 1.8 time = 960
.meas tran vdout2_27ck47 FIND v(dout2_27) AT=960.1n

* CHECK dout2_28 Vdout2_28ck47 = 0 time = 960
.meas tran vdout2_28ck47 FIND v(dout2_28) AT=960.1n

* CHECK dout2_29 Vdout2_29ck47 = 0 time = 960
.meas tran vdout2_29ck47 FIND v(dout2_29) AT=960.1n

* CHECK dout2_30 Vdout2_30ck47 = 1.8 time = 960
.meas tran vdout2_30ck47 FIND v(dout2_30) AT=960.1n

* CHECK dout2_31 Vdout2_31ck47 = 1.8 time = 960
.meas tran vdout2_31ck47 FIND v(dout2_31) AT=960.1n

* CHECK dout1_0 Vdout1_0ck48 = 0 time = 980
.meas tran vdout1_0ck48 FIND v(dout1_0) AT=980.1n

* CHECK dout1_1 Vdout1_1ck48 = 1.8 time = 980
.meas tran vdout1_1ck48 FIND v(dout1_1) AT=980.1n

* CHECK dout1_2 Vdout1_2ck48 = 0 time = 980
.meas tran vdout1_2ck48 FIND v(dout1_2) AT=980.1n

* CHECK dout1_3 Vdout1_3ck48 = 0 time = 980
.meas tran vdout1_3ck48 FIND v(dout1_3) AT=980.1n

* CHECK dout1_4 Vdout1_4ck48 = 1.8 time = 980
.meas tran vdout1_4ck48 FIND v(dout1_4) AT=980.1n

* CHECK dout1_5 Vdout1_5ck48 = 0 time = 980
.meas tran vdout1_5ck48 FIND v(dout1_5) AT=980.1n

* CHECK dout1_6 Vdout1_6ck48 = 1.8 time = 980
.meas tran vdout1_6ck48 FIND v(dout1_6) AT=980.1n

* CHECK dout1_7 Vdout1_7ck48 = 0 time = 980
.meas tran vdout1_7ck48 FIND v(dout1_7) AT=980.1n

* CHECK dout1_8 Vdout1_8ck48 = 0 time = 980
.meas tran vdout1_8ck48 FIND v(dout1_8) AT=980.1n

* CHECK dout1_9 Vdout1_9ck48 = 1.8 time = 980
.meas tran vdout1_9ck48 FIND v(dout1_9) AT=980.1n

* CHECK dout1_10 Vdout1_10ck48 = 1.8 time = 980
.meas tran vdout1_10ck48 FIND v(dout1_10) AT=980.1n

* CHECK dout1_11 Vdout1_11ck48 = 1.8 time = 980
.meas tran vdout1_11ck48 FIND v(dout1_11) AT=980.1n

* CHECK dout1_12 Vdout1_12ck48 = 1.8 time = 980
.meas tran vdout1_12ck48 FIND v(dout1_12) AT=980.1n

* CHECK dout1_13 Vdout1_13ck48 = 1.8 time = 980
.meas tran vdout1_13ck48 FIND v(dout1_13) AT=980.1n

* CHECK dout1_14 Vdout1_14ck48 = 0 time = 980
.meas tran vdout1_14ck48 FIND v(dout1_14) AT=980.1n

* CHECK dout1_15 Vdout1_15ck48 = 1.8 time = 980
.meas tran vdout1_15ck48 FIND v(dout1_15) AT=980.1n

* CHECK dout1_16 Vdout1_16ck48 = 0 time = 980
.meas tran vdout1_16ck48 FIND v(dout1_16) AT=980.1n

* CHECK dout1_17 Vdout1_17ck48 = 1.8 time = 980
.meas tran vdout1_17ck48 FIND v(dout1_17) AT=980.1n

* CHECK dout1_18 Vdout1_18ck48 = 1.8 time = 980
.meas tran vdout1_18ck48 FIND v(dout1_18) AT=980.1n

* CHECK dout1_19 Vdout1_19ck48 = 0 time = 980
.meas tran vdout1_19ck48 FIND v(dout1_19) AT=980.1n

* CHECK dout1_20 Vdout1_20ck48 = 1.8 time = 980
.meas tran vdout1_20ck48 FIND v(dout1_20) AT=980.1n

* CHECK dout1_21 Vdout1_21ck48 = 1.8 time = 980
.meas tran vdout1_21ck48 FIND v(dout1_21) AT=980.1n

* CHECK dout1_22 Vdout1_22ck48 = 0 time = 980
.meas tran vdout1_22ck48 FIND v(dout1_22) AT=980.1n

* CHECK dout1_23 Vdout1_23ck48 = 1.8 time = 980
.meas tran vdout1_23ck48 FIND v(dout1_23) AT=980.1n

* CHECK dout1_24 Vdout1_24ck48 = 0 time = 980
.meas tran vdout1_24ck48 FIND v(dout1_24) AT=980.1n

* CHECK dout1_25 Vdout1_25ck48 = 1.8 time = 980
.meas tran vdout1_25ck48 FIND v(dout1_25) AT=980.1n

* CHECK dout1_26 Vdout1_26ck48 = 1.8 time = 980
.meas tran vdout1_26ck48 FIND v(dout1_26) AT=980.1n

* CHECK dout1_27 Vdout1_27ck48 = 1.8 time = 980
.meas tran vdout1_27ck48 FIND v(dout1_27) AT=980.1n

* CHECK dout1_28 Vdout1_28ck48 = 0 time = 980
.meas tran vdout1_28ck48 FIND v(dout1_28) AT=980.1n

* CHECK dout1_29 Vdout1_29ck48 = 0 time = 980
.meas tran vdout1_29ck48 FIND v(dout1_29) AT=980.1n

* CHECK dout1_30 Vdout1_30ck48 = 0 time = 980
.meas tran vdout1_30ck48 FIND v(dout1_30) AT=980.1n

* CHECK dout1_31 Vdout1_31ck48 = 0 time = 980
.meas tran vdout1_31ck48 FIND v(dout1_31) AT=980.1n

* CHECK dout1_0 Vdout1_0ck49 = 1.8 time = 1000
.meas tran vdout1_0ck49 FIND v(dout1_0) AT=1000.1n

* CHECK dout1_1 Vdout1_1ck49 = 1.8 time = 1000
.meas tran vdout1_1ck49 FIND v(dout1_1) AT=1000.1n

* CHECK dout1_2 Vdout1_2ck49 = 1.8 time = 1000
.meas tran vdout1_2ck49 FIND v(dout1_2) AT=1000.1n

* CHECK dout1_3 Vdout1_3ck49 = 0 time = 1000
.meas tran vdout1_3ck49 FIND v(dout1_3) AT=1000.1n

* CHECK dout1_4 Vdout1_4ck49 = 0 time = 1000
.meas tran vdout1_4ck49 FIND v(dout1_4) AT=1000.1n

* CHECK dout1_5 Vdout1_5ck49 = 0 time = 1000
.meas tran vdout1_5ck49 FIND v(dout1_5) AT=1000.1n

* CHECK dout1_6 Vdout1_6ck49 = 0 time = 1000
.meas tran vdout1_6ck49 FIND v(dout1_6) AT=1000.1n

* CHECK dout1_7 Vdout1_7ck49 = 1.8 time = 1000
.meas tran vdout1_7ck49 FIND v(dout1_7) AT=1000.1n

* CHECK dout1_8 Vdout1_8ck49 = 0 time = 1000
.meas tran vdout1_8ck49 FIND v(dout1_8) AT=1000.1n

* CHECK dout1_9 Vdout1_9ck49 = 1.8 time = 1000
.meas tran vdout1_9ck49 FIND v(dout1_9) AT=1000.1n

* CHECK dout1_10 Vdout1_10ck49 = 0 time = 1000
.meas tran vdout1_10ck49 FIND v(dout1_10) AT=1000.1n

* CHECK dout1_11 Vdout1_11ck49 = 0 time = 1000
.meas tran vdout1_11ck49 FIND v(dout1_11) AT=1000.1n

* CHECK dout1_12 Vdout1_12ck49 = 1.8 time = 1000
.meas tran vdout1_12ck49 FIND v(dout1_12) AT=1000.1n

* CHECK dout1_13 Vdout1_13ck49 = 0 time = 1000
.meas tran vdout1_13ck49 FIND v(dout1_13) AT=1000.1n

* CHECK dout1_14 Vdout1_14ck49 = 1.8 time = 1000
.meas tran vdout1_14ck49 FIND v(dout1_14) AT=1000.1n

* CHECK dout1_15 Vdout1_15ck49 = 1.8 time = 1000
.meas tran vdout1_15ck49 FIND v(dout1_15) AT=1000.1n

* CHECK dout1_16 Vdout1_16ck49 = 1.8 time = 1000
.meas tran vdout1_16ck49 FIND v(dout1_16) AT=1000.1n

* CHECK dout1_17 Vdout1_17ck49 = 0 time = 1000
.meas tran vdout1_17ck49 FIND v(dout1_17) AT=1000.1n

* CHECK dout1_18 Vdout1_18ck49 = 1.8 time = 1000
.meas tran vdout1_18ck49 FIND v(dout1_18) AT=1000.1n

* CHECK dout1_19 Vdout1_19ck49 = 0 time = 1000
.meas tran vdout1_19ck49 FIND v(dout1_19) AT=1000.1n

* CHECK dout1_20 Vdout1_20ck49 = 1.8 time = 1000
.meas tran vdout1_20ck49 FIND v(dout1_20) AT=1000.1n

* CHECK dout1_21 Vdout1_21ck49 = 0 time = 1000
.meas tran vdout1_21ck49 FIND v(dout1_21) AT=1000.1n

* CHECK dout1_22 Vdout1_22ck49 = 0 time = 1000
.meas tran vdout1_22ck49 FIND v(dout1_22) AT=1000.1n

* CHECK dout1_23 Vdout1_23ck49 = 1.8 time = 1000
.meas tran vdout1_23ck49 FIND v(dout1_23) AT=1000.1n

* CHECK dout1_24 Vdout1_24ck49 = 0 time = 1000
.meas tran vdout1_24ck49 FIND v(dout1_24) AT=1000.1n

* CHECK dout1_25 Vdout1_25ck49 = 1.8 time = 1000
.meas tran vdout1_25ck49 FIND v(dout1_25) AT=1000.1n

* CHECK dout1_26 Vdout1_26ck49 = 0 time = 1000
.meas tran vdout1_26ck49 FIND v(dout1_26) AT=1000.1n

* CHECK dout1_27 Vdout1_27ck49 = 1.8 time = 1000
.meas tran vdout1_27ck49 FIND v(dout1_27) AT=1000.1n

* CHECK dout1_28 Vdout1_28ck49 = 0 time = 1000
.meas tran vdout1_28ck49 FIND v(dout1_28) AT=1000.1n

* CHECK dout1_29 Vdout1_29ck49 = 1.8 time = 1000
.meas tran vdout1_29ck49 FIND v(dout1_29) AT=1000.1n

* CHECK dout1_30 Vdout1_30ck49 = 0 time = 1000
.meas tran vdout1_30ck49 FIND v(dout1_30) AT=1000.1n

* CHECK dout1_31 Vdout1_31ck49 = 0 time = 1000
.meas tran vdout1_31ck49 FIND v(dout1_31) AT=1000.1n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 1020
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=1020.1n

* CHECK dout1_1 Vdout1_1ck50 = 1.8 time = 1020
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=1020.1n

* CHECK dout1_2 Vdout1_2ck50 = 0 time = 1020
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=1020.1n

* CHECK dout1_3 Vdout1_3ck50 = 1.8 time = 1020
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=1020.1n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 1020
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=1020.1n

* CHECK dout1_5 Vdout1_5ck50 = 1.8 time = 1020
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=1020.1n

* CHECK dout1_6 Vdout1_6ck50 = 1.8 time = 1020
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=1020.1n

* CHECK dout1_7 Vdout1_7ck50 = 0 time = 1020
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=1020.1n

* CHECK dout1_8 Vdout1_8ck50 = 0 time = 1020
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=1020.1n

* CHECK dout1_9 Vdout1_9ck50 = 1.8 time = 1020
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=1020.1n

* CHECK dout1_10 Vdout1_10ck50 = 0 time = 1020
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=1020.1n

* CHECK dout1_11 Vdout1_11ck50 = 1.8 time = 1020
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=1020.1n

* CHECK dout1_12 Vdout1_12ck50 = 0 time = 1020
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=1020.1n

* CHECK dout1_13 Vdout1_13ck50 = 1.8 time = 1020
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=1020.1n

* CHECK dout1_14 Vdout1_14ck50 = 1.8 time = 1020
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=1020.1n

* CHECK dout1_15 Vdout1_15ck50 = 1.8 time = 1020
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=1020.1n

* CHECK dout1_16 Vdout1_16ck50 = 1.8 time = 1020
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=1020.1n

* CHECK dout1_17 Vdout1_17ck50 = 1.8 time = 1020
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=1020.1n

* CHECK dout1_18 Vdout1_18ck50 = 0 time = 1020
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=1020.1n

* CHECK dout1_19 Vdout1_19ck50 = 0 time = 1020
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=1020.1n

* CHECK dout1_20 Vdout1_20ck50 = 0 time = 1020
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=1020.1n

* CHECK dout1_21 Vdout1_21ck50 = 1.8 time = 1020
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=1020.1n

* CHECK dout1_22 Vdout1_22ck50 = 0 time = 1020
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=1020.1n

* CHECK dout1_23 Vdout1_23ck50 = 0 time = 1020
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=1020.1n

* CHECK dout1_24 Vdout1_24ck50 = 1.8 time = 1020
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=1020.1n

* CHECK dout1_25 Vdout1_25ck50 = 1.8 time = 1020
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=1020.1n

* CHECK dout1_26 Vdout1_26ck50 = 1.8 time = 1020
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=1020.1n

* CHECK dout1_27 Vdout1_27ck50 = 1.8 time = 1020
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=1020.1n

* CHECK dout1_28 Vdout1_28ck50 = 1.8 time = 1020
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=1020.1n

* CHECK dout1_29 Vdout1_29ck50 = 0 time = 1020
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=1020.1n

* CHECK dout1_30 Vdout1_30ck50 = 1.8 time = 1020
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=1020.1n

* CHECK dout1_31 Vdout1_31ck50 = 1.8 time = 1020
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=1020.1n

* CHECK dout1_0 Vdout1_0ck51 = 1.8 time = 1040
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=1040.1n

* CHECK dout1_1 Vdout1_1ck51 = 1.8 time = 1040
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=1040.1n

* CHECK dout1_2 Vdout1_2ck51 = 1.8 time = 1040
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=1040.1n

* CHECK dout1_3 Vdout1_3ck51 = 0 time = 1040
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=1040.1n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 1040
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=1040.1n

* CHECK dout1_5 Vdout1_5ck51 = 0 time = 1040
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=1040.1n

* CHECK dout1_6 Vdout1_6ck51 = 0 time = 1040
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=1040.1n

* CHECK dout1_7 Vdout1_7ck51 = 1.8 time = 1040
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=1040.1n

* CHECK dout1_8 Vdout1_8ck51 = 0 time = 1040
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=1040.1n

* CHECK dout1_9 Vdout1_9ck51 = 1.8 time = 1040
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=1040.1n

* CHECK dout1_10 Vdout1_10ck51 = 0 time = 1040
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=1040.1n

* CHECK dout1_11 Vdout1_11ck51 = 0 time = 1040
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=1040.1n

* CHECK dout1_12 Vdout1_12ck51 = 1.8 time = 1040
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=1040.1n

* CHECK dout1_13 Vdout1_13ck51 = 0 time = 1040
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=1040.1n

* CHECK dout1_14 Vdout1_14ck51 = 1.8 time = 1040
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=1040.1n

* CHECK dout1_15 Vdout1_15ck51 = 1.8 time = 1040
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=1040.1n

* CHECK dout1_16 Vdout1_16ck51 = 1.8 time = 1040
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=1040.1n

* CHECK dout1_17 Vdout1_17ck51 = 0 time = 1040
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=1040.1n

* CHECK dout1_18 Vdout1_18ck51 = 1.8 time = 1040
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=1040.1n

* CHECK dout1_19 Vdout1_19ck51 = 0 time = 1040
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=1040.1n

* CHECK dout1_20 Vdout1_20ck51 = 1.8 time = 1040
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=1040.1n

* CHECK dout1_21 Vdout1_21ck51 = 0 time = 1040
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=1040.1n

* CHECK dout1_22 Vdout1_22ck51 = 0 time = 1040
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=1040.1n

* CHECK dout1_23 Vdout1_23ck51 = 1.8 time = 1040
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=1040.1n

* CHECK dout1_24 Vdout1_24ck51 = 0 time = 1040
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=1040.1n

* CHECK dout1_25 Vdout1_25ck51 = 1.8 time = 1040
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=1040.1n

* CHECK dout1_26 Vdout1_26ck51 = 0 time = 1040
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=1040.1n

* CHECK dout1_27 Vdout1_27ck51 = 1.8 time = 1040
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=1040.1n

* CHECK dout1_28 Vdout1_28ck51 = 0 time = 1040
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=1040.1n

* CHECK dout1_29 Vdout1_29ck51 = 1.8 time = 1040
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=1040.1n

* CHECK dout1_30 Vdout1_30ck51 = 0 time = 1040
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=1040.1n

* CHECK dout1_31 Vdout1_31ck51 = 0 time = 1040
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=1040.1n

* CHECK dout1_0 Vdout1_0ck52 = 0 time = 1060
.meas tran vdout1_0ck52 FIND v(dout1_0) AT=1060.1n

* CHECK dout1_1 Vdout1_1ck52 = 0 time = 1060
.meas tran vdout1_1ck52 FIND v(dout1_1) AT=1060.1n

* CHECK dout1_2 Vdout1_2ck52 = 1.8 time = 1060
.meas tran vdout1_2ck52 FIND v(dout1_2) AT=1060.1n

* CHECK dout1_3 Vdout1_3ck52 = 0 time = 1060
.meas tran vdout1_3ck52 FIND v(dout1_3) AT=1060.1n

* CHECK dout1_4 Vdout1_4ck52 = 0 time = 1060
.meas tran vdout1_4ck52 FIND v(dout1_4) AT=1060.1n

* CHECK dout1_5 Vdout1_5ck52 = 0 time = 1060
.meas tran vdout1_5ck52 FIND v(dout1_5) AT=1060.1n

* CHECK dout1_6 Vdout1_6ck52 = 1.8 time = 1060
.meas tran vdout1_6ck52 FIND v(dout1_6) AT=1060.1n

* CHECK dout1_7 Vdout1_7ck52 = 0 time = 1060
.meas tran vdout1_7ck52 FIND v(dout1_7) AT=1060.1n

* CHECK dout1_8 Vdout1_8ck52 = 1.8 time = 1060
.meas tran vdout1_8ck52 FIND v(dout1_8) AT=1060.1n

* CHECK dout1_9 Vdout1_9ck52 = 0 time = 1060
.meas tran vdout1_9ck52 FIND v(dout1_9) AT=1060.1n

* CHECK dout1_10 Vdout1_10ck52 = 0 time = 1060
.meas tran vdout1_10ck52 FIND v(dout1_10) AT=1060.1n

* CHECK dout1_11 Vdout1_11ck52 = 1.8 time = 1060
.meas tran vdout1_11ck52 FIND v(dout1_11) AT=1060.1n

* CHECK dout1_12 Vdout1_12ck52 = 0 time = 1060
.meas tran vdout1_12ck52 FIND v(dout1_12) AT=1060.1n

* CHECK dout1_13 Vdout1_13ck52 = 1.8 time = 1060
.meas tran vdout1_13ck52 FIND v(dout1_13) AT=1060.1n

* CHECK dout1_14 Vdout1_14ck52 = 1.8 time = 1060
.meas tran vdout1_14ck52 FIND v(dout1_14) AT=1060.1n

* CHECK dout1_15 Vdout1_15ck52 = 1.8 time = 1060
.meas tran vdout1_15ck52 FIND v(dout1_15) AT=1060.1n

* CHECK dout1_16 Vdout1_16ck52 = 0 time = 1060
.meas tran vdout1_16ck52 FIND v(dout1_16) AT=1060.1n

* CHECK dout1_17 Vdout1_17ck52 = 0 time = 1060
.meas tran vdout1_17ck52 FIND v(dout1_17) AT=1060.1n

* CHECK dout1_18 Vdout1_18ck52 = 1.8 time = 1060
.meas tran vdout1_18ck52 FIND v(dout1_18) AT=1060.1n

* CHECK dout1_19 Vdout1_19ck52 = 1.8 time = 1060
.meas tran vdout1_19ck52 FIND v(dout1_19) AT=1060.1n

* CHECK dout1_20 Vdout1_20ck52 = 1.8 time = 1060
.meas tran vdout1_20ck52 FIND v(dout1_20) AT=1060.1n

* CHECK dout1_21 Vdout1_21ck52 = 1.8 time = 1060
.meas tran vdout1_21ck52 FIND v(dout1_21) AT=1060.1n

* CHECK dout1_22 Vdout1_22ck52 = 0 time = 1060
.meas tran vdout1_22ck52 FIND v(dout1_22) AT=1060.1n

* CHECK dout1_23 Vdout1_23ck52 = 0 time = 1060
.meas tran vdout1_23ck52 FIND v(dout1_23) AT=1060.1n

* CHECK dout1_24 Vdout1_24ck52 = 0 time = 1060
.meas tran vdout1_24ck52 FIND v(dout1_24) AT=1060.1n

* CHECK dout1_25 Vdout1_25ck52 = 0 time = 1060
.meas tran vdout1_25ck52 FIND v(dout1_25) AT=1060.1n

* CHECK dout1_26 Vdout1_26ck52 = 1.8 time = 1060
.meas tran vdout1_26ck52 FIND v(dout1_26) AT=1060.1n

* CHECK dout1_27 Vdout1_27ck52 = 1.8 time = 1060
.meas tran vdout1_27ck52 FIND v(dout1_27) AT=1060.1n

* CHECK dout1_28 Vdout1_28ck52 = 0 time = 1060
.meas tran vdout1_28ck52 FIND v(dout1_28) AT=1060.1n

* CHECK dout1_29 Vdout1_29ck52 = 0 time = 1060
.meas tran vdout1_29ck52 FIND v(dout1_29) AT=1060.1n

* CHECK dout1_30 Vdout1_30ck52 = 1.8 time = 1060
.meas tran vdout1_30ck52 FIND v(dout1_30) AT=1060.1n

* CHECK dout1_31 Vdout1_31ck52 = 1.8 time = 1060
.meas tran vdout1_31ck52 FIND v(dout1_31) AT=1060.1n

* CHECK dout2_0 Vdout2_0ck52 = 0 time = 1060
.meas tran vdout2_0ck52 FIND v(dout2_0) AT=1060.1n

* CHECK dout2_1 Vdout2_1ck52 = 0 time = 1060
.meas tran vdout2_1ck52 FIND v(dout2_1) AT=1060.1n

* CHECK dout2_2 Vdout2_2ck52 = 1.8 time = 1060
.meas tran vdout2_2ck52 FIND v(dout2_2) AT=1060.1n

* CHECK dout2_3 Vdout2_3ck52 = 0 time = 1060
.meas tran vdout2_3ck52 FIND v(dout2_3) AT=1060.1n

* CHECK dout2_4 Vdout2_4ck52 = 0 time = 1060
.meas tran vdout2_4ck52 FIND v(dout2_4) AT=1060.1n

* CHECK dout2_5 Vdout2_5ck52 = 0 time = 1060
.meas tran vdout2_5ck52 FIND v(dout2_5) AT=1060.1n

* CHECK dout2_6 Vdout2_6ck52 = 1.8 time = 1060
.meas tran vdout2_6ck52 FIND v(dout2_6) AT=1060.1n

* CHECK dout2_7 Vdout2_7ck52 = 0 time = 1060
.meas tran vdout2_7ck52 FIND v(dout2_7) AT=1060.1n

* CHECK dout2_8 Vdout2_8ck52 = 1.8 time = 1060
.meas tran vdout2_8ck52 FIND v(dout2_8) AT=1060.1n

* CHECK dout2_9 Vdout2_9ck52 = 0 time = 1060
.meas tran vdout2_9ck52 FIND v(dout2_9) AT=1060.1n

* CHECK dout2_10 Vdout2_10ck52 = 0 time = 1060
.meas tran vdout2_10ck52 FIND v(dout2_10) AT=1060.1n

* CHECK dout2_11 Vdout2_11ck52 = 1.8 time = 1060
.meas tran vdout2_11ck52 FIND v(dout2_11) AT=1060.1n

* CHECK dout2_12 Vdout2_12ck52 = 0 time = 1060
.meas tran vdout2_12ck52 FIND v(dout2_12) AT=1060.1n

* CHECK dout2_13 Vdout2_13ck52 = 1.8 time = 1060
.meas tran vdout2_13ck52 FIND v(dout2_13) AT=1060.1n

* CHECK dout2_14 Vdout2_14ck52 = 1.8 time = 1060
.meas tran vdout2_14ck52 FIND v(dout2_14) AT=1060.1n

* CHECK dout2_15 Vdout2_15ck52 = 1.8 time = 1060
.meas tran vdout2_15ck52 FIND v(dout2_15) AT=1060.1n

* CHECK dout2_16 Vdout2_16ck52 = 0 time = 1060
.meas tran vdout2_16ck52 FIND v(dout2_16) AT=1060.1n

* CHECK dout2_17 Vdout2_17ck52 = 0 time = 1060
.meas tran vdout2_17ck52 FIND v(dout2_17) AT=1060.1n

* CHECK dout2_18 Vdout2_18ck52 = 1.8 time = 1060
.meas tran vdout2_18ck52 FIND v(dout2_18) AT=1060.1n

* CHECK dout2_19 Vdout2_19ck52 = 1.8 time = 1060
.meas tran vdout2_19ck52 FIND v(dout2_19) AT=1060.1n

* CHECK dout2_20 Vdout2_20ck52 = 1.8 time = 1060
.meas tran vdout2_20ck52 FIND v(dout2_20) AT=1060.1n

* CHECK dout2_21 Vdout2_21ck52 = 1.8 time = 1060
.meas tran vdout2_21ck52 FIND v(dout2_21) AT=1060.1n

* CHECK dout2_22 Vdout2_22ck52 = 0 time = 1060
.meas tran vdout2_22ck52 FIND v(dout2_22) AT=1060.1n

* CHECK dout2_23 Vdout2_23ck52 = 0 time = 1060
.meas tran vdout2_23ck52 FIND v(dout2_23) AT=1060.1n

* CHECK dout2_24 Vdout2_24ck52 = 0 time = 1060
.meas tran vdout2_24ck52 FIND v(dout2_24) AT=1060.1n

* CHECK dout2_25 Vdout2_25ck52 = 0 time = 1060
.meas tran vdout2_25ck52 FIND v(dout2_25) AT=1060.1n

* CHECK dout2_26 Vdout2_26ck52 = 1.8 time = 1060
.meas tran vdout2_26ck52 FIND v(dout2_26) AT=1060.1n

* CHECK dout2_27 Vdout2_27ck52 = 1.8 time = 1060
.meas tran vdout2_27ck52 FIND v(dout2_27) AT=1060.1n

* CHECK dout2_28 Vdout2_28ck52 = 0 time = 1060
.meas tran vdout2_28ck52 FIND v(dout2_28) AT=1060.1n

* CHECK dout2_29 Vdout2_29ck52 = 0 time = 1060
.meas tran vdout2_29ck52 FIND v(dout2_29) AT=1060.1n

* CHECK dout2_30 Vdout2_30ck52 = 1.8 time = 1060
.meas tran vdout2_30ck52 FIND v(dout2_30) AT=1060.1n

* CHECK dout2_31 Vdout2_31ck52 = 1.8 time = 1060
.meas tran vdout2_31ck52 FIND v(dout2_31) AT=1060.1n

* CHECK dout1_0 Vdout1_0ck54 = 0 time = 1100
.meas tran vdout1_0ck54 FIND v(dout1_0) AT=1100.1n

* CHECK dout1_1 Vdout1_1ck54 = 0 time = 1100
.meas tran vdout1_1ck54 FIND v(dout1_1) AT=1100.1n

* CHECK dout1_2 Vdout1_2ck54 = 0 time = 1100
.meas tran vdout1_2ck54 FIND v(dout1_2) AT=1100.1n

* CHECK dout1_3 Vdout1_3ck54 = 0 time = 1100
.meas tran vdout1_3ck54 FIND v(dout1_3) AT=1100.1n

* CHECK dout1_4 Vdout1_4ck54 = 0 time = 1100
.meas tran vdout1_4ck54 FIND v(dout1_4) AT=1100.1n

* CHECK dout1_5 Vdout1_5ck54 = 0 time = 1100
.meas tran vdout1_5ck54 FIND v(dout1_5) AT=1100.1n

* CHECK dout1_6 Vdout1_6ck54 = 0 time = 1100
.meas tran vdout1_6ck54 FIND v(dout1_6) AT=1100.1n

* CHECK dout1_7 Vdout1_7ck54 = 0 time = 1100
.meas tran vdout1_7ck54 FIND v(dout1_7) AT=1100.1n

* CHECK dout1_8 Vdout1_8ck54 = 0 time = 1100
.meas tran vdout1_8ck54 FIND v(dout1_8) AT=1100.1n

* CHECK dout1_9 Vdout1_9ck54 = 1.8 time = 1100
.meas tran vdout1_9ck54 FIND v(dout1_9) AT=1100.1n

* CHECK dout1_10 Vdout1_10ck54 = 0 time = 1100
.meas tran vdout1_10ck54 FIND v(dout1_10) AT=1100.1n

* CHECK dout1_11 Vdout1_11ck54 = 1.8 time = 1100
.meas tran vdout1_11ck54 FIND v(dout1_11) AT=1100.1n

* CHECK dout1_12 Vdout1_12ck54 = 1.8 time = 1100
.meas tran vdout1_12ck54 FIND v(dout1_12) AT=1100.1n

* CHECK dout1_13 Vdout1_13ck54 = 0 time = 1100
.meas tran vdout1_13ck54 FIND v(dout1_13) AT=1100.1n

* CHECK dout1_14 Vdout1_14ck54 = 0 time = 1100
.meas tran vdout1_14ck54 FIND v(dout1_14) AT=1100.1n

* CHECK dout1_15 Vdout1_15ck54 = 0 time = 1100
.meas tran vdout1_15ck54 FIND v(dout1_15) AT=1100.1n

* CHECK dout1_16 Vdout1_16ck54 = 1.8 time = 1100
.meas tran vdout1_16ck54 FIND v(dout1_16) AT=1100.1n

* CHECK dout1_17 Vdout1_17ck54 = 0 time = 1100
.meas tran vdout1_17ck54 FIND v(dout1_17) AT=1100.1n

* CHECK dout1_18 Vdout1_18ck54 = 0 time = 1100
.meas tran vdout1_18ck54 FIND v(dout1_18) AT=1100.1n

* CHECK dout1_19 Vdout1_19ck54 = 1.8 time = 1100
.meas tran vdout1_19ck54 FIND v(dout1_19) AT=1100.1n

* CHECK dout1_20 Vdout1_20ck54 = 0 time = 1100
.meas tran vdout1_20ck54 FIND v(dout1_20) AT=1100.1n

* CHECK dout1_21 Vdout1_21ck54 = 1.8 time = 1100
.meas tran vdout1_21ck54 FIND v(dout1_21) AT=1100.1n

* CHECK dout1_22 Vdout1_22ck54 = 0 time = 1100
.meas tran vdout1_22ck54 FIND v(dout1_22) AT=1100.1n

* CHECK dout1_23 Vdout1_23ck54 = 0 time = 1100
.meas tran vdout1_23ck54 FIND v(dout1_23) AT=1100.1n

* CHECK dout1_24 Vdout1_24ck54 = 1.8 time = 1100
.meas tran vdout1_24ck54 FIND v(dout1_24) AT=1100.1n

* CHECK dout1_25 Vdout1_25ck54 = 1.8 time = 1100
.meas tran vdout1_25ck54 FIND v(dout1_25) AT=1100.1n

* CHECK dout1_26 Vdout1_26ck54 = 1.8 time = 1100
.meas tran vdout1_26ck54 FIND v(dout1_26) AT=1100.1n

* CHECK dout1_27 Vdout1_27ck54 = 1.8 time = 1100
.meas tran vdout1_27ck54 FIND v(dout1_27) AT=1100.1n

* CHECK dout1_28 Vdout1_28ck54 = 0 time = 1100
.meas tran vdout1_28ck54 FIND v(dout1_28) AT=1100.1n

* CHECK dout1_29 Vdout1_29ck54 = 0 time = 1100
.meas tran vdout1_29ck54 FIND v(dout1_29) AT=1100.1n

* CHECK dout1_30 Vdout1_30ck54 = 1.8 time = 1100
.meas tran vdout1_30ck54 FIND v(dout1_30) AT=1100.1n

* CHECK dout1_31 Vdout1_31ck54 = 0 time = 1100
.meas tran vdout1_31ck54 FIND v(dout1_31) AT=1100.1n

* CHECK dout2_0 Vdout2_0ck54 = 0 time = 1100
.meas tran vdout2_0ck54 FIND v(dout2_0) AT=1100.1n

* CHECK dout2_1 Vdout2_1ck54 = 1.8 time = 1100
.meas tran vdout2_1ck54 FIND v(dout2_1) AT=1100.1n

* CHECK dout2_2 Vdout2_2ck54 = 1.8 time = 1100
.meas tran vdout2_2ck54 FIND v(dout2_2) AT=1100.1n

* CHECK dout2_3 Vdout2_3ck54 = 0 time = 1100
.meas tran vdout2_3ck54 FIND v(dout2_3) AT=1100.1n

* CHECK dout2_4 Vdout2_4ck54 = 1.8 time = 1100
.meas tran vdout2_4ck54 FIND v(dout2_4) AT=1100.1n

* CHECK dout2_5 Vdout2_5ck54 = 0 time = 1100
.meas tran vdout2_5ck54 FIND v(dout2_5) AT=1100.1n

* CHECK dout2_6 Vdout2_6ck54 = 1.8 time = 1100
.meas tran vdout2_6ck54 FIND v(dout2_6) AT=1100.1n

* CHECK dout2_7 Vdout2_7ck54 = 0 time = 1100
.meas tran vdout2_7ck54 FIND v(dout2_7) AT=1100.1n

* CHECK dout2_8 Vdout2_8ck54 = 1.8 time = 1100
.meas tran vdout2_8ck54 FIND v(dout2_8) AT=1100.1n

* CHECK dout2_9 Vdout2_9ck54 = 0 time = 1100
.meas tran vdout2_9ck54 FIND v(dout2_9) AT=1100.1n

* CHECK dout2_10 Vdout2_10ck54 = 1.8 time = 1100
.meas tran vdout2_10ck54 FIND v(dout2_10) AT=1100.1n

* CHECK dout2_11 Vdout2_11ck54 = 0 time = 1100
.meas tran vdout2_11ck54 FIND v(dout2_11) AT=1100.1n

* CHECK dout2_12 Vdout2_12ck54 = 1.8 time = 1100
.meas tran vdout2_12ck54 FIND v(dout2_12) AT=1100.1n

* CHECK dout2_13 Vdout2_13ck54 = 1.8 time = 1100
.meas tran vdout2_13ck54 FIND v(dout2_13) AT=1100.1n

* CHECK dout2_14 Vdout2_14ck54 = 0 time = 1100
.meas tran vdout2_14ck54 FIND v(dout2_14) AT=1100.1n

* CHECK dout2_15 Vdout2_15ck54 = 1.8 time = 1100
.meas tran vdout2_15ck54 FIND v(dout2_15) AT=1100.1n

* CHECK dout2_16 Vdout2_16ck54 = 1.8 time = 1100
.meas tran vdout2_16ck54 FIND v(dout2_16) AT=1100.1n

* CHECK dout2_17 Vdout2_17ck54 = 0 time = 1100
.meas tran vdout2_17ck54 FIND v(dout2_17) AT=1100.1n

* CHECK dout2_18 Vdout2_18ck54 = 0 time = 1100
.meas tran vdout2_18ck54 FIND v(dout2_18) AT=1100.1n

* CHECK dout2_19 Vdout2_19ck54 = 1.8 time = 1100
.meas tran vdout2_19ck54 FIND v(dout2_19) AT=1100.1n

* CHECK dout2_20 Vdout2_20ck54 = 0 time = 1100
.meas tran vdout2_20ck54 FIND v(dout2_20) AT=1100.1n

* CHECK dout2_21 Vdout2_21ck54 = 0 time = 1100
.meas tran vdout2_21ck54 FIND v(dout2_21) AT=1100.1n

* CHECK dout2_22 Vdout2_22ck54 = 0 time = 1100
.meas tran vdout2_22ck54 FIND v(dout2_22) AT=1100.1n

* CHECK dout2_23 Vdout2_23ck54 = 1.8 time = 1100
.meas tran vdout2_23ck54 FIND v(dout2_23) AT=1100.1n

* CHECK dout2_24 Vdout2_24ck54 = 1.8 time = 1100
.meas tran vdout2_24ck54 FIND v(dout2_24) AT=1100.1n

* CHECK dout2_25 Vdout2_25ck54 = 1.8 time = 1100
.meas tran vdout2_25ck54 FIND v(dout2_25) AT=1100.1n

* CHECK dout2_26 Vdout2_26ck54 = 0 time = 1100
.meas tran vdout2_26ck54 FIND v(dout2_26) AT=1100.1n

* CHECK dout2_27 Vdout2_27ck54 = 1.8 time = 1100
.meas tran vdout2_27ck54 FIND v(dout2_27) AT=1100.1n

* CHECK dout2_28 Vdout2_28ck54 = 0 time = 1100
.meas tran vdout2_28ck54 FIND v(dout2_28) AT=1100.1n

* CHECK dout2_29 Vdout2_29ck54 = 0 time = 1100
.meas tran vdout2_29ck54 FIND v(dout2_29) AT=1100.1n

* CHECK dout2_30 Vdout2_30ck54 = 1.8 time = 1100
.meas tran vdout2_30ck54 FIND v(dout2_30) AT=1100.1n

* CHECK dout2_31 Vdout2_31ck54 = 0 time = 1100
.meas tran vdout2_31ck54 FIND v(dout2_31) AT=1100.1n

* CHECK dout1_0 Vdout1_0ck55 = 0 time = 1120
.meas tran vdout1_0ck55 FIND v(dout1_0) AT=1120.1n

* CHECK dout1_1 Vdout1_1ck55 = 1.8 time = 1120
.meas tran vdout1_1ck55 FIND v(dout1_1) AT=1120.1n

* CHECK dout1_2 Vdout1_2ck55 = 1.8 time = 1120
.meas tran vdout1_2ck55 FIND v(dout1_2) AT=1120.1n

* CHECK dout1_3 Vdout1_3ck55 = 0 time = 1120
.meas tran vdout1_3ck55 FIND v(dout1_3) AT=1120.1n

* CHECK dout1_4 Vdout1_4ck55 = 1.8 time = 1120
.meas tran vdout1_4ck55 FIND v(dout1_4) AT=1120.1n

* CHECK dout1_5 Vdout1_5ck55 = 0 time = 1120
.meas tran vdout1_5ck55 FIND v(dout1_5) AT=1120.1n

* CHECK dout1_6 Vdout1_6ck55 = 0 time = 1120
.meas tran vdout1_6ck55 FIND v(dout1_6) AT=1120.1n

* CHECK dout1_7 Vdout1_7ck55 = 1.8 time = 1120
.meas tran vdout1_7ck55 FIND v(dout1_7) AT=1120.1n

* CHECK dout1_8 Vdout1_8ck55 = 0 time = 1120
.meas tran vdout1_8ck55 FIND v(dout1_8) AT=1120.1n

* CHECK dout1_9 Vdout1_9ck55 = 0 time = 1120
.meas tran vdout1_9ck55 FIND v(dout1_9) AT=1120.1n

* CHECK dout1_10 Vdout1_10ck55 = 1.8 time = 1120
.meas tran vdout1_10ck55 FIND v(dout1_10) AT=1120.1n

* CHECK dout1_11 Vdout1_11ck55 = 1.8 time = 1120
.meas tran vdout1_11ck55 FIND v(dout1_11) AT=1120.1n

* CHECK dout1_12 Vdout1_12ck55 = 1.8 time = 1120
.meas tran vdout1_12ck55 FIND v(dout1_12) AT=1120.1n

* CHECK dout1_13 Vdout1_13ck55 = 0 time = 1120
.meas tran vdout1_13ck55 FIND v(dout1_13) AT=1120.1n

* CHECK dout1_14 Vdout1_14ck55 = 0 time = 1120
.meas tran vdout1_14ck55 FIND v(dout1_14) AT=1120.1n

* CHECK dout1_15 Vdout1_15ck55 = 0 time = 1120
.meas tran vdout1_15ck55 FIND v(dout1_15) AT=1120.1n

* CHECK dout1_16 Vdout1_16ck55 = 0 time = 1120
.meas tran vdout1_16ck55 FIND v(dout1_16) AT=1120.1n

* CHECK dout1_17 Vdout1_17ck55 = 0 time = 1120
.meas tran vdout1_17ck55 FIND v(dout1_17) AT=1120.1n

* CHECK dout1_18 Vdout1_18ck55 = 0 time = 1120
.meas tran vdout1_18ck55 FIND v(dout1_18) AT=1120.1n

* CHECK dout1_19 Vdout1_19ck55 = 0 time = 1120
.meas tran vdout1_19ck55 FIND v(dout1_19) AT=1120.1n

* CHECK dout1_20 Vdout1_20ck55 = 1.8 time = 1120
.meas tran vdout1_20ck55 FIND v(dout1_20) AT=1120.1n

* CHECK dout1_21 Vdout1_21ck55 = 1.8 time = 1120
.meas tran vdout1_21ck55 FIND v(dout1_21) AT=1120.1n

* CHECK dout1_22 Vdout1_22ck55 = 1.8 time = 1120
.meas tran vdout1_22ck55 FIND v(dout1_22) AT=1120.1n

* CHECK dout1_23 Vdout1_23ck55 = 1.8 time = 1120
.meas tran vdout1_23ck55 FIND v(dout1_23) AT=1120.1n

* CHECK dout1_24 Vdout1_24ck55 = 0 time = 1120
.meas tran vdout1_24ck55 FIND v(dout1_24) AT=1120.1n

* CHECK dout1_25 Vdout1_25ck55 = 1.8 time = 1120
.meas tran vdout1_25ck55 FIND v(dout1_25) AT=1120.1n

* CHECK dout1_26 Vdout1_26ck55 = 1.8 time = 1120
.meas tran vdout1_26ck55 FIND v(dout1_26) AT=1120.1n

* CHECK dout1_27 Vdout1_27ck55 = 1.8 time = 1120
.meas tran vdout1_27ck55 FIND v(dout1_27) AT=1120.1n

* CHECK dout1_28 Vdout1_28ck55 = 1.8 time = 1120
.meas tran vdout1_28ck55 FIND v(dout1_28) AT=1120.1n

* CHECK dout1_29 Vdout1_29ck55 = 0 time = 1120
.meas tran vdout1_29ck55 FIND v(dout1_29) AT=1120.1n

* CHECK dout1_30 Vdout1_30ck55 = 0 time = 1120
.meas tran vdout1_30ck55 FIND v(dout1_30) AT=1120.1n

* CHECK dout1_31 Vdout1_31ck55 = 0 time = 1120
.meas tran vdout1_31ck55 FIND v(dout1_31) AT=1120.1n

* CHECK dout2_0 Vdout2_0ck55 = 0 time = 1120
.meas tran vdout2_0ck55 FIND v(dout2_0) AT=1120.1n

* CHECK dout2_1 Vdout2_1ck55 = 1.8 time = 1120
.meas tran vdout2_1ck55 FIND v(dout2_1) AT=1120.1n

* CHECK dout2_2 Vdout2_2ck55 = 1.8 time = 1120
.meas tran vdout2_2ck55 FIND v(dout2_2) AT=1120.1n

* CHECK dout2_3 Vdout2_3ck55 = 0 time = 1120
.meas tran vdout2_3ck55 FIND v(dout2_3) AT=1120.1n

* CHECK dout2_4 Vdout2_4ck55 = 1.8 time = 1120
.meas tran vdout2_4ck55 FIND v(dout2_4) AT=1120.1n

* CHECK dout2_5 Vdout2_5ck55 = 0 time = 1120
.meas tran vdout2_5ck55 FIND v(dout2_5) AT=1120.1n

* CHECK dout2_6 Vdout2_6ck55 = 1.8 time = 1120
.meas tran vdout2_6ck55 FIND v(dout2_6) AT=1120.1n

* CHECK dout2_7 Vdout2_7ck55 = 0 time = 1120
.meas tran vdout2_7ck55 FIND v(dout2_7) AT=1120.1n

* CHECK dout2_8 Vdout2_8ck55 = 1.8 time = 1120
.meas tran vdout2_8ck55 FIND v(dout2_8) AT=1120.1n

* CHECK dout2_9 Vdout2_9ck55 = 0 time = 1120
.meas tran vdout2_9ck55 FIND v(dout2_9) AT=1120.1n

* CHECK dout2_10 Vdout2_10ck55 = 1.8 time = 1120
.meas tran vdout2_10ck55 FIND v(dout2_10) AT=1120.1n

* CHECK dout2_11 Vdout2_11ck55 = 0 time = 1120
.meas tran vdout2_11ck55 FIND v(dout2_11) AT=1120.1n

* CHECK dout2_12 Vdout2_12ck55 = 1.8 time = 1120
.meas tran vdout2_12ck55 FIND v(dout2_12) AT=1120.1n

* CHECK dout2_13 Vdout2_13ck55 = 1.8 time = 1120
.meas tran vdout2_13ck55 FIND v(dout2_13) AT=1120.1n

* CHECK dout2_14 Vdout2_14ck55 = 0 time = 1120
.meas tran vdout2_14ck55 FIND v(dout2_14) AT=1120.1n

* CHECK dout2_15 Vdout2_15ck55 = 1.8 time = 1120
.meas tran vdout2_15ck55 FIND v(dout2_15) AT=1120.1n

* CHECK dout2_16 Vdout2_16ck55 = 1.8 time = 1120
.meas tran vdout2_16ck55 FIND v(dout2_16) AT=1120.1n

* CHECK dout2_17 Vdout2_17ck55 = 0 time = 1120
.meas tran vdout2_17ck55 FIND v(dout2_17) AT=1120.1n

* CHECK dout2_18 Vdout2_18ck55 = 0 time = 1120
.meas tran vdout2_18ck55 FIND v(dout2_18) AT=1120.1n

* CHECK dout2_19 Vdout2_19ck55 = 1.8 time = 1120
.meas tran vdout2_19ck55 FIND v(dout2_19) AT=1120.1n

* CHECK dout2_20 Vdout2_20ck55 = 0 time = 1120
.meas tran vdout2_20ck55 FIND v(dout2_20) AT=1120.1n

* CHECK dout2_21 Vdout2_21ck55 = 0 time = 1120
.meas tran vdout2_21ck55 FIND v(dout2_21) AT=1120.1n

* CHECK dout2_22 Vdout2_22ck55 = 0 time = 1120
.meas tran vdout2_22ck55 FIND v(dout2_22) AT=1120.1n

* CHECK dout2_23 Vdout2_23ck55 = 1.8 time = 1120
.meas tran vdout2_23ck55 FIND v(dout2_23) AT=1120.1n

* CHECK dout2_24 Vdout2_24ck55 = 1.8 time = 1120
.meas tran vdout2_24ck55 FIND v(dout2_24) AT=1120.1n

* CHECK dout2_25 Vdout2_25ck55 = 1.8 time = 1120
.meas tran vdout2_25ck55 FIND v(dout2_25) AT=1120.1n

* CHECK dout2_26 Vdout2_26ck55 = 0 time = 1120
.meas tran vdout2_26ck55 FIND v(dout2_26) AT=1120.1n

* CHECK dout2_27 Vdout2_27ck55 = 1.8 time = 1120
.meas tran vdout2_27ck55 FIND v(dout2_27) AT=1120.1n

* CHECK dout2_28 Vdout2_28ck55 = 0 time = 1120
.meas tran vdout2_28ck55 FIND v(dout2_28) AT=1120.1n

* CHECK dout2_29 Vdout2_29ck55 = 0 time = 1120
.meas tran vdout2_29ck55 FIND v(dout2_29) AT=1120.1n

* CHECK dout2_30 Vdout2_30ck55 = 1.8 time = 1120
.meas tran vdout2_30ck55 FIND v(dout2_30) AT=1120.1n

* CHECK dout2_31 Vdout2_31ck55 = 0 time = 1120
.meas tran vdout2_31ck55 FIND v(dout2_31) AT=1120.1n

* CHECK dout1_0 Vdout1_0ck56 = 0 time = 1140
.meas tran vdout1_0ck56 FIND v(dout1_0) AT=1140.1n

* CHECK dout1_1 Vdout1_1ck56 = 1.8 time = 1140
.meas tran vdout1_1ck56 FIND v(dout1_1) AT=1140.1n

* CHECK dout1_2 Vdout1_2ck56 = 1.8 time = 1140
.meas tran vdout1_2ck56 FIND v(dout1_2) AT=1140.1n

* CHECK dout1_3 Vdout1_3ck56 = 0 time = 1140
.meas tran vdout1_3ck56 FIND v(dout1_3) AT=1140.1n

* CHECK dout1_4 Vdout1_4ck56 = 1.8 time = 1140
.meas tran vdout1_4ck56 FIND v(dout1_4) AT=1140.1n

* CHECK dout1_5 Vdout1_5ck56 = 0 time = 1140
.meas tran vdout1_5ck56 FIND v(dout1_5) AT=1140.1n

* CHECK dout1_6 Vdout1_6ck56 = 1.8 time = 1140
.meas tran vdout1_6ck56 FIND v(dout1_6) AT=1140.1n

* CHECK dout1_7 Vdout1_7ck56 = 0 time = 1140
.meas tran vdout1_7ck56 FIND v(dout1_7) AT=1140.1n

* CHECK dout1_8 Vdout1_8ck56 = 1.8 time = 1140
.meas tran vdout1_8ck56 FIND v(dout1_8) AT=1140.1n

* CHECK dout1_9 Vdout1_9ck56 = 0 time = 1140
.meas tran vdout1_9ck56 FIND v(dout1_9) AT=1140.1n

* CHECK dout1_10 Vdout1_10ck56 = 1.8 time = 1140
.meas tran vdout1_10ck56 FIND v(dout1_10) AT=1140.1n

* CHECK dout1_11 Vdout1_11ck56 = 0 time = 1140
.meas tran vdout1_11ck56 FIND v(dout1_11) AT=1140.1n

* CHECK dout1_12 Vdout1_12ck56 = 1.8 time = 1140
.meas tran vdout1_12ck56 FIND v(dout1_12) AT=1140.1n

* CHECK dout1_13 Vdout1_13ck56 = 1.8 time = 1140
.meas tran vdout1_13ck56 FIND v(dout1_13) AT=1140.1n

* CHECK dout1_14 Vdout1_14ck56 = 0 time = 1140
.meas tran vdout1_14ck56 FIND v(dout1_14) AT=1140.1n

* CHECK dout1_15 Vdout1_15ck56 = 1.8 time = 1140
.meas tran vdout1_15ck56 FIND v(dout1_15) AT=1140.1n

* CHECK dout1_16 Vdout1_16ck56 = 1.8 time = 1140
.meas tran vdout1_16ck56 FIND v(dout1_16) AT=1140.1n

* CHECK dout1_17 Vdout1_17ck56 = 0 time = 1140
.meas tran vdout1_17ck56 FIND v(dout1_17) AT=1140.1n

* CHECK dout1_18 Vdout1_18ck56 = 0 time = 1140
.meas tran vdout1_18ck56 FIND v(dout1_18) AT=1140.1n

* CHECK dout1_19 Vdout1_19ck56 = 1.8 time = 1140
.meas tran vdout1_19ck56 FIND v(dout1_19) AT=1140.1n

* CHECK dout1_20 Vdout1_20ck56 = 0 time = 1140
.meas tran vdout1_20ck56 FIND v(dout1_20) AT=1140.1n

* CHECK dout1_21 Vdout1_21ck56 = 0 time = 1140
.meas tran vdout1_21ck56 FIND v(dout1_21) AT=1140.1n

* CHECK dout1_22 Vdout1_22ck56 = 0 time = 1140
.meas tran vdout1_22ck56 FIND v(dout1_22) AT=1140.1n

* CHECK dout1_23 Vdout1_23ck56 = 1.8 time = 1140
.meas tran vdout1_23ck56 FIND v(dout1_23) AT=1140.1n

* CHECK dout1_24 Vdout1_24ck56 = 1.8 time = 1140
.meas tran vdout1_24ck56 FIND v(dout1_24) AT=1140.1n

* CHECK dout1_25 Vdout1_25ck56 = 1.8 time = 1140
.meas tran vdout1_25ck56 FIND v(dout1_25) AT=1140.1n

* CHECK dout1_26 Vdout1_26ck56 = 0 time = 1140
.meas tran vdout1_26ck56 FIND v(dout1_26) AT=1140.1n

* CHECK dout1_27 Vdout1_27ck56 = 1.8 time = 1140
.meas tran vdout1_27ck56 FIND v(dout1_27) AT=1140.1n

* CHECK dout1_28 Vdout1_28ck56 = 0 time = 1140
.meas tran vdout1_28ck56 FIND v(dout1_28) AT=1140.1n

* CHECK dout1_29 Vdout1_29ck56 = 0 time = 1140
.meas tran vdout1_29ck56 FIND v(dout1_29) AT=1140.1n

* CHECK dout1_30 Vdout1_30ck56 = 1.8 time = 1140
.meas tran vdout1_30ck56 FIND v(dout1_30) AT=1140.1n

* CHECK dout1_31 Vdout1_31ck56 = 0 time = 1140
.meas tran vdout1_31ck56 FIND v(dout1_31) AT=1140.1n

* CHECK dout2_0 Vdout2_0ck56 = 0 time = 1140
.meas tran vdout2_0ck56 FIND v(dout2_0) AT=1140.1n

* CHECK dout2_1 Vdout2_1ck56 = 1.8 time = 1140
.meas tran vdout2_1ck56 FIND v(dout2_1) AT=1140.1n

* CHECK dout2_2 Vdout2_2ck56 = 1.8 time = 1140
.meas tran vdout2_2ck56 FIND v(dout2_2) AT=1140.1n

* CHECK dout2_3 Vdout2_3ck56 = 0 time = 1140
.meas tran vdout2_3ck56 FIND v(dout2_3) AT=1140.1n

* CHECK dout2_4 Vdout2_4ck56 = 1.8 time = 1140
.meas tran vdout2_4ck56 FIND v(dout2_4) AT=1140.1n

* CHECK dout2_5 Vdout2_5ck56 = 0 time = 1140
.meas tran vdout2_5ck56 FIND v(dout2_5) AT=1140.1n

* CHECK dout2_6 Vdout2_6ck56 = 0 time = 1140
.meas tran vdout2_6ck56 FIND v(dout2_6) AT=1140.1n

* CHECK dout2_7 Vdout2_7ck56 = 1.8 time = 1140
.meas tran vdout2_7ck56 FIND v(dout2_7) AT=1140.1n

* CHECK dout2_8 Vdout2_8ck56 = 0 time = 1140
.meas tran vdout2_8ck56 FIND v(dout2_8) AT=1140.1n

* CHECK dout2_9 Vdout2_9ck56 = 0 time = 1140
.meas tran vdout2_9ck56 FIND v(dout2_9) AT=1140.1n

* CHECK dout2_10 Vdout2_10ck56 = 1.8 time = 1140
.meas tran vdout2_10ck56 FIND v(dout2_10) AT=1140.1n

* CHECK dout2_11 Vdout2_11ck56 = 1.8 time = 1140
.meas tran vdout2_11ck56 FIND v(dout2_11) AT=1140.1n

* CHECK dout2_12 Vdout2_12ck56 = 1.8 time = 1140
.meas tran vdout2_12ck56 FIND v(dout2_12) AT=1140.1n

* CHECK dout2_13 Vdout2_13ck56 = 0 time = 1140
.meas tran vdout2_13ck56 FIND v(dout2_13) AT=1140.1n

* CHECK dout2_14 Vdout2_14ck56 = 0 time = 1140
.meas tran vdout2_14ck56 FIND v(dout2_14) AT=1140.1n

* CHECK dout2_15 Vdout2_15ck56 = 0 time = 1140
.meas tran vdout2_15ck56 FIND v(dout2_15) AT=1140.1n

* CHECK dout2_16 Vdout2_16ck56 = 0 time = 1140
.meas tran vdout2_16ck56 FIND v(dout2_16) AT=1140.1n

* CHECK dout2_17 Vdout2_17ck56 = 0 time = 1140
.meas tran vdout2_17ck56 FIND v(dout2_17) AT=1140.1n

* CHECK dout2_18 Vdout2_18ck56 = 0 time = 1140
.meas tran vdout2_18ck56 FIND v(dout2_18) AT=1140.1n

* CHECK dout2_19 Vdout2_19ck56 = 0 time = 1140
.meas tran vdout2_19ck56 FIND v(dout2_19) AT=1140.1n

* CHECK dout2_20 Vdout2_20ck56 = 1.8 time = 1140
.meas tran vdout2_20ck56 FIND v(dout2_20) AT=1140.1n

* CHECK dout2_21 Vdout2_21ck56 = 1.8 time = 1140
.meas tran vdout2_21ck56 FIND v(dout2_21) AT=1140.1n

* CHECK dout2_22 Vdout2_22ck56 = 1.8 time = 1140
.meas tran vdout2_22ck56 FIND v(dout2_22) AT=1140.1n

* CHECK dout2_23 Vdout2_23ck56 = 1.8 time = 1140
.meas tran vdout2_23ck56 FIND v(dout2_23) AT=1140.1n

* CHECK dout2_24 Vdout2_24ck56 = 0 time = 1140
.meas tran vdout2_24ck56 FIND v(dout2_24) AT=1140.1n

* CHECK dout2_25 Vdout2_25ck56 = 1.8 time = 1140
.meas tran vdout2_25ck56 FIND v(dout2_25) AT=1140.1n

* CHECK dout2_26 Vdout2_26ck56 = 1.8 time = 1140
.meas tran vdout2_26ck56 FIND v(dout2_26) AT=1140.1n

* CHECK dout2_27 Vdout2_27ck56 = 1.8 time = 1140
.meas tran vdout2_27ck56 FIND v(dout2_27) AT=1140.1n

* CHECK dout2_28 Vdout2_28ck56 = 1.8 time = 1140
.meas tran vdout2_28ck56 FIND v(dout2_28) AT=1140.1n

* CHECK dout2_29 Vdout2_29ck56 = 0 time = 1140
.meas tran vdout2_29ck56 FIND v(dout2_29) AT=1140.1n

* CHECK dout2_30 Vdout2_30ck56 = 0 time = 1140
.meas tran vdout2_30ck56 FIND v(dout2_30) AT=1140.1n

* CHECK dout2_31 Vdout2_31ck56 = 0 time = 1140
.meas tran vdout2_31ck56 FIND v(dout2_31) AT=1140.1n

* CHECK dout1_0 Vdout1_0ck57 = 0 time = 1160
.meas tran vdout1_0ck57 FIND v(dout1_0) AT=1160.1n

* CHECK dout1_1 Vdout1_1ck57 = 0 time = 1160
.meas tran vdout1_1ck57 FIND v(dout1_1) AT=1160.1n

* CHECK dout1_2 Vdout1_2ck57 = 1.8 time = 1160
.meas tran vdout1_2ck57 FIND v(dout1_2) AT=1160.1n

* CHECK dout1_3 Vdout1_3ck57 = 1.8 time = 1160
.meas tran vdout1_3ck57 FIND v(dout1_3) AT=1160.1n

* CHECK dout1_4 Vdout1_4ck57 = 0 time = 1160
.meas tran vdout1_4ck57 FIND v(dout1_4) AT=1160.1n

* CHECK dout1_5 Vdout1_5ck57 = 1.8 time = 1160
.meas tran vdout1_5ck57 FIND v(dout1_5) AT=1160.1n

* CHECK dout1_6 Vdout1_6ck57 = 0 time = 1160
.meas tran vdout1_6ck57 FIND v(dout1_6) AT=1160.1n

* CHECK dout1_7 Vdout1_7ck57 = 1.8 time = 1160
.meas tran vdout1_7ck57 FIND v(dout1_7) AT=1160.1n

* CHECK dout1_8 Vdout1_8ck57 = 1.8 time = 1160
.meas tran vdout1_8ck57 FIND v(dout1_8) AT=1160.1n

* CHECK dout1_9 Vdout1_9ck57 = 0 time = 1160
.meas tran vdout1_9ck57 FIND v(dout1_9) AT=1160.1n

* CHECK dout1_10 Vdout1_10ck57 = 1.8 time = 1160
.meas tran vdout1_10ck57 FIND v(dout1_10) AT=1160.1n

* CHECK dout1_11 Vdout1_11ck57 = 1.8 time = 1160
.meas tran vdout1_11ck57 FIND v(dout1_11) AT=1160.1n

* CHECK dout1_12 Vdout1_12ck57 = 1.8 time = 1160
.meas tran vdout1_12ck57 FIND v(dout1_12) AT=1160.1n

* CHECK dout1_13 Vdout1_13ck57 = 0 time = 1160
.meas tran vdout1_13ck57 FIND v(dout1_13) AT=1160.1n

* CHECK dout1_14 Vdout1_14ck57 = 0 time = 1160
.meas tran vdout1_14ck57 FIND v(dout1_14) AT=1160.1n

* CHECK dout1_15 Vdout1_15ck57 = 1.8 time = 1160
.meas tran vdout1_15ck57 FIND v(dout1_15) AT=1160.1n

* CHECK dout1_16 Vdout1_16ck57 = 1.8 time = 1160
.meas tran vdout1_16ck57 FIND v(dout1_16) AT=1160.1n

* CHECK dout1_17 Vdout1_17ck57 = 0 time = 1160
.meas tran vdout1_17ck57 FIND v(dout1_17) AT=1160.1n

* CHECK dout1_18 Vdout1_18ck57 = 0 time = 1160
.meas tran vdout1_18ck57 FIND v(dout1_18) AT=1160.1n

* CHECK dout1_19 Vdout1_19ck57 = 1.8 time = 1160
.meas tran vdout1_19ck57 FIND v(dout1_19) AT=1160.1n

* CHECK dout1_20 Vdout1_20ck57 = 1.8 time = 1160
.meas tran vdout1_20ck57 FIND v(dout1_20) AT=1160.1n

* CHECK dout1_21 Vdout1_21ck57 = 1.8 time = 1160
.meas tran vdout1_21ck57 FIND v(dout1_21) AT=1160.1n

* CHECK dout1_22 Vdout1_22ck57 = 1.8 time = 1160
.meas tran vdout1_22ck57 FIND v(dout1_22) AT=1160.1n

* CHECK dout1_23 Vdout1_23ck57 = 1.8 time = 1160
.meas tran vdout1_23ck57 FIND v(dout1_23) AT=1160.1n

* CHECK dout1_24 Vdout1_24ck57 = 0 time = 1160
.meas tran vdout1_24ck57 FIND v(dout1_24) AT=1160.1n

* CHECK dout1_25 Vdout1_25ck57 = 0 time = 1160
.meas tran vdout1_25ck57 FIND v(dout1_25) AT=1160.1n

* CHECK dout1_26 Vdout1_26ck57 = 1.8 time = 1160
.meas tran vdout1_26ck57 FIND v(dout1_26) AT=1160.1n

* CHECK dout1_27 Vdout1_27ck57 = 0 time = 1160
.meas tran vdout1_27ck57 FIND v(dout1_27) AT=1160.1n

* CHECK dout1_28 Vdout1_28ck57 = 0 time = 1160
.meas tran vdout1_28ck57 FIND v(dout1_28) AT=1160.1n

* CHECK dout1_29 Vdout1_29ck57 = 1.8 time = 1160
.meas tran vdout1_29ck57 FIND v(dout1_29) AT=1160.1n

* CHECK dout1_30 Vdout1_30ck57 = 0 time = 1160
.meas tran vdout1_30ck57 FIND v(dout1_30) AT=1160.1n

* CHECK dout1_31 Vdout1_31ck57 = 1.8 time = 1160
.meas tran vdout1_31ck57 FIND v(dout1_31) AT=1160.1n

* CHECK dout2_0 Vdout2_0ck57 = 0 time = 1160
.meas tran vdout2_0ck57 FIND v(dout2_0) AT=1160.1n

* CHECK dout2_1 Vdout2_1ck57 = 1.8 time = 1160
.meas tran vdout2_1ck57 FIND v(dout2_1) AT=1160.1n

* CHECK dout2_2 Vdout2_2ck57 = 1.8 time = 1160
.meas tran vdout2_2ck57 FIND v(dout2_2) AT=1160.1n

* CHECK dout2_3 Vdout2_3ck57 = 0 time = 1160
.meas tran vdout2_3ck57 FIND v(dout2_3) AT=1160.1n

* CHECK dout2_4 Vdout2_4ck57 = 1.8 time = 1160
.meas tran vdout2_4ck57 FIND v(dout2_4) AT=1160.1n

* CHECK dout2_5 Vdout2_5ck57 = 0 time = 1160
.meas tran vdout2_5ck57 FIND v(dout2_5) AT=1160.1n

* CHECK dout2_6 Vdout2_6ck57 = 1.8 time = 1160
.meas tran vdout2_6ck57 FIND v(dout2_6) AT=1160.1n

* CHECK dout2_7 Vdout2_7ck57 = 0 time = 1160
.meas tran vdout2_7ck57 FIND v(dout2_7) AT=1160.1n

* CHECK dout2_8 Vdout2_8ck57 = 1.8 time = 1160
.meas tran vdout2_8ck57 FIND v(dout2_8) AT=1160.1n

* CHECK dout2_9 Vdout2_9ck57 = 0 time = 1160
.meas tran vdout2_9ck57 FIND v(dout2_9) AT=1160.1n

* CHECK dout2_10 Vdout2_10ck57 = 1.8 time = 1160
.meas tran vdout2_10ck57 FIND v(dout2_10) AT=1160.1n

* CHECK dout2_11 Vdout2_11ck57 = 0 time = 1160
.meas tran vdout2_11ck57 FIND v(dout2_11) AT=1160.1n

* CHECK dout2_12 Vdout2_12ck57 = 1.8 time = 1160
.meas tran vdout2_12ck57 FIND v(dout2_12) AT=1160.1n

* CHECK dout2_13 Vdout2_13ck57 = 1.8 time = 1160
.meas tran vdout2_13ck57 FIND v(dout2_13) AT=1160.1n

* CHECK dout2_14 Vdout2_14ck57 = 0 time = 1160
.meas tran vdout2_14ck57 FIND v(dout2_14) AT=1160.1n

* CHECK dout2_15 Vdout2_15ck57 = 1.8 time = 1160
.meas tran vdout2_15ck57 FIND v(dout2_15) AT=1160.1n

* CHECK dout2_16 Vdout2_16ck57 = 1.8 time = 1160
.meas tran vdout2_16ck57 FIND v(dout2_16) AT=1160.1n

* CHECK dout2_17 Vdout2_17ck57 = 0 time = 1160
.meas tran vdout2_17ck57 FIND v(dout2_17) AT=1160.1n

* CHECK dout2_18 Vdout2_18ck57 = 0 time = 1160
.meas tran vdout2_18ck57 FIND v(dout2_18) AT=1160.1n

* CHECK dout2_19 Vdout2_19ck57 = 1.8 time = 1160
.meas tran vdout2_19ck57 FIND v(dout2_19) AT=1160.1n

* CHECK dout2_20 Vdout2_20ck57 = 0 time = 1160
.meas tran vdout2_20ck57 FIND v(dout2_20) AT=1160.1n

* CHECK dout2_21 Vdout2_21ck57 = 0 time = 1160
.meas tran vdout2_21ck57 FIND v(dout2_21) AT=1160.1n

* CHECK dout2_22 Vdout2_22ck57 = 0 time = 1160
.meas tran vdout2_22ck57 FIND v(dout2_22) AT=1160.1n

* CHECK dout2_23 Vdout2_23ck57 = 1.8 time = 1160
.meas tran vdout2_23ck57 FIND v(dout2_23) AT=1160.1n

* CHECK dout2_24 Vdout2_24ck57 = 1.8 time = 1160
.meas tran vdout2_24ck57 FIND v(dout2_24) AT=1160.1n

* CHECK dout2_25 Vdout2_25ck57 = 1.8 time = 1160
.meas tran vdout2_25ck57 FIND v(dout2_25) AT=1160.1n

* CHECK dout2_26 Vdout2_26ck57 = 0 time = 1160
.meas tran vdout2_26ck57 FIND v(dout2_26) AT=1160.1n

* CHECK dout2_27 Vdout2_27ck57 = 1.8 time = 1160
.meas tran vdout2_27ck57 FIND v(dout2_27) AT=1160.1n

* CHECK dout2_28 Vdout2_28ck57 = 0 time = 1160
.meas tran vdout2_28ck57 FIND v(dout2_28) AT=1160.1n

* CHECK dout2_29 Vdout2_29ck57 = 0 time = 1160
.meas tran vdout2_29ck57 FIND v(dout2_29) AT=1160.1n

* CHECK dout2_30 Vdout2_30ck57 = 1.8 time = 1160
.meas tran vdout2_30ck57 FIND v(dout2_30) AT=1160.1n

* CHECK dout2_31 Vdout2_31ck57 = 0 time = 1160
.meas tran vdout2_31ck57 FIND v(dout2_31) AT=1160.1n

* CHECK dout1_0 Vdout1_0ck58 = 1.8 time = 1180
.meas tran vdout1_0ck58 FIND v(dout1_0) AT=1180.1n

* CHECK dout1_1 Vdout1_1ck58 = 1.8 time = 1180
.meas tran vdout1_1ck58 FIND v(dout1_1) AT=1180.1n

* CHECK dout1_2 Vdout1_2ck58 = 1.8 time = 1180
.meas tran vdout1_2ck58 FIND v(dout1_2) AT=1180.1n

* CHECK dout1_3 Vdout1_3ck58 = 1.8 time = 1180
.meas tran vdout1_3ck58 FIND v(dout1_3) AT=1180.1n

* CHECK dout1_4 Vdout1_4ck58 = 0 time = 1180
.meas tran vdout1_4ck58 FIND v(dout1_4) AT=1180.1n

* CHECK dout1_5 Vdout1_5ck58 = 1.8 time = 1180
.meas tran vdout1_5ck58 FIND v(dout1_5) AT=1180.1n

* CHECK dout1_6 Vdout1_6ck58 = 0 time = 1180
.meas tran vdout1_6ck58 FIND v(dout1_6) AT=1180.1n

* CHECK dout1_7 Vdout1_7ck58 = 0 time = 1180
.meas tran vdout1_7ck58 FIND v(dout1_7) AT=1180.1n

* CHECK dout1_8 Vdout1_8ck58 = 0 time = 1180
.meas tran vdout1_8ck58 FIND v(dout1_8) AT=1180.1n

* CHECK dout1_9 Vdout1_9ck58 = 1.8 time = 1180
.meas tran vdout1_9ck58 FIND v(dout1_9) AT=1180.1n

* CHECK dout1_10 Vdout1_10ck58 = 0 time = 1180
.meas tran vdout1_10ck58 FIND v(dout1_10) AT=1180.1n

* CHECK dout1_11 Vdout1_11ck58 = 0 time = 1180
.meas tran vdout1_11ck58 FIND v(dout1_11) AT=1180.1n

* CHECK dout1_12 Vdout1_12ck58 = 1.8 time = 1180
.meas tran vdout1_12ck58 FIND v(dout1_12) AT=1180.1n

* CHECK dout1_13 Vdout1_13ck58 = 1.8 time = 1180
.meas tran vdout1_13ck58 FIND v(dout1_13) AT=1180.1n

* CHECK dout1_14 Vdout1_14ck58 = 1.8 time = 1180
.meas tran vdout1_14ck58 FIND v(dout1_14) AT=1180.1n

* CHECK dout1_15 Vdout1_15ck58 = 1.8 time = 1180
.meas tran vdout1_15ck58 FIND v(dout1_15) AT=1180.1n

* CHECK dout1_16 Vdout1_16ck58 = 0 time = 1180
.meas tran vdout1_16ck58 FIND v(dout1_16) AT=1180.1n

* CHECK dout1_17 Vdout1_17ck58 = 1.8 time = 1180
.meas tran vdout1_17ck58 FIND v(dout1_17) AT=1180.1n

* CHECK dout1_18 Vdout1_18ck58 = 0 time = 1180
.meas tran vdout1_18ck58 FIND v(dout1_18) AT=1180.1n

* CHECK dout1_19 Vdout1_19ck58 = 1.8 time = 1180
.meas tran vdout1_19ck58 FIND v(dout1_19) AT=1180.1n

* CHECK dout1_20 Vdout1_20ck58 = 0 time = 1180
.meas tran vdout1_20ck58 FIND v(dout1_20) AT=1180.1n

* CHECK dout1_21 Vdout1_21ck58 = 0 time = 1180
.meas tran vdout1_21ck58 FIND v(dout1_21) AT=1180.1n

* CHECK dout1_22 Vdout1_22ck58 = 0 time = 1180
.meas tran vdout1_22ck58 FIND v(dout1_22) AT=1180.1n

* CHECK dout1_23 Vdout1_23ck58 = 0 time = 1180
.meas tran vdout1_23ck58 FIND v(dout1_23) AT=1180.1n

* CHECK dout1_24 Vdout1_24ck58 = 0 time = 1180
.meas tran vdout1_24ck58 FIND v(dout1_24) AT=1180.1n

* CHECK dout1_25 Vdout1_25ck58 = 0 time = 1180
.meas tran vdout1_25ck58 FIND v(dout1_25) AT=1180.1n

* CHECK dout1_26 Vdout1_26ck58 = 0 time = 1180
.meas tran vdout1_26ck58 FIND v(dout1_26) AT=1180.1n

* CHECK dout1_27 Vdout1_27ck58 = 1.8 time = 1180
.meas tran vdout1_27ck58 FIND v(dout1_27) AT=1180.1n

* CHECK dout1_28 Vdout1_28ck58 = 1.8 time = 1180
.meas tran vdout1_28ck58 FIND v(dout1_28) AT=1180.1n

* CHECK dout1_29 Vdout1_29ck58 = 1.8 time = 1180
.meas tran vdout1_29ck58 FIND v(dout1_29) AT=1180.1n

* CHECK dout1_30 Vdout1_30ck58 = 0 time = 1180
.meas tran vdout1_30ck58 FIND v(dout1_30) AT=1180.1n

* CHECK dout1_31 Vdout1_31ck58 = 0 time = 1180
.meas tran vdout1_31ck58 FIND v(dout1_31) AT=1180.1n

* CHECK dout2_0 Vdout2_0ck58 = 0 time = 1180
.meas tran vdout2_0ck58 FIND v(dout2_0) AT=1180.1n

* CHECK dout2_1 Vdout2_1ck58 = 0 time = 1180
.meas tran vdout2_1ck58 FIND v(dout2_1) AT=1180.1n

* CHECK dout2_2 Vdout2_2ck58 = 1.8 time = 1180
.meas tran vdout2_2ck58 FIND v(dout2_2) AT=1180.1n

* CHECK dout2_3 Vdout2_3ck58 = 1.8 time = 1180
.meas tran vdout2_3ck58 FIND v(dout2_3) AT=1180.1n

* CHECK dout2_4 Vdout2_4ck58 = 0 time = 1180
.meas tran vdout2_4ck58 FIND v(dout2_4) AT=1180.1n

* CHECK dout2_5 Vdout2_5ck58 = 1.8 time = 1180
.meas tran vdout2_5ck58 FIND v(dout2_5) AT=1180.1n

* CHECK dout2_6 Vdout2_6ck58 = 0 time = 1180
.meas tran vdout2_6ck58 FIND v(dout2_6) AT=1180.1n

* CHECK dout2_7 Vdout2_7ck58 = 1.8 time = 1180
.meas tran vdout2_7ck58 FIND v(dout2_7) AT=1180.1n

* CHECK dout2_8 Vdout2_8ck58 = 1.8 time = 1180
.meas tran vdout2_8ck58 FIND v(dout2_8) AT=1180.1n

* CHECK dout2_9 Vdout2_9ck58 = 0 time = 1180
.meas tran vdout2_9ck58 FIND v(dout2_9) AT=1180.1n

* CHECK dout2_10 Vdout2_10ck58 = 1.8 time = 1180
.meas tran vdout2_10ck58 FIND v(dout2_10) AT=1180.1n

* CHECK dout2_11 Vdout2_11ck58 = 1.8 time = 1180
.meas tran vdout2_11ck58 FIND v(dout2_11) AT=1180.1n

* CHECK dout2_12 Vdout2_12ck58 = 1.8 time = 1180
.meas tran vdout2_12ck58 FIND v(dout2_12) AT=1180.1n

* CHECK dout2_13 Vdout2_13ck58 = 0 time = 1180
.meas tran vdout2_13ck58 FIND v(dout2_13) AT=1180.1n

* CHECK dout2_14 Vdout2_14ck58 = 0 time = 1180
.meas tran vdout2_14ck58 FIND v(dout2_14) AT=1180.1n

* CHECK dout2_15 Vdout2_15ck58 = 1.8 time = 1180
.meas tran vdout2_15ck58 FIND v(dout2_15) AT=1180.1n

* CHECK dout2_16 Vdout2_16ck58 = 1.8 time = 1180
.meas tran vdout2_16ck58 FIND v(dout2_16) AT=1180.1n

* CHECK dout2_17 Vdout2_17ck58 = 0 time = 1180
.meas tran vdout2_17ck58 FIND v(dout2_17) AT=1180.1n

* CHECK dout2_18 Vdout2_18ck58 = 0 time = 1180
.meas tran vdout2_18ck58 FIND v(dout2_18) AT=1180.1n

* CHECK dout2_19 Vdout2_19ck58 = 1.8 time = 1180
.meas tran vdout2_19ck58 FIND v(dout2_19) AT=1180.1n

* CHECK dout2_20 Vdout2_20ck58 = 1.8 time = 1180
.meas tran vdout2_20ck58 FIND v(dout2_20) AT=1180.1n

* CHECK dout2_21 Vdout2_21ck58 = 1.8 time = 1180
.meas tran vdout2_21ck58 FIND v(dout2_21) AT=1180.1n

* CHECK dout2_22 Vdout2_22ck58 = 1.8 time = 1180
.meas tran vdout2_22ck58 FIND v(dout2_22) AT=1180.1n

* CHECK dout2_23 Vdout2_23ck58 = 1.8 time = 1180
.meas tran vdout2_23ck58 FIND v(dout2_23) AT=1180.1n

* CHECK dout2_24 Vdout2_24ck58 = 0 time = 1180
.meas tran vdout2_24ck58 FIND v(dout2_24) AT=1180.1n

* CHECK dout2_25 Vdout2_25ck58 = 0 time = 1180
.meas tran vdout2_25ck58 FIND v(dout2_25) AT=1180.1n

* CHECK dout2_26 Vdout2_26ck58 = 1.8 time = 1180
.meas tran vdout2_26ck58 FIND v(dout2_26) AT=1180.1n

* CHECK dout2_27 Vdout2_27ck58 = 0 time = 1180
.meas tran vdout2_27ck58 FIND v(dout2_27) AT=1180.1n

* CHECK dout2_28 Vdout2_28ck58 = 0 time = 1180
.meas tran vdout2_28ck58 FIND v(dout2_28) AT=1180.1n

* CHECK dout2_29 Vdout2_29ck58 = 1.8 time = 1180
.meas tran vdout2_29ck58 FIND v(dout2_29) AT=1180.1n

* CHECK dout2_30 Vdout2_30ck58 = 0 time = 1180
.meas tran vdout2_30ck58 FIND v(dout2_30) AT=1180.1n

* CHECK dout2_31 Vdout2_31ck58 = 1.8 time = 1180
.meas tran vdout2_31ck58 FIND v(dout2_31) AT=1180.1n

* CHECK dout1_0 Vdout1_0ck59 = 0 time = 1200
.meas tran vdout1_0ck59 FIND v(dout1_0) AT=1200.1n

* CHECK dout1_1 Vdout1_1ck59 = 1.8 time = 1200
.meas tran vdout1_1ck59 FIND v(dout1_1) AT=1200.1n

* CHECK dout1_2 Vdout1_2ck59 = 1.8 time = 1200
.meas tran vdout1_2ck59 FIND v(dout1_2) AT=1200.1n

* CHECK dout1_3 Vdout1_3ck59 = 0 time = 1200
.meas tran vdout1_3ck59 FIND v(dout1_3) AT=1200.1n

* CHECK dout1_4 Vdout1_4ck59 = 1.8 time = 1200
.meas tran vdout1_4ck59 FIND v(dout1_4) AT=1200.1n

* CHECK dout1_5 Vdout1_5ck59 = 0 time = 1200
.meas tran vdout1_5ck59 FIND v(dout1_5) AT=1200.1n

* CHECK dout1_6 Vdout1_6ck59 = 1.8 time = 1200
.meas tran vdout1_6ck59 FIND v(dout1_6) AT=1200.1n

* CHECK dout1_7 Vdout1_7ck59 = 0 time = 1200
.meas tran vdout1_7ck59 FIND v(dout1_7) AT=1200.1n

* CHECK dout1_8 Vdout1_8ck59 = 1.8 time = 1200
.meas tran vdout1_8ck59 FIND v(dout1_8) AT=1200.1n

* CHECK dout1_9 Vdout1_9ck59 = 0 time = 1200
.meas tran vdout1_9ck59 FIND v(dout1_9) AT=1200.1n

* CHECK dout1_10 Vdout1_10ck59 = 1.8 time = 1200
.meas tran vdout1_10ck59 FIND v(dout1_10) AT=1200.1n

* CHECK dout1_11 Vdout1_11ck59 = 0 time = 1200
.meas tran vdout1_11ck59 FIND v(dout1_11) AT=1200.1n

* CHECK dout1_12 Vdout1_12ck59 = 1.8 time = 1200
.meas tran vdout1_12ck59 FIND v(dout1_12) AT=1200.1n

* CHECK dout1_13 Vdout1_13ck59 = 1.8 time = 1200
.meas tran vdout1_13ck59 FIND v(dout1_13) AT=1200.1n

* CHECK dout1_14 Vdout1_14ck59 = 0 time = 1200
.meas tran vdout1_14ck59 FIND v(dout1_14) AT=1200.1n

* CHECK dout1_15 Vdout1_15ck59 = 1.8 time = 1200
.meas tran vdout1_15ck59 FIND v(dout1_15) AT=1200.1n

* CHECK dout1_16 Vdout1_16ck59 = 1.8 time = 1200
.meas tran vdout1_16ck59 FIND v(dout1_16) AT=1200.1n

* CHECK dout1_17 Vdout1_17ck59 = 0 time = 1200
.meas tran vdout1_17ck59 FIND v(dout1_17) AT=1200.1n

* CHECK dout1_18 Vdout1_18ck59 = 0 time = 1200
.meas tran vdout1_18ck59 FIND v(dout1_18) AT=1200.1n

* CHECK dout1_19 Vdout1_19ck59 = 1.8 time = 1200
.meas tran vdout1_19ck59 FIND v(dout1_19) AT=1200.1n

* CHECK dout1_20 Vdout1_20ck59 = 0 time = 1200
.meas tran vdout1_20ck59 FIND v(dout1_20) AT=1200.1n

* CHECK dout1_21 Vdout1_21ck59 = 0 time = 1200
.meas tran vdout1_21ck59 FIND v(dout1_21) AT=1200.1n

* CHECK dout1_22 Vdout1_22ck59 = 0 time = 1200
.meas tran vdout1_22ck59 FIND v(dout1_22) AT=1200.1n

* CHECK dout1_23 Vdout1_23ck59 = 1.8 time = 1200
.meas tran vdout1_23ck59 FIND v(dout1_23) AT=1200.1n

* CHECK dout1_24 Vdout1_24ck59 = 1.8 time = 1200
.meas tran vdout1_24ck59 FIND v(dout1_24) AT=1200.1n

* CHECK dout1_25 Vdout1_25ck59 = 1.8 time = 1200
.meas tran vdout1_25ck59 FIND v(dout1_25) AT=1200.1n

* CHECK dout1_26 Vdout1_26ck59 = 0 time = 1200
.meas tran vdout1_26ck59 FIND v(dout1_26) AT=1200.1n

* CHECK dout1_27 Vdout1_27ck59 = 1.8 time = 1200
.meas tran vdout1_27ck59 FIND v(dout1_27) AT=1200.1n

* CHECK dout1_28 Vdout1_28ck59 = 0 time = 1200
.meas tran vdout1_28ck59 FIND v(dout1_28) AT=1200.1n

* CHECK dout1_29 Vdout1_29ck59 = 0 time = 1200
.meas tran vdout1_29ck59 FIND v(dout1_29) AT=1200.1n

* CHECK dout1_30 Vdout1_30ck59 = 1.8 time = 1200
.meas tran vdout1_30ck59 FIND v(dout1_30) AT=1200.1n

* CHECK dout1_31 Vdout1_31ck59 = 0 time = 1200
.meas tran vdout1_31ck59 FIND v(dout1_31) AT=1200.1n

* CHECK dout2_0 Vdout2_0ck59 = 0 time = 1200
.meas tran vdout2_0ck59 FIND v(dout2_0) AT=1200.1n

* CHECK dout2_1 Vdout2_1ck59 = 1.8 time = 1200
.meas tran vdout2_1ck59 FIND v(dout2_1) AT=1200.1n

* CHECK dout2_2 Vdout2_2ck59 = 1.8 time = 1200
.meas tran vdout2_2ck59 FIND v(dout2_2) AT=1200.1n

* CHECK dout2_3 Vdout2_3ck59 = 0 time = 1200
.meas tran vdout2_3ck59 FIND v(dout2_3) AT=1200.1n

* CHECK dout2_4 Vdout2_4ck59 = 1.8 time = 1200
.meas tran vdout2_4ck59 FIND v(dout2_4) AT=1200.1n

* CHECK dout2_5 Vdout2_5ck59 = 0 time = 1200
.meas tran vdout2_5ck59 FIND v(dout2_5) AT=1200.1n

* CHECK dout2_6 Vdout2_6ck59 = 1.8 time = 1200
.meas tran vdout2_6ck59 FIND v(dout2_6) AT=1200.1n

* CHECK dout2_7 Vdout2_7ck59 = 0 time = 1200
.meas tran vdout2_7ck59 FIND v(dout2_7) AT=1200.1n

* CHECK dout2_8 Vdout2_8ck59 = 1.8 time = 1200
.meas tran vdout2_8ck59 FIND v(dout2_8) AT=1200.1n

* CHECK dout2_9 Vdout2_9ck59 = 0 time = 1200
.meas tran vdout2_9ck59 FIND v(dout2_9) AT=1200.1n

* CHECK dout2_10 Vdout2_10ck59 = 1.8 time = 1200
.meas tran vdout2_10ck59 FIND v(dout2_10) AT=1200.1n

* CHECK dout2_11 Vdout2_11ck59 = 0 time = 1200
.meas tran vdout2_11ck59 FIND v(dout2_11) AT=1200.1n

* CHECK dout2_12 Vdout2_12ck59 = 1.8 time = 1200
.meas tran vdout2_12ck59 FIND v(dout2_12) AT=1200.1n

* CHECK dout2_13 Vdout2_13ck59 = 1.8 time = 1200
.meas tran vdout2_13ck59 FIND v(dout2_13) AT=1200.1n

* CHECK dout2_14 Vdout2_14ck59 = 0 time = 1200
.meas tran vdout2_14ck59 FIND v(dout2_14) AT=1200.1n

* CHECK dout2_15 Vdout2_15ck59 = 1.8 time = 1200
.meas tran vdout2_15ck59 FIND v(dout2_15) AT=1200.1n

* CHECK dout2_16 Vdout2_16ck59 = 1.8 time = 1200
.meas tran vdout2_16ck59 FIND v(dout2_16) AT=1200.1n

* CHECK dout2_17 Vdout2_17ck59 = 0 time = 1200
.meas tran vdout2_17ck59 FIND v(dout2_17) AT=1200.1n

* CHECK dout2_18 Vdout2_18ck59 = 0 time = 1200
.meas tran vdout2_18ck59 FIND v(dout2_18) AT=1200.1n

* CHECK dout2_19 Vdout2_19ck59 = 1.8 time = 1200
.meas tran vdout2_19ck59 FIND v(dout2_19) AT=1200.1n

* CHECK dout2_20 Vdout2_20ck59 = 0 time = 1200
.meas tran vdout2_20ck59 FIND v(dout2_20) AT=1200.1n

* CHECK dout2_21 Vdout2_21ck59 = 0 time = 1200
.meas tran vdout2_21ck59 FIND v(dout2_21) AT=1200.1n

* CHECK dout2_22 Vdout2_22ck59 = 0 time = 1200
.meas tran vdout2_22ck59 FIND v(dout2_22) AT=1200.1n

* CHECK dout2_23 Vdout2_23ck59 = 1.8 time = 1200
.meas tran vdout2_23ck59 FIND v(dout2_23) AT=1200.1n

* CHECK dout2_24 Vdout2_24ck59 = 1.8 time = 1200
.meas tran vdout2_24ck59 FIND v(dout2_24) AT=1200.1n

* CHECK dout2_25 Vdout2_25ck59 = 1.8 time = 1200
.meas tran vdout2_25ck59 FIND v(dout2_25) AT=1200.1n

* CHECK dout2_26 Vdout2_26ck59 = 0 time = 1200
.meas tran vdout2_26ck59 FIND v(dout2_26) AT=1200.1n

* CHECK dout2_27 Vdout2_27ck59 = 1.8 time = 1200
.meas tran vdout2_27ck59 FIND v(dout2_27) AT=1200.1n

* CHECK dout2_28 Vdout2_28ck59 = 0 time = 1200
.meas tran vdout2_28ck59 FIND v(dout2_28) AT=1200.1n

* CHECK dout2_29 Vdout2_29ck59 = 0 time = 1200
.meas tran vdout2_29ck59 FIND v(dout2_29) AT=1200.1n

* CHECK dout2_30 Vdout2_30ck59 = 1.8 time = 1200
.meas tran vdout2_30ck59 FIND v(dout2_30) AT=1200.1n

* CHECK dout2_31 Vdout2_31ck59 = 0 time = 1200
.meas tran vdout2_31ck59 FIND v(dout2_31) AT=1200.1n

* CHECK dout2_0 Vdout2_0ck60 = 0 time = 1220
.meas tran vdout2_0ck60 FIND v(dout2_0) AT=1220.1n

* CHECK dout2_1 Vdout2_1ck60 = 1.8 time = 1220
.meas tran vdout2_1ck60 FIND v(dout2_1) AT=1220.1n

* CHECK dout2_2 Vdout2_2ck60 = 1.8 time = 1220
.meas tran vdout2_2ck60 FIND v(dout2_2) AT=1220.1n

* CHECK dout2_3 Vdout2_3ck60 = 0 time = 1220
.meas tran vdout2_3ck60 FIND v(dout2_3) AT=1220.1n

* CHECK dout2_4 Vdout2_4ck60 = 1.8 time = 1220
.meas tran vdout2_4ck60 FIND v(dout2_4) AT=1220.1n

* CHECK dout2_5 Vdout2_5ck60 = 0 time = 1220
.meas tran vdout2_5ck60 FIND v(dout2_5) AT=1220.1n

* CHECK dout2_6 Vdout2_6ck60 = 1.8 time = 1220
.meas tran vdout2_6ck60 FIND v(dout2_6) AT=1220.1n

* CHECK dout2_7 Vdout2_7ck60 = 0 time = 1220
.meas tran vdout2_7ck60 FIND v(dout2_7) AT=1220.1n

* CHECK dout2_8 Vdout2_8ck60 = 1.8 time = 1220
.meas tran vdout2_8ck60 FIND v(dout2_8) AT=1220.1n

* CHECK dout2_9 Vdout2_9ck60 = 0 time = 1220
.meas tran vdout2_9ck60 FIND v(dout2_9) AT=1220.1n

* CHECK dout2_10 Vdout2_10ck60 = 1.8 time = 1220
.meas tran vdout2_10ck60 FIND v(dout2_10) AT=1220.1n

* CHECK dout2_11 Vdout2_11ck60 = 0 time = 1220
.meas tran vdout2_11ck60 FIND v(dout2_11) AT=1220.1n

* CHECK dout2_12 Vdout2_12ck60 = 1.8 time = 1220
.meas tran vdout2_12ck60 FIND v(dout2_12) AT=1220.1n

* CHECK dout2_13 Vdout2_13ck60 = 1.8 time = 1220
.meas tran vdout2_13ck60 FIND v(dout2_13) AT=1220.1n

* CHECK dout2_14 Vdout2_14ck60 = 0 time = 1220
.meas tran vdout2_14ck60 FIND v(dout2_14) AT=1220.1n

* CHECK dout2_15 Vdout2_15ck60 = 1.8 time = 1220
.meas tran vdout2_15ck60 FIND v(dout2_15) AT=1220.1n

* CHECK dout2_16 Vdout2_16ck60 = 1.8 time = 1220
.meas tran vdout2_16ck60 FIND v(dout2_16) AT=1220.1n

* CHECK dout2_17 Vdout2_17ck60 = 0 time = 1220
.meas tran vdout2_17ck60 FIND v(dout2_17) AT=1220.1n

* CHECK dout2_18 Vdout2_18ck60 = 0 time = 1220
.meas tran vdout2_18ck60 FIND v(dout2_18) AT=1220.1n

* CHECK dout2_19 Vdout2_19ck60 = 1.8 time = 1220
.meas tran vdout2_19ck60 FIND v(dout2_19) AT=1220.1n

* CHECK dout2_20 Vdout2_20ck60 = 0 time = 1220
.meas tran vdout2_20ck60 FIND v(dout2_20) AT=1220.1n

* CHECK dout2_21 Vdout2_21ck60 = 0 time = 1220
.meas tran vdout2_21ck60 FIND v(dout2_21) AT=1220.1n

* CHECK dout2_22 Vdout2_22ck60 = 0 time = 1220
.meas tran vdout2_22ck60 FIND v(dout2_22) AT=1220.1n

* CHECK dout2_23 Vdout2_23ck60 = 1.8 time = 1220
.meas tran vdout2_23ck60 FIND v(dout2_23) AT=1220.1n

* CHECK dout2_24 Vdout2_24ck60 = 1.8 time = 1220
.meas tran vdout2_24ck60 FIND v(dout2_24) AT=1220.1n

* CHECK dout2_25 Vdout2_25ck60 = 1.8 time = 1220
.meas tran vdout2_25ck60 FIND v(dout2_25) AT=1220.1n

* CHECK dout2_26 Vdout2_26ck60 = 0 time = 1220
.meas tran vdout2_26ck60 FIND v(dout2_26) AT=1220.1n

* CHECK dout2_27 Vdout2_27ck60 = 1.8 time = 1220
.meas tran vdout2_27ck60 FIND v(dout2_27) AT=1220.1n

* CHECK dout2_28 Vdout2_28ck60 = 0 time = 1220
.meas tran vdout2_28ck60 FIND v(dout2_28) AT=1220.1n

* CHECK dout2_29 Vdout2_29ck60 = 0 time = 1220
.meas tran vdout2_29ck60 FIND v(dout2_29) AT=1220.1n

* CHECK dout2_30 Vdout2_30ck60 = 1.8 time = 1220
.meas tran vdout2_30ck60 FIND v(dout2_30) AT=1220.1n

* CHECK dout2_31 Vdout2_31ck60 = 0 time = 1220
.meas tran vdout2_31ck60 FIND v(dout2_31) AT=1220.1n

* CHECK dout1_0 Vdout1_0ck61 = 0 time = 1240
.meas tran vdout1_0ck61 FIND v(dout1_0) AT=1240.1n

* CHECK dout1_1 Vdout1_1ck61 = 0 time = 1240
.meas tran vdout1_1ck61 FIND v(dout1_1) AT=1240.1n

* CHECK dout1_2 Vdout1_2ck61 = 0 time = 1240
.meas tran vdout1_2ck61 FIND v(dout1_2) AT=1240.1n

* CHECK dout1_3 Vdout1_3ck61 = 0 time = 1240
.meas tran vdout1_3ck61 FIND v(dout1_3) AT=1240.1n

* CHECK dout1_4 Vdout1_4ck61 = 0 time = 1240
.meas tran vdout1_4ck61 FIND v(dout1_4) AT=1240.1n

* CHECK dout1_5 Vdout1_5ck61 = 1.8 time = 1240
.meas tran vdout1_5ck61 FIND v(dout1_5) AT=1240.1n

* CHECK dout1_6 Vdout1_6ck61 = 0 time = 1240
.meas tran vdout1_6ck61 FIND v(dout1_6) AT=1240.1n

* CHECK dout1_7 Vdout1_7ck61 = 1.8 time = 1240
.meas tran vdout1_7ck61 FIND v(dout1_7) AT=1240.1n

* CHECK dout1_8 Vdout1_8ck61 = 0 time = 1240
.meas tran vdout1_8ck61 FIND v(dout1_8) AT=1240.1n

* CHECK dout1_9 Vdout1_9ck61 = 1.8 time = 1240
.meas tran vdout1_9ck61 FIND v(dout1_9) AT=1240.1n

* CHECK dout1_10 Vdout1_10ck61 = 1.8 time = 1240
.meas tran vdout1_10ck61 FIND v(dout1_10) AT=1240.1n

* CHECK dout1_11 Vdout1_11ck61 = 1.8 time = 1240
.meas tran vdout1_11ck61 FIND v(dout1_11) AT=1240.1n

* CHECK dout1_12 Vdout1_12ck61 = 1.8 time = 1240
.meas tran vdout1_12ck61 FIND v(dout1_12) AT=1240.1n

* CHECK dout1_13 Vdout1_13ck61 = 1.8 time = 1240
.meas tran vdout1_13ck61 FIND v(dout1_13) AT=1240.1n

* CHECK dout1_14 Vdout1_14ck61 = 1.8 time = 1240
.meas tran vdout1_14ck61 FIND v(dout1_14) AT=1240.1n

* CHECK dout1_15 Vdout1_15ck61 = 1.8 time = 1240
.meas tran vdout1_15ck61 FIND v(dout1_15) AT=1240.1n

* CHECK dout1_16 Vdout1_16ck61 = 1.8 time = 1240
.meas tran vdout1_16ck61 FIND v(dout1_16) AT=1240.1n

* CHECK dout1_17 Vdout1_17ck61 = 0 time = 1240
.meas tran vdout1_17ck61 FIND v(dout1_17) AT=1240.1n

* CHECK dout1_18 Vdout1_18ck61 = 0 time = 1240
.meas tran vdout1_18ck61 FIND v(dout1_18) AT=1240.1n

* CHECK dout1_19 Vdout1_19ck61 = 0 time = 1240
.meas tran vdout1_19ck61 FIND v(dout1_19) AT=1240.1n

* CHECK dout1_20 Vdout1_20ck61 = 0 time = 1240
.meas tran vdout1_20ck61 FIND v(dout1_20) AT=1240.1n

* CHECK dout1_21 Vdout1_21ck61 = 1.8 time = 1240
.meas tran vdout1_21ck61 FIND v(dout1_21) AT=1240.1n

* CHECK dout1_22 Vdout1_22ck61 = 0 time = 1240
.meas tran vdout1_22ck61 FIND v(dout1_22) AT=1240.1n

* CHECK dout1_23 Vdout1_23ck61 = 1.8 time = 1240
.meas tran vdout1_23ck61 FIND v(dout1_23) AT=1240.1n

* CHECK dout1_24 Vdout1_24ck61 = 0 time = 1240
.meas tran vdout1_24ck61 FIND v(dout1_24) AT=1240.1n

* CHECK dout1_25 Vdout1_25ck61 = 1.8 time = 1240
.meas tran vdout1_25ck61 FIND v(dout1_25) AT=1240.1n

* CHECK dout1_26 Vdout1_26ck61 = 0 time = 1240
.meas tran vdout1_26ck61 FIND v(dout1_26) AT=1240.1n

* CHECK dout1_27 Vdout1_27ck61 = 1.8 time = 1240
.meas tran vdout1_27ck61 FIND v(dout1_27) AT=1240.1n

* CHECK dout1_28 Vdout1_28ck61 = 1.8 time = 1240
.meas tran vdout1_28ck61 FIND v(dout1_28) AT=1240.1n

* CHECK dout1_29 Vdout1_29ck61 = 1.8 time = 1240
.meas tran vdout1_29ck61 FIND v(dout1_29) AT=1240.1n

* CHECK dout1_30 Vdout1_30ck61 = 0 time = 1240
.meas tran vdout1_30ck61 FIND v(dout1_30) AT=1240.1n

* CHECK dout1_31 Vdout1_31ck61 = 0 time = 1240
.meas tran vdout1_31ck61 FIND v(dout1_31) AT=1240.1n

* CHECK dout1_0 Vdout1_0ck62 = 1.8 time = 1260
.meas tran vdout1_0ck62 FIND v(dout1_0) AT=1260.1n

* CHECK dout1_1 Vdout1_1ck62 = 1.8 time = 1260
.meas tran vdout1_1ck62 FIND v(dout1_1) AT=1260.1n

* CHECK dout1_2 Vdout1_2ck62 = 1.8 time = 1260
.meas tran vdout1_2ck62 FIND v(dout1_2) AT=1260.1n

* CHECK dout1_3 Vdout1_3ck62 = 1.8 time = 1260
.meas tran vdout1_3ck62 FIND v(dout1_3) AT=1260.1n

* CHECK dout1_4 Vdout1_4ck62 = 0 time = 1260
.meas tran vdout1_4ck62 FIND v(dout1_4) AT=1260.1n

* CHECK dout1_5 Vdout1_5ck62 = 1.8 time = 1260
.meas tran vdout1_5ck62 FIND v(dout1_5) AT=1260.1n

* CHECK dout1_6 Vdout1_6ck62 = 0 time = 1260
.meas tran vdout1_6ck62 FIND v(dout1_6) AT=1260.1n

* CHECK dout1_7 Vdout1_7ck62 = 0 time = 1260
.meas tran vdout1_7ck62 FIND v(dout1_7) AT=1260.1n

* CHECK dout1_8 Vdout1_8ck62 = 0 time = 1260
.meas tran vdout1_8ck62 FIND v(dout1_8) AT=1260.1n

* CHECK dout1_9 Vdout1_9ck62 = 1.8 time = 1260
.meas tran vdout1_9ck62 FIND v(dout1_9) AT=1260.1n

* CHECK dout1_10 Vdout1_10ck62 = 0 time = 1260
.meas tran vdout1_10ck62 FIND v(dout1_10) AT=1260.1n

* CHECK dout1_11 Vdout1_11ck62 = 0 time = 1260
.meas tran vdout1_11ck62 FIND v(dout1_11) AT=1260.1n

* CHECK dout1_12 Vdout1_12ck62 = 1.8 time = 1260
.meas tran vdout1_12ck62 FIND v(dout1_12) AT=1260.1n

* CHECK dout1_13 Vdout1_13ck62 = 1.8 time = 1260
.meas tran vdout1_13ck62 FIND v(dout1_13) AT=1260.1n

* CHECK dout1_14 Vdout1_14ck62 = 1.8 time = 1260
.meas tran vdout1_14ck62 FIND v(dout1_14) AT=1260.1n

* CHECK dout1_15 Vdout1_15ck62 = 1.8 time = 1260
.meas tran vdout1_15ck62 FIND v(dout1_15) AT=1260.1n

* CHECK dout1_16 Vdout1_16ck62 = 0 time = 1260
.meas tran vdout1_16ck62 FIND v(dout1_16) AT=1260.1n

* CHECK dout1_17 Vdout1_17ck62 = 1.8 time = 1260
.meas tran vdout1_17ck62 FIND v(dout1_17) AT=1260.1n

* CHECK dout1_18 Vdout1_18ck62 = 0 time = 1260
.meas tran vdout1_18ck62 FIND v(dout1_18) AT=1260.1n

* CHECK dout1_19 Vdout1_19ck62 = 1.8 time = 1260
.meas tran vdout1_19ck62 FIND v(dout1_19) AT=1260.1n

* CHECK dout1_20 Vdout1_20ck62 = 0 time = 1260
.meas tran vdout1_20ck62 FIND v(dout1_20) AT=1260.1n

* CHECK dout1_21 Vdout1_21ck62 = 0 time = 1260
.meas tran vdout1_21ck62 FIND v(dout1_21) AT=1260.1n

* CHECK dout1_22 Vdout1_22ck62 = 0 time = 1260
.meas tran vdout1_22ck62 FIND v(dout1_22) AT=1260.1n

* CHECK dout1_23 Vdout1_23ck62 = 0 time = 1260
.meas tran vdout1_23ck62 FIND v(dout1_23) AT=1260.1n

* CHECK dout1_24 Vdout1_24ck62 = 0 time = 1260
.meas tran vdout1_24ck62 FIND v(dout1_24) AT=1260.1n

* CHECK dout1_25 Vdout1_25ck62 = 0 time = 1260
.meas tran vdout1_25ck62 FIND v(dout1_25) AT=1260.1n

* CHECK dout1_26 Vdout1_26ck62 = 0 time = 1260
.meas tran vdout1_26ck62 FIND v(dout1_26) AT=1260.1n

* CHECK dout1_27 Vdout1_27ck62 = 1.8 time = 1260
.meas tran vdout1_27ck62 FIND v(dout1_27) AT=1260.1n

* CHECK dout1_28 Vdout1_28ck62 = 1.8 time = 1260
.meas tran vdout1_28ck62 FIND v(dout1_28) AT=1260.1n

* CHECK dout1_29 Vdout1_29ck62 = 1.8 time = 1260
.meas tran vdout1_29ck62 FIND v(dout1_29) AT=1260.1n

* CHECK dout1_30 Vdout1_30ck62 = 0 time = 1260
.meas tran vdout1_30ck62 FIND v(dout1_30) AT=1260.1n

* CHECK dout1_31 Vdout1_31ck62 = 0 time = 1260
.meas tran vdout1_31ck62 FIND v(dout1_31) AT=1260.1n

* CHECK dout2_0 Vdout2_0ck62 = 0 time = 1260
.meas tran vdout2_0ck62 FIND v(dout2_0) AT=1260.1n

* CHECK dout2_1 Vdout2_1ck62 = 0 time = 1260
.meas tran vdout2_1ck62 FIND v(dout2_1) AT=1260.1n

* CHECK dout2_2 Vdout2_2ck62 = 0 time = 1260
.meas tran vdout2_2ck62 FIND v(dout2_2) AT=1260.1n

* CHECK dout2_3 Vdout2_3ck62 = 0 time = 1260
.meas tran vdout2_3ck62 FIND v(dout2_3) AT=1260.1n

* CHECK dout2_4 Vdout2_4ck62 = 0 time = 1260
.meas tran vdout2_4ck62 FIND v(dout2_4) AT=1260.1n

* CHECK dout2_5 Vdout2_5ck62 = 1.8 time = 1260
.meas tran vdout2_5ck62 FIND v(dout2_5) AT=1260.1n

* CHECK dout2_6 Vdout2_6ck62 = 0 time = 1260
.meas tran vdout2_6ck62 FIND v(dout2_6) AT=1260.1n

* CHECK dout2_7 Vdout2_7ck62 = 1.8 time = 1260
.meas tran vdout2_7ck62 FIND v(dout2_7) AT=1260.1n

* CHECK dout2_8 Vdout2_8ck62 = 0 time = 1260
.meas tran vdout2_8ck62 FIND v(dout2_8) AT=1260.1n

* CHECK dout2_9 Vdout2_9ck62 = 1.8 time = 1260
.meas tran vdout2_9ck62 FIND v(dout2_9) AT=1260.1n

* CHECK dout2_10 Vdout2_10ck62 = 1.8 time = 1260
.meas tran vdout2_10ck62 FIND v(dout2_10) AT=1260.1n

* CHECK dout2_11 Vdout2_11ck62 = 1.8 time = 1260
.meas tran vdout2_11ck62 FIND v(dout2_11) AT=1260.1n

* CHECK dout2_12 Vdout2_12ck62 = 1.8 time = 1260
.meas tran vdout2_12ck62 FIND v(dout2_12) AT=1260.1n

* CHECK dout2_13 Vdout2_13ck62 = 1.8 time = 1260
.meas tran vdout2_13ck62 FIND v(dout2_13) AT=1260.1n

* CHECK dout2_14 Vdout2_14ck62 = 1.8 time = 1260
.meas tran vdout2_14ck62 FIND v(dout2_14) AT=1260.1n

* CHECK dout2_15 Vdout2_15ck62 = 1.8 time = 1260
.meas tran vdout2_15ck62 FIND v(dout2_15) AT=1260.1n

* CHECK dout2_16 Vdout2_16ck62 = 1.8 time = 1260
.meas tran vdout2_16ck62 FIND v(dout2_16) AT=1260.1n

* CHECK dout2_17 Vdout2_17ck62 = 0 time = 1260
.meas tran vdout2_17ck62 FIND v(dout2_17) AT=1260.1n

* CHECK dout2_18 Vdout2_18ck62 = 0 time = 1260
.meas tran vdout2_18ck62 FIND v(dout2_18) AT=1260.1n

* CHECK dout2_19 Vdout2_19ck62 = 0 time = 1260
.meas tran vdout2_19ck62 FIND v(dout2_19) AT=1260.1n

* CHECK dout2_20 Vdout2_20ck62 = 0 time = 1260
.meas tran vdout2_20ck62 FIND v(dout2_20) AT=1260.1n

* CHECK dout2_21 Vdout2_21ck62 = 1.8 time = 1260
.meas tran vdout2_21ck62 FIND v(dout2_21) AT=1260.1n

* CHECK dout2_22 Vdout2_22ck62 = 0 time = 1260
.meas tran vdout2_22ck62 FIND v(dout2_22) AT=1260.1n

* CHECK dout2_23 Vdout2_23ck62 = 1.8 time = 1260
.meas tran vdout2_23ck62 FIND v(dout2_23) AT=1260.1n

* CHECK dout2_24 Vdout2_24ck62 = 0 time = 1260
.meas tran vdout2_24ck62 FIND v(dout2_24) AT=1260.1n

* CHECK dout2_25 Vdout2_25ck62 = 1.8 time = 1260
.meas tran vdout2_25ck62 FIND v(dout2_25) AT=1260.1n

* CHECK dout2_26 Vdout2_26ck62 = 0 time = 1260
.meas tran vdout2_26ck62 FIND v(dout2_26) AT=1260.1n

* CHECK dout2_27 Vdout2_27ck62 = 1.8 time = 1260
.meas tran vdout2_27ck62 FIND v(dout2_27) AT=1260.1n

* CHECK dout2_28 Vdout2_28ck62 = 1.8 time = 1260
.meas tran vdout2_28ck62 FIND v(dout2_28) AT=1260.1n

* CHECK dout2_29 Vdout2_29ck62 = 1.8 time = 1260
.meas tran vdout2_29ck62 FIND v(dout2_29) AT=1260.1n

* CHECK dout2_30 Vdout2_30ck62 = 0 time = 1260
.meas tran vdout2_30ck62 FIND v(dout2_30) AT=1260.1n

* CHECK dout2_31 Vdout2_31ck62 = 0 time = 1260
.meas tran vdout2_31ck62 FIND v(dout2_31) AT=1260.1n

* CHECK dout1_0 Vdout1_0ck63 = 0 time = 1280
.meas tran vdout1_0ck63 FIND v(dout1_0) AT=1280.1n

* CHECK dout1_1 Vdout1_1ck63 = 1.8 time = 1280
.meas tran vdout1_1ck63 FIND v(dout1_1) AT=1280.1n

* CHECK dout1_2 Vdout1_2ck63 = 1.8 time = 1280
.meas tran vdout1_2ck63 FIND v(dout1_2) AT=1280.1n

* CHECK dout1_3 Vdout1_3ck63 = 1.8 time = 1280
.meas tran vdout1_3ck63 FIND v(dout1_3) AT=1280.1n

* CHECK dout1_4 Vdout1_4ck63 = 1.8 time = 1280
.meas tran vdout1_4ck63 FIND v(dout1_4) AT=1280.1n

* CHECK dout1_5 Vdout1_5ck63 = 0 time = 1280
.meas tran vdout1_5ck63 FIND v(dout1_5) AT=1280.1n

* CHECK dout1_6 Vdout1_6ck63 = 0 time = 1280
.meas tran vdout1_6ck63 FIND v(dout1_6) AT=1280.1n

* CHECK dout1_7 Vdout1_7ck63 = 0 time = 1280
.meas tran vdout1_7ck63 FIND v(dout1_7) AT=1280.1n

* CHECK dout1_8 Vdout1_8ck63 = 1.8 time = 1280
.meas tran vdout1_8ck63 FIND v(dout1_8) AT=1280.1n

* CHECK dout1_9 Vdout1_9ck63 = 1.8 time = 1280
.meas tran vdout1_9ck63 FIND v(dout1_9) AT=1280.1n

* CHECK dout1_10 Vdout1_10ck63 = 1.8 time = 1280
.meas tran vdout1_10ck63 FIND v(dout1_10) AT=1280.1n

* CHECK dout1_11 Vdout1_11ck63 = 0 time = 1280
.meas tran vdout1_11ck63 FIND v(dout1_11) AT=1280.1n

* CHECK dout1_12 Vdout1_12ck63 = 0 time = 1280
.meas tran vdout1_12ck63 FIND v(dout1_12) AT=1280.1n

* CHECK dout1_13 Vdout1_13ck63 = 1.8 time = 1280
.meas tran vdout1_13ck63 FIND v(dout1_13) AT=1280.1n

* CHECK dout1_14 Vdout1_14ck63 = 0 time = 1280
.meas tran vdout1_14ck63 FIND v(dout1_14) AT=1280.1n

* CHECK dout1_15 Vdout1_15ck63 = 0 time = 1280
.meas tran vdout1_15ck63 FIND v(dout1_15) AT=1280.1n

* CHECK dout1_16 Vdout1_16ck63 = 1.8 time = 1280
.meas tran vdout1_16ck63 FIND v(dout1_16) AT=1280.1n

* CHECK dout1_17 Vdout1_17ck63 = 1.8 time = 1280
.meas tran vdout1_17ck63 FIND v(dout1_17) AT=1280.1n

* CHECK dout1_18 Vdout1_18ck63 = 1.8 time = 1280
.meas tran vdout1_18ck63 FIND v(dout1_18) AT=1280.1n

* CHECK dout1_19 Vdout1_19ck63 = 1.8 time = 1280
.meas tran vdout1_19ck63 FIND v(dout1_19) AT=1280.1n

* CHECK dout1_20 Vdout1_20ck63 = 0 time = 1280
.meas tran vdout1_20ck63 FIND v(dout1_20) AT=1280.1n

* CHECK dout1_21 Vdout1_21ck63 = 1.8 time = 1280
.meas tran vdout1_21ck63 FIND v(dout1_21) AT=1280.1n

* CHECK dout1_22 Vdout1_22ck63 = 0 time = 1280
.meas tran vdout1_22ck63 FIND v(dout1_22) AT=1280.1n

* CHECK dout1_23 Vdout1_23ck63 = 1.8 time = 1280
.meas tran vdout1_23ck63 FIND v(dout1_23) AT=1280.1n

* CHECK dout1_24 Vdout1_24ck63 = 1.8 time = 1280
.meas tran vdout1_24ck63 FIND v(dout1_24) AT=1280.1n

* CHECK dout1_25 Vdout1_25ck63 = 0 time = 1280
.meas tran vdout1_25ck63 FIND v(dout1_25) AT=1280.1n

* CHECK dout1_26 Vdout1_26ck63 = 1.8 time = 1280
.meas tran vdout1_26ck63 FIND v(dout1_26) AT=1280.1n

* CHECK dout1_27 Vdout1_27ck63 = 1.8 time = 1280
.meas tran vdout1_27ck63 FIND v(dout1_27) AT=1280.1n

* CHECK dout1_28 Vdout1_28ck63 = 1.8 time = 1280
.meas tran vdout1_28ck63 FIND v(dout1_28) AT=1280.1n

* CHECK dout1_29 Vdout1_29ck63 = 0 time = 1280
.meas tran vdout1_29ck63 FIND v(dout1_29) AT=1280.1n

* CHECK dout1_30 Vdout1_30ck63 = 0 time = 1280
.meas tran vdout1_30ck63 FIND v(dout1_30) AT=1280.1n

* CHECK dout1_31 Vdout1_31ck63 = 1.8 time = 1280
.meas tran vdout1_31ck63 FIND v(dout1_31) AT=1280.1n

* CHECK dout1_0 Vdout1_0ck64 = 1.8 time = 1300
.meas tran vdout1_0ck64 FIND v(dout1_0) AT=1300.1n

* CHECK dout1_1 Vdout1_1ck64 = 1.8 time = 1300
.meas tran vdout1_1ck64 FIND v(dout1_1) AT=1300.1n

* CHECK dout1_2 Vdout1_2ck64 = 1.8 time = 1300
.meas tran vdout1_2ck64 FIND v(dout1_2) AT=1300.1n

* CHECK dout1_3 Vdout1_3ck64 = 0 time = 1300
.meas tran vdout1_3ck64 FIND v(dout1_3) AT=1300.1n

* CHECK dout1_4 Vdout1_4ck64 = 0 time = 1300
.meas tran vdout1_4ck64 FIND v(dout1_4) AT=1300.1n

* CHECK dout1_5 Vdout1_5ck64 = 1.8 time = 1300
.meas tran vdout1_5ck64 FIND v(dout1_5) AT=1300.1n

* CHECK dout1_6 Vdout1_6ck64 = 0 time = 1300
.meas tran vdout1_6ck64 FIND v(dout1_6) AT=1300.1n

* CHECK dout1_7 Vdout1_7ck64 = 0 time = 1300
.meas tran vdout1_7ck64 FIND v(dout1_7) AT=1300.1n

* CHECK dout1_8 Vdout1_8ck64 = 1.8 time = 1300
.meas tran vdout1_8ck64 FIND v(dout1_8) AT=1300.1n

* CHECK dout1_9 Vdout1_9ck64 = 0 time = 1300
.meas tran vdout1_9ck64 FIND v(dout1_9) AT=1300.1n

* CHECK dout1_10 Vdout1_10ck64 = 0 time = 1300
.meas tran vdout1_10ck64 FIND v(dout1_10) AT=1300.1n

* CHECK dout1_11 Vdout1_11ck64 = 0 time = 1300
.meas tran vdout1_11ck64 FIND v(dout1_11) AT=1300.1n

* CHECK dout1_12 Vdout1_12ck64 = 1.8 time = 1300
.meas tran vdout1_12ck64 FIND v(dout1_12) AT=1300.1n

* CHECK dout1_13 Vdout1_13ck64 = 0 time = 1300
.meas tran vdout1_13ck64 FIND v(dout1_13) AT=1300.1n

* CHECK dout1_14 Vdout1_14ck64 = 0 time = 1300
.meas tran vdout1_14ck64 FIND v(dout1_14) AT=1300.1n

* CHECK dout1_15 Vdout1_15ck64 = 1.8 time = 1300
.meas tran vdout1_15ck64 FIND v(dout1_15) AT=1300.1n

* CHECK dout1_16 Vdout1_16ck64 = 0 time = 1300
.meas tran vdout1_16ck64 FIND v(dout1_16) AT=1300.1n

* CHECK dout1_17 Vdout1_17ck64 = 1.8 time = 1300
.meas tran vdout1_17ck64 FIND v(dout1_17) AT=1300.1n

* CHECK dout1_18 Vdout1_18ck64 = 1.8 time = 1300
.meas tran vdout1_18ck64 FIND v(dout1_18) AT=1300.1n

* CHECK dout1_19 Vdout1_19ck64 = 0 time = 1300
.meas tran vdout1_19ck64 FIND v(dout1_19) AT=1300.1n

* CHECK dout1_20 Vdout1_20ck64 = 1.8 time = 1300
.meas tran vdout1_20ck64 FIND v(dout1_20) AT=1300.1n

* CHECK dout1_21 Vdout1_21ck64 = 0 time = 1300
.meas tran vdout1_21ck64 FIND v(dout1_21) AT=1300.1n

* CHECK dout1_22 Vdout1_22ck64 = 0 time = 1300
.meas tran vdout1_22ck64 FIND v(dout1_22) AT=1300.1n

* CHECK dout1_23 Vdout1_23ck64 = 0 time = 1300
.meas tran vdout1_23ck64 FIND v(dout1_23) AT=1300.1n

* CHECK dout1_24 Vdout1_24ck64 = 0 time = 1300
.meas tran vdout1_24ck64 FIND v(dout1_24) AT=1300.1n

* CHECK dout1_25 Vdout1_25ck64 = 1.8 time = 1300
.meas tran vdout1_25ck64 FIND v(dout1_25) AT=1300.1n

* CHECK dout1_26 Vdout1_26ck64 = 1.8 time = 1300
.meas tran vdout1_26ck64 FIND v(dout1_26) AT=1300.1n

* CHECK dout1_27 Vdout1_27ck64 = 0 time = 1300
.meas tran vdout1_27ck64 FIND v(dout1_27) AT=1300.1n

* CHECK dout1_28 Vdout1_28ck64 = 1.8 time = 1300
.meas tran vdout1_28ck64 FIND v(dout1_28) AT=1300.1n

* CHECK dout1_29 Vdout1_29ck64 = 0 time = 1300
.meas tran vdout1_29ck64 FIND v(dout1_29) AT=1300.1n

* CHECK dout1_30 Vdout1_30ck64 = 1.8 time = 1300
.meas tran vdout1_30ck64 FIND v(dout1_30) AT=1300.1n

* CHECK dout1_31 Vdout1_31ck64 = 1.8 time = 1300
.meas tran vdout1_31ck64 FIND v(dout1_31) AT=1300.1n

* CHECK dout2_0 Vdout2_0ck64 = 1.8 time = 1300
.meas tran vdout2_0ck64 FIND v(dout2_0) AT=1300.1n

* CHECK dout2_1 Vdout2_1ck64 = 0 time = 1300
.meas tran vdout2_1ck64 FIND v(dout2_1) AT=1300.1n

* CHECK dout2_2 Vdout2_2ck64 = 1.8 time = 1300
.meas tran vdout2_2ck64 FIND v(dout2_2) AT=1300.1n

* CHECK dout2_3 Vdout2_3ck64 = 1.8 time = 1300
.meas tran vdout2_3ck64 FIND v(dout2_3) AT=1300.1n

* CHECK dout2_4 Vdout2_4ck64 = 1.8 time = 1300
.meas tran vdout2_4ck64 FIND v(dout2_4) AT=1300.1n

* CHECK dout2_5 Vdout2_5ck64 = 0 time = 1300
.meas tran vdout2_5ck64 FIND v(dout2_5) AT=1300.1n

* CHECK dout2_6 Vdout2_6ck64 = 1.8 time = 1300
.meas tran vdout2_6ck64 FIND v(dout2_6) AT=1300.1n

* CHECK dout2_7 Vdout2_7ck64 = 1.8 time = 1300
.meas tran vdout2_7ck64 FIND v(dout2_7) AT=1300.1n

* CHECK dout2_8 Vdout2_8ck64 = 1.8 time = 1300
.meas tran vdout2_8ck64 FIND v(dout2_8) AT=1300.1n

* CHECK dout2_9 Vdout2_9ck64 = 1.8 time = 1300
.meas tran vdout2_9ck64 FIND v(dout2_9) AT=1300.1n

* CHECK dout2_10 Vdout2_10ck64 = 0 time = 1300
.meas tran vdout2_10ck64 FIND v(dout2_10) AT=1300.1n

* CHECK dout2_11 Vdout2_11ck64 = 1.8 time = 1300
.meas tran vdout2_11ck64 FIND v(dout2_11) AT=1300.1n

* CHECK dout2_12 Vdout2_12ck64 = 0 time = 1300
.meas tran vdout2_12ck64 FIND v(dout2_12) AT=1300.1n

* CHECK dout2_13 Vdout2_13ck64 = 1.8 time = 1300
.meas tran vdout2_13ck64 FIND v(dout2_13) AT=1300.1n

* CHECK dout2_14 Vdout2_14ck64 = 0 time = 1300
.meas tran vdout2_14ck64 FIND v(dout2_14) AT=1300.1n

* CHECK dout2_15 Vdout2_15ck64 = 1.8 time = 1300
.meas tran vdout2_15ck64 FIND v(dout2_15) AT=1300.1n

* CHECK dout2_16 Vdout2_16ck64 = 0 time = 1300
.meas tran vdout2_16ck64 FIND v(dout2_16) AT=1300.1n

* CHECK dout2_17 Vdout2_17ck64 = 0 time = 1300
.meas tran vdout2_17ck64 FIND v(dout2_17) AT=1300.1n

* CHECK dout2_18 Vdout2_18ck64 = 0 time = 1300
.meas tran vdout2_18ck64 FIND v(dout2_18) AT=1300.1n

* CHECK dout2_19 Vdout2_19ck64 = 0 time = 1300
.meas tran vdout2_19ck64 FIND v(dout2_19) AT=1300.1n

* CHECK dout2_20 Vdout2_20ck64 = 0 time = 1300
.meas tran vdout2_20ck64 FIND v(dout2_20) AT=1300.1n

* CHECK dout2_21 Vdout2_21ck64 = 0 time = 1300
.meas tran vdout2_21ck64 FIND v(dout2_21) AT=1300.1n

* CHECK dout2_22 Vdout2_22ck64 = 0 time = 1300
.meas tran vdout2_22ck64 FIND v(dout2_22) AT=1300.1n

* CHECK dout2_23 Vdout2_23ck64 = 0 time = 1300
.meas tran vdout2_23ck64 FIND v(dout2_23) AT=1300.1n

* CHECK dout2_24 Vdout2_24ck64 = 1.8 time = 1300
.meas tran vdout2_24ck64 FIND v(dout2_24) AT=1300.1n

* CHECK dout2_25 Vdout2_25ck64 = 1.8 time = 1300
.meas tran vdout2_25ck64 FIND v(dout2_25) AT=1300.1n

* CHECK dout2_26 Vdout2_26ck64 = 1.8 time = 1300
.meas tran vdout2_26ck64 FIND v(dout2_26) AT=1300.1n

* CHECK dout2_27 Vdout2_27ck64 = 1.8 time = 1300
.meas tran vdout2_27ck64 FIND v(dout2_27) AT=1300.1n

* CHECK dout2_28 Vdout2_28ck64 = 0 time = 1300
.meas tran vdout2_28ck64 FIND v(dout2_28) AT=1300.1n

* CHECK dout2_29 Vdout2_29ck64 = 0 time = 1300
.meas tran vdout2_29ck64 FIND v(dout2_29) AT=1300.1n

* CHECK dout2_30 Vdout2_30ck64 = 1.8 time = 1300
.meas tran vdout2_30ck64 FIND v(dout2_30) AT=1300.1n

* CHECK dout2_31 Vdout2_31ck64 = 1.8 time = 1300
.meas tran vdout2_31ck64 FIND v(dout2_31) AT=1300.1n

* CHECK dout1_0 Vdout1_0ck65 = 1.8 time = 1320
.meas tran vdout1_0ck65 FIND v(dout1_0) AT=1320.1n

* CHECK dout1_1 Vdout1_1ck65 = 0 time = 1320
.meas tran vdout1_1ck65 FIND v(dout1_1) AT=1320.1n

* CHECK dout1_2 Vdout1_2ck65 = 1.8 time = 1320
.meas tran vdout1_2ck65 FIND v(dout1_2) AT=1320.1n

* CHECK dout1_3 Vdout1_3ck65 = 1.8 time = 1320
.meas tran vdout1_3ck65 FIND v(dout1_3) AT=1320.1n

* CHECK dout1_4 Vdout1_4ck65 = 1.8 time = 1320
.meas tran vdout1_4ck65 FIND v(dout1_4) AT=1320.1n

* CHECK dout1_5 Vdout1_5ck65 = 0 time = 1320
.meas tran vdout1_5ck65 FIND v(dout1_5) AT=1320.1n

* CHECK dout1_6 Vdout1_6ck65 = 1.8 time = 1320
.meas tran vdout1_6ck65 FIND v(dout1_6) AT=1320.1n

* CHECK dout1_7 Vdout1_7ck65 = 1.8 time = 1320
.meas tran vdout1_7ck65 FIND v(dout1_7) AT=1320.1n

* CHECK dout1_8 Vdout1_8ck65 = 1.8 time = 1320
.meas tran vdout1_8ck65 FIND v(dout1_8) AT=1320.1n

* CHECK dout1_9 Vdout1_9ck65 = 1.8 time = 1320
.meas tran vdout1_9ck65 FIND v(dout1_9) AT=1320.1n

* CHECK dout1_10 Vdout1_10ck65 = 0 time = 1320
.meas tran vdout1_10ck65 FIND v(dout1_10) AT=1320.1n

* CHECK dout1_11 Vdout1_11ck65 = 1.8 time = 1320
.meas tran vdout1_11ck65 FIND v(dout1_11) AT=1320.1n

* CHECK dout1_12 Vdout1_12ck65 = 0 time = 1320
.meas tran vdout1_12ck65 FIND v(dout1_12) AT=1320.1n

* CHECK dout1_13 Vdout1_13ck65 = 1.8 time = 1320
.meas tran vdout1_13ck65 FIND v(dout1_13) AT=1320.1n

* CHECK dout1_14 Vdout1_14ck65 = 0 time = 1320
.meas tran vdout1_14ck65 FIND v(dout1_14) AT=1320.1n

* CHECK dout1_15 Vdout1_15ck65 = 1.8 time = 1320
.meas tran vdout1_15ck65 FIND v(dout1_15) AT=1320.1n

* CHECK dout1_16 Vdout1_16ck65 = 0 time = 1320
.meas tran vdout1_16ck65 FIND v(dout1_16) AT=1320.1n

* CHECK dout1_17 Vdout1_17ck65 = 0 time = 1320
.meas tran vdout1_17ck65 FIND v(dout1_17) AT=1320.1n

* CHECK dout1_18 Vdout1_18ck65 = 0 time = 1320
.meas tran vdout1_18ck65 FIND v(dout1_18) AT=1320.1n

* CHECK dout1_19 Vdout1_19ck65 = 0 time = 1320
.meas tran vdout1_19ck65 FIND v(dout1_19) AT=1320.1n

* CHECK dout1_20 Vdout1_20ck65 = 0 time = 1320
.meas tran vdout1_20ck65 FIND v(dout1_20) AT=1320.1n

* CHECK dout1_21 Vdout1_21ck65 = 0 time = 1320
.meas tran vdout1_21ck65 FIND v(dout1_21) AT=1320.1n

* CHECK dout1_22 Vdout1_22ck65 = 0 time = 1320
.meas tran vdout1_22ck65 FIND v(dout1_22) AT=1320.1n

* CHECK dout1_23 Vdout1_23ck65 = 0 time = 1320
.meas tran vdout1_23ck65 FIND v(dout1_23) AT=1320.1n

* CHECK dout1_24 Vdout1_24ck65 = 1.8 time = 1320
.meas tran vdout1_24ck65 FIND v(dout1_24) AT=1320.1n

* CHECK dout1_25 Vdout1_25ck65 = 1.8 time = 1320
.meas tran vdout1_25ck65 FIND v(dout1_25) AT=1320.1n

* CHECK dout1_26 Vdout1_26ck65 = 1.8 time = 1320
.meas tran vdout1_26ck65 FIND v(dout1_26) AT=1320.1n

* CHECK dout1_27 Vdout1_27ck65 = 1.8 time = 1320
.meas tran vdout1_27ck65 FIND v(dout1_27) AT=1320.1n

* CHECK dout1_28 Vdout1_28ck65 = 0 time = 1320
.meas tran vdout1_28ck65 FIND v(dout1_28) AT=1320.1n

* CHECK dout1_29 Vdout1_29ck65 = 0 time = 1320
.meas tran vdout1_29ck65 FIND v(dout1_29) AT=1320.1n

* CHECK dout1_30 Vdout1_30ck65 = 1.8 time = 1320
.meas tran vdout1_30ck65 FIND v(dout1_30) AT=1320.1n

* CHECK dout1_31 Vdout1_31ck65 = 1.8 time = 1320
.meas tran vdout1_31ck65 FIND v(dout1_31) AT=1320.1n

* CHECK dout2_0 Vdout2_0ck65 = 1.8 time = 1320
.meas tran vdout2_0ck65 FIND v(dout2_0) AT=1320.1n

* CHECK dout2_1 Vdout2_1ck65 = 1.8 time = 1320
.meas tran vdout2_1ck65 FIND v(dout2_1) AT=1320.1n

* CHECK dout2_2 Vdout2_2ck65 = 1.8 time = 1320
.meas tran vdout2_2ck65 FIND v(dout2_2) AT=1320.1n

* CHECK dout2_3 Vdout2_3ck65 = 0 time = 1320
.meas tran vdout2_3ck65 FIND v(dout2_3) AT=1320.1n

* CHECK dout2_4 Vdout2_4ck65 = 0 time = 1320
.meas tran vdout2_4ck65 FIND v(dout2_4) AT=1320.1n

* CHECK dout2_5 Vdout2_5ck65 = 1.8 time = 1320
.meas tran vdout2_5ck65 FIND v(dout2_5) AT=1320.1n

* CHECK dout2_6 Vdout2_6ck65 = 0 time = 1320
.meas tran vdout2_6ck65 FIND v(dout2_6) AT=1320.1n

* CHECK dout2_7 Vdout2_7ck65 = 0 time = 1320
.meas tran vdout2_7ck65 FIND v(dout2_7) AT=1320.1n

* CHECK dout2_8 Vdout2_8ck65 = 1.8 time = 1320
.meas tran vdout2_8ck65 FIND v(dout2_8) AT=1320.1n

* CHECK dout2_9 Vdout2_9ck65 = 0 time = 1320
.meas tran vdout2_9ck65 FIND v(dout2_9) AT=1320.1n

* CHECK dout2_10 Vdout2_10ck65 = 0 time = 1320
.meas tran vdout2_10ck65 FIND v(dout2_10) AT=1320.1n

* CHECK dout2_11 Vdout2_11ck65 = 0 time = 1320
.meas tran vdout2_11ck65 FIND v(dout2_11) AT=1320.1n

* CHECK dout2_12 Vdout2_12ck65 = 1.8 time = 1320
.meas tran vdout2_12ck65 FIND v(dout2_12) AT=1320.1n

* CHECK dout2_13 Vdout2_13ck65 = 0 time = 1320
.meas tran vdout2_13ck65 FIND v(dout2_13) AT=1320.1n

* CHECK dout2_14 Vdout2_14ck65 = 0 time = 1320
.meas tran vdout2_14ck65 FIND v(dout2_14) AT=1320.1n

* CHECK dout2_15 Vdout2_15ck65 = 1.8 time = 1320
.meas tran vdout2_15ck65 FIND v(dout2_15) AT=1320.1n

* CHECK dout2_16 Vdout2_16ck65 = 0 time = 1320
.meas tran vdout2_16ck65 FIND v(dout2_16) AT=1320.1n

* CHECK dout2_17 Vdout2_17ck65 = 1.8 time = 1320
.meas tran vdout2_17ck65 FIND v(dout2_17) AT=1320.1n

* CHECK dout2_18 Vdout2_18ck65 = 1.8 time = 1320
.meas tran vdout2_18ck65 FIND v(dout2_18) AT=1320.1n

* CHECK dout2_19 Vdout2_19ck65 = 0 time = 1320
.meas tran vdout2_19ck65 FIND v(dout2_19) AT=1320.1n

* CHECK dout2_20 Vdout2_20ck65 = 1.8 time = 1320
.meas tran vdout2_20ck65 FIND v(dout2_20) AT=1320.1n

* CHECK dout2_21 Vdout2_21ck65 = 0 time = 1320
.meas tran vdout2_21ck65 FIND v(dout2_21) AT=1320.1n

* CHECK dout2_22 Vdout2_22ck65 = 0 time = 1320
.meas tran vdout2_22ck65 FIND v(dout2_22) AT=1320.1n

* CHECK dout2_23 Vdout2_23ck65 = 0 time = 1320
.meas tran vdout2_23ck65 FIND v(dout2_23) AT=1320.1n

* CHECK dout2_24 Vdout2_24ck65 = 0 time = 1320
.meas tran vdout2_24ck65 FIND v(dout2_24) AT=1320.1n

* CHECK dout2_25 Vdout2_25ck65 = 1.8 time = 1320
.meas tran vdout2_25ck65 FIND v(dout2_25) AT=1320.1n

* CHECK dout2_26 Vdout2_26ck65 = 1.8 time = 1320
.meas tran vdout2_26ck65 FIND v(dout2_26) AT=1320.1n

* CHECK dout2_27 Vdout2_27ck65 = 0 time = 1320
.meas tran vdout2_27ck65 FIND v(dout2_27) AT=1320.1n

* CHECK dout2_28 Vdout2_28ck65 = 1.8 time = 1320
.meas tran vdout2_28ck65 FIND v(dout2_28) AT=1320.1n

* CHECK dout2_29 Vdout2_29ck65 = 0 time = 1320
.meas tran vdout2_29ck65 FIND v(dout2_29) AT=1320.1n

* CHECK dout2_30 Vdout2_30ck65 = 1.8 time = 1320
.meas tran vdout2_30ck65 FIND v(dout2_30) AT=1320.1n

* CHECK dout2_31 Vdout2_31ck65 = 1.8 time = 1320
.meas tran vdout2_31ck65 FIND v(dout2_31) AT=1320.1n

* CHECK dout1_0 Vdout1_0ck66 = 1.8 time = 1340
.meas tran vdout1_0ck66 FIND v(dout1_0) AT=1340.1n

* CHECK dout1_1 Vdout1_1ck66 = 1.8 time = 1340
.meas tran vdout1_1ck66 FIND v(dout1_1) AT=1340.1n

* CHECK dout1_2 Vdout1_2ck66 = 1.8 time = 1340
.meas tran vdout1_2ck66 FIND v(dout1_2) AT=1340.1n

* CHECK dout1_3 Vdout1_3ck66 = 0 time = 1340
.meas tran vdout1_3ck66 FIND v(dout1_3) AT=1340.1n

* CHECK dout1_4 Vdout1_4ck66 = 0 time = 1340
.meas tran vdout1_4ck66 FIND v(dout1_4) AT=1340.1n

* CHECK dout1_5 Vdout1_5ck66 = 1.8 time = 1340
.meas tran vdout1_5ck66 FIND v(dout1_5) AT=1340.1n

* CHECK dout1_6 Vdout1_6ck66 = 0 time = 1340
.meas tran vdout1_6ck66 FIND v(dout1_6) AT=1340.1n

* CHECK dout1_7 Vdout1_7ck66 = 0 time = 1340
.meas tran vdout1_7ck66 FIND v(dout1_7) AT=1340.1n

* CHECK dout1_8 Vdout1_8ck66 = 1.8 time = 1340
.meas tran vdout1_8ck66 FIND v(dout1_8) AT=1340.1n

* CHECK dout1_9 Vdout1_9ck66 = 0 time = 1340
.meas tran vdout1_9ck66 FIND v(dout1_9) AT=1340.1n

* CHECK dout1_10 Vdout1_10ck66 = 0 time = 1340
.meas tran vdout1_10ck66 FIND v(dout1_10) AT=1340.1n

* CHECK dout1_11 Vdout1_11ck66 = 0 time = 1340
.meas tran vdout1_11ck66 FIND v(dout1_11) AT=1340.1n

* CHECK dout1_12 Vdout1_12ck66 = 1.8 time = 1340
.meas tran vdout1_12ck66 FIND v(dout1_12) AT=1340.1n

* CHECK dout1_13 Vdout1_13ck66 = 0 time = 1340
.meas tran vdout1_13ck66 FIND v(dout1_13) AT=1340.1n

* CHECK dout1_14 Vdout1_14ck66 = 0 time = 1340
.meas tran vdout1_14ck66 FIND v(dout1_14) AT=1340.1n

* CHECK dout1_15 Vdout1_15ck66 = 1.8 time = 1340
.meas tran vdout1_15ck66 FIND v(dout1_15) AT=1340.1n

* CHECK dout1_16 Vdout1_16ck66 = 0 time = 1340
.meas tran vdout1_16ck66 FIND v(dout1_16) AT=1340.1n

* CHECK dout1_17 Vdout1_17ck66 = 1.8 time = 1340
.meas tran vdout1_17ck66 FIND v(dout1_17) AT=1340.1n

* CHECK dout1_18 Vdout1_18ck66 = 1.8 time = 1340
.meas tran vdout1_18ck66 FIND v(dout1_18) AT=1340.1n

* CHECK dout1_19 Vdout1_19ck66 = 0 time = 1340
.meas tran vdout1_19ck66 FIND v(dout1_19) AT=1340.1n

* CHECK dout1_20 Vdout1_20ck66 = 1.8 time = 1340
.meas tran vdout1_20ck66 FIND v(dout1_20) AT=1340.1n

* CHECK dout1_21 Vdout1_21ck66 = 0 time = 1340
.meas tran vdout1_21ck66 FIND v(dout1_21) AT=1340.1n

* CHECK dout1_22 Vdout1_22ck66 = 0 time = 1340
.meas tran vdout1_22ck66 FIND v(dout1_22) AT=1340.1n

* CHECK dout1_23 Vdout1_23ck66 = 0 time = 1340
.meas tran vdout1_23ck66 FIND v(dout1_23) AT=1340.1n

* CHECK dout1_24 Vdout1_24ck66 = 0 time = 1340
.meas tran vdout1_24ck66 FIND v(dout1_24) AT=1340.1n

* CHECK dout1_25 Vdout1_25ck66 = 1.8 time = 1340
.meas tran vdout1_25ck66 FIND v(dout1_25) AT=1340.1n

* CHECK dout1_26 Vdout1_26ck66 = 1.8 time = 1340
.meas tran vdout1_26ck66 FIND v(dout1_26) AT=1340.1n

* CHECK dout1_27 Vdout1_27ck66 = 0 time = 1340
.meas tran vdout1_27ck66 FIND v(dout1_27) AT=1340.1n

* CHECK dout1_28 Vdout1_28ck66 = 1.8 time = 1340
.meas tran vdout1_28ck66 FIND v(dout1_28) AT=1340.1n

* CHECK dout1_29 Vdout1_29ck66 = 0 time = 1340
.meas tran vdout1_29ck66 FIND v(dout1_29) AT=1340.1n

* CHECK dout1_30 Vdout1_30ck66 = 1.8 time = 1340
.meas tran vdout1_30ck66 FIND v(dout1_30) AT=1340.1n

* CHECK dout1_31 Vdout1_31ck66 = 1.8 time = 1340
.meas tran vdout1_31ck66 FIND v(dout1_31) AT=1340.1n

* CHECK dout2_0 Vdout2_0ck66 = 1.8 time = 1340
.meas tran vdout2_0ck66 FIND v(dout2_0) AT=1340.1n

* CHECK dout2_1 Vdout2_1ck66 = 0 time = 1340
.meas tran vdout2_1ck66 FIND v(dout2_1) AT=1340.1n

* CHECK dout2_2 Vdout2_2ck66 = 1.8 time = 1340
.meas tran vdout2_2ck66 FIND v(dout2_2) AT=1340.1n

* CHECK dout2_3 Vdout2_3ck66 = 1.8 time = 1340
.meas tran vdout2_3ck66 FIND v(dout2_3) AT=1340.1n

* CHECK dout2_4 Vdout2_4ck66 = 1.8 time = 1340
.meas tran vdout2_4ck66 FIND v(dout2_4) AT=1340.1n

* CHECK dout2_5 Vdout2_5ck66 = 0 time = 1340
.meas tran vdout2_5ck66 FIND v(dout2_5) AT=1340.1n

* CHECK dout2_6 Vdout2_6ck66 = 1.8 time = 1340
.meas tran vdout2_6ck66 FIND v(dout2_6) AT=1340.1n

* CHECK dout2_7 Vdout2_7ck66 = 1.8 time = 1340
.meas tran vdout2_7ck66 FIND v(dout2_7) AT=1340.1n

* CHECK dout2_8 Vdout2_8ck66 = 1.8 time = 1340
.meas tran vdout2_8ck66 FIND v(dout2_8) AT=1340.1n

* CHECK dout2_9 Vdout2_9ck66 = 1.8 time = 1340
.meas tran vdout2_9ck66 FIND v(dout2_9) AT=1340.1n

* CHECK dout2_10 Vdout2_10ck66 = 0 time = 1340
.meas tran vdout2_10ck66 FIND v(dout2_10) AT=1340.1n

* CHECK dout2_11 Vdout2_11ck66 = 1.8 time = 1340
.meas tran vdout2_11ck66 FIND v(dout2_11) AT=1340.1n

* CHECK dout2_12 Vdout2_12ck66 = 0 time = 1340
.meas tran vdout2_12ck66 FIND v(dout2_12) AT=1340.1n

* CHECK dout2_13 Vdout2_13ck66 = 1.8 time = 1340
.meas tran vdout2_13ck66 FIND v(dout2_13) AT=1340.1n

* CHECK dout2_14 Vdout2_14ck66 = 0 time = 1340
.meas tran vdout2_14ck66 FIND v(dout2_14) AT=1340.1n

* CHECK dout2_15 Vdout2_15ck66 = 1.8 time = 1340
.meas tran vdout2_15ck66 FIND v(dout2_15) AT=1340.1n

* CHECK dout2_16 Vdout2_16ck66 = 0 time = 1340
.meas tran vdout2_16ck66 FIND v(dout2_16) AT=1340.1n

* CHECK dout2_17 Vdout2_17ck66 = 0 time = 1340
.meas tran vdout2_17ck66 FIND v(dout2_17) AT=1340.1n

* CHECK dout2_18 Vdout2_18ck66 = 0 time = 1340
.meas tran vdout2_18ck66 FIND v(dout2_18) AT=1340.1n

* CHECK dout2_19 Vdout2_19ck66 = 0 time = 1340
.meas tran vdout2_19ck66 FIND v(dout2_19) AT=1340.1n

* CHECK dout2_20 Vdout2_20ck66 = 0 time = 1340
.meas tran vdout2_20ck66 FIND v(dout2_20) AT=1340.1n

* CHECK dout2_21 Vdout2_21ck66 = 0 time = 1340
.meas tran vdout2_21ck66 FIND v(dout2_21) AT=1340.1n

* CHECK dout2_22 Vdout2_22ck66 = 0 time = 1340
.meas tran vdout2_22ck66 FIND v(dout2_22) AT=1340.1n

* CHECK dout2_23 Vdout2_23ck66 = 0 time = 1340
.meas tran vdout2_23ck66 FIND v(dout2_23) AT=1340.1n

* CHECK dout2_24 Vdout2_24ck66 = 1.8 time = 1340
.meas tran vdout2_24ck66 FIND v(dout2_24) AT=1340.1n

* CHECK dout2_25 Vdout2_25ck66 = 1.8 time = 1340
.meas tran vdout2_25ck66 FIND v(dout2_25) AT=1340.1n

* CHECK dout2_26 Vdout2_26ck66 = 1.8 time = 1340
.meas tran vdout2_26ck66 FIND v(dout2_26) AT=1340.1n

* CHECK dout2_27 Vdout2_27ck66 = 1.8 time = 1340
.meas tran vdout2_27ck66 FIND v(dout2_27) AT=1340.1n

* CHECK dout2_28 Vdout2_28ck66 = 0 time = 1340
.meas tran vdout2_28ck66 FIND v(dout2_28) AT=1340.1n

* CHECK dout2_29 Vdout2_29ck66 = 0 time = 1340
.meas tran vdout2_29ck66 FIND v(dout2_29) AT=1340.1n

* CHECK dout2_30 Vdout2_30ck66 = 1.8 time = 1340
.meas tran vdout2_30ck66 FIND v(dout2_30) AT=1340.1n

* CHECK dout2_31 Vdout2_31ck66 = 1.8 time = 1340
.meas tran vdout2_31ck66 FIND v(dout2_31) AT=1340.1n

* CHECK dout2_0 Vdout2_0ck67 = 1.8 time = 1360
.meas tran vdout2_0ck67 FIND v(dout2_0) AT=1360.1n

* CHECK dout2_1 Vdout2_1ck67 = 1.8 time = 1360
.meas tran vdout2_1ck67 FIND v(dout2_1) AT=1360.1n

* CHECK dout2_2 Vdout2_2ck67 = 1.8 time = 1360
.meas tran vdout2_2ck67 FIND v(dout2_2) AT=1360.1n

* CHECK dout2_3 Vdout2_3ck67 = 1.8 time = 1360
.meas tran vdout2_3ck67 FIND v(dout2_3) AT=1360.1n

* CHECK dout2_4 Vdout2_4ck67 = 1.8 time = 1360
.meas tran vdout2_4ck67 FIND v(dout2_4) AT=1360.1n

* CHECK dout2_5 Vdout2_5ck67 = 1.8 time = 1360
.meas tran vdout2_5ck67 FIND v(dout2_5) AT=1360.1n

* CHECK dout2_6 Vdout2_6ck67 = 0 time = 1360
.meas tran vdout2_6ck67 FIND v(dout2_6) AT=1360.1n

* CHECK dout2_7 Vdout2_7ck67 = 0 time = 1360
.meas tran vdout2_7ck67 FIND v(dout2_7) AT=1360.1n

* CHECK dout2_8 Vdout2_8ck67 = 0 time = 1360
.meas tran vdout2_8ck67 FIND v(dout2_8) AT=1360.1n

* CHECK dout2_9 Vdout2_9ck67 = 1.8 time = 1360
.meas tran vdout2_9ck67 FIND v(dout2_9) AT=1360.1n

* CHECK dout2_10 Vdout2_10ck67 = 1.8 time = 1360
.meas tran vdout2_10ck67 FIND v(dout2_10) AT=1360.1n

* CHECK dout2_11 Vdout2_11ck67 = 0 time = 1360
.meas tran vdout2_11ck67 FIND v(dout2_11) AT=1360.1n

* CHECK dout2_12 Vdout2_12ck67 = 0 time = 1360
.meas tran vdout2_12ck67 FIND v(dout2_12) AT=1360.1n

* CHECK dout2_13 Vdout2_13ck67 = 1.8 time = 1360
.meas tran vdout2_13ck67 FIND v(dout2_13) AT=1360.1n

* CHECK dout2_14 Vdout2_14ck67 = 0 time = 1360
.meas tran vdout2_14ck67 FIND v(dout2_14) AT=1360.1n

* CHECK dout2_15 Vdout2_15ck67 = 0 time = 1360
.meas tran vdout2_15ck67 FIND v(dout2_15) AT=1360.1n

* CHECK dout2_16 Vdout2_16ck67 = 1.8 time = 1360
.meas tran vdout2_16ck67 FIND v(dout2_16) AT=1360.1n

* CHECK dout2_17 Vdout2_17ck67 = 0 time = 1360
.meas tran vdout2_17ck67 FIND v(dout2_17) AT=1360.1n

* CHECK dout2_18 Vdout2_18ck67 = 1.8 time = 1360
.meas tran vdout2_18ck67 FIND v(dout2_18) AT=1360.1n

* CHECK dout2_19 Vdout2_19ck67 = 1.8 time = 1360
.meas tran vdout2_19ck67 FIND v(dout2_19) AT=1360.1n

* CHECK dout2_20 Vdout2_20ck67 = 1.8 time = 1360
.meas tran vdout2_20ck67 FIND v(dout2_20) AT=1360.1n

* CHECK dout2_21 Vdout2_21ck67 = 1.8 time = 1360
.meas tran vdout2_21ck67 FIND v(dout2_21) AT=1360.1n

* CHECK dout2_22 Vdout2_22ck67 = 1.8 time = 1360
.meas tran vdout2_22ck67 FIND v(dout2_22) AT=1360.1n

* CHECK dout2_23 Vdout2_23ck67 = 1.8 time = 1360
.meas tran vdout2_23ck67 FIND v(dout2_23) AT=1360.1n

* CHECK dout2_24 Vdout2_24ck67 = 0 time = 1360
.meas tran vdout2_24ck67 FIND v(dout2_24) AT=1360.1n

* CHECK dout2_25 Vdout2_25ck67 = 0 time = 1360
.meas tran vdout2_25ck67 FIND v(dout2_25) AT=1360.1n

* CHECK dout2_26 Vdout2_26ck67 = 1.8 time = 1360
.meas tran vdout2_26ck67 FIND v(dout2_26) AT=1360.1n

* CHECK dout2_27 Vdout2_27ck67 = 1.8 time = 1360
.meas tran vdout2_27ck67 FIND v(dout2_27) AT=1360.1n

* CHECK dout2_28 Vdout2_28ck67 = 0 time = 1360
.meas tran vdout2_28ck67 FIND v(dout2_28) AT=1360.1n

* CHECK dout2_29 Vdout2_29ck67 = 0 time = 1360
.meas tran vdout2_29ck67 FIND v(dout2_29) AT=1360.1n

* CHECK dout2_30 Vdout2_30ck67 = 1.8 time = 1360
.meas tran vdout2_30ck67 FIND v(dout2_30) AT=1360.1n

* CHECK dout2_31 Vdout2_31ck67 = 1.8 time = 1360
.meas tran vdout2_31ck67 FIND v(dout2_31) AT=1360.1n

* CHECK dout1_0 Vdout1_0ck68 = 1.8 time = 1380
.meas tran vdout1_0ck68 FIND v(dout1_0) AT=1380.1n

* CHECK dout1_1 Vdout1_1ck68 = 1.8 time = 1380
.meas tran vdout1_1ck68 FIND v(dout1_1) AT=1380.1n

* CHECK dout1_2 Vdout1_2ck68 = 0 time = 1380
.meas tran vdout1_2ck68 FIND v(dout1_2) AT=1380.1n

* CHECK dout1_3 Vdout1_3ck68 = 1.8 time = 1380
.meas tran vdout1_3ck68 FIND v(dout1_3) AT=1380.1n

* CHECK dout1_4 Vdout1_4ck68 = 0 time = 1380
.meas tran vdout1_4ck68 FIND v(dout1_4) AT=1380.1n

* CHECK dout1_5 Vdout1_5ck68 = 0 time = 1380
.meas tran vdout1_5ck68 FIND v(dout1_5) AT=1380.1n

* CHECK dout1_6 Vdout1_6ck68 = 0 time = 1380
.meas tran vdout1_6ck68 FIND v(dout1_6) AT=1380.1n

* CHECK dout1_7 Vdout1_7ck68 = 1.8 time = 1380
.meas tran vdout1_7ck68 FIND v(dout1_7) AT=1380.1n

* CHECK dout1_8 Vdout1_8ck68 = 0 time = 1380
.meas tran vdout1_8ck68 FIND v(dout1_8) AT=1380.1n

* CHECK dout1_9 Vdout1_9ck68 = 1.8 time = 1380
.meas tran vdout1_9ck68 FIND v(dout1_9) AT=1380.1n

* CHECK dout1_10 Vdout1_10ck68 = 1.8 time = 1380
.meas tran vdout1_10ck68 FIND v(dout1_10) AT=1380.1n

* CHECK dout1_11 Vdout1_11ck68 = 1.8 time = 1380
.meas tran vdout1_11ck68 FIND v(dout1_11) AT=1380.1n

* CHECK dout1_12 Vdout1_12ck68 = 0 time = 1380
.meas tran vdout1_12ck68 FIND v(dout1_12) AT=1380.1n

* CHECK dout1_13 Vdout1_13ck68 = 0 time = 1380
.meas tran vdout1_13ck68 FIND v(dout1_13) AT=1380.1n

* CHECK dout1_14 Vdout1_14ck68 = 1.8 time = 1380
.meas tran vdout1_14ck68 FIND v(dout1_14) AT=1380.1n

* CHECK dout1_15 Vdout1_15ck68 = 1.8 time = 1380
.meas tran vdout1_15ck68 FIND v(dout1_15) AT=1380.1n

* CHECK dout1_16 Vdout1_16ck68 = 1.8 time = 1380
.meas tran vdout1_16ck68 FIND v(dout1_16) AT=1380.1n

* CHECK dout1_17 Vdout1_17ck68 = 1.8 time = 1380
.meas tran vdout1_17ck68 FIND v(dout1_17) AT=1380.1n

* CHECK dout1_18 Vdout1_18ck68 = 0 time = 1380
.meas tran vdout1_18ck68 FIND v(dout1_18) AT=1380.1n

* CHECK dout1_19 Vdout1_19ck68 = 0 time = 1380
.meas tran vdout1_19ck68 FIND v(dout1_19) AT=1380.1n

* CHECK dout1_20 Vdout1_20ck68 = 1.8 time = 1380
.meas tran vdout1_20ck68 FIND v(dout1_20) AT=1380.1n

* CHECK dout1_21 Vdout1_21ck68 = 0 time = 1380
.meas tran vdout1_21ck68 FIND v(dout1_21) AT=1380.1n

* CHECK dout1_22 Vdout1_22ck68 = 1.8 time = 1380
.meas tran vdout1_22ck68 FIND v(dout1_22) AT=1380.1n

* CHECK dout1_23 Vdout1_23ck68 = 1.8 time = 1380
.meas tran vdout1_23ck68 FIND v(dout1_23) AT=1380.1n

* CHECK dout1_24 Vdout1_24ck68 = 0 time = 1380
.meas tran vdout1_24ck68 FIND v(dout1_24) AT=1380.1n

* CHECK dout1_25 Vdout1_25ck68 = 0 time = 1380
.meas tran vdout1_25ck68 FIND v(dout1_25) AT=1380.1n

* CHECK dout1_26 Vdout1_26ck68 = 0 time = 1380
.meas tran vdout1_26ck68 FIND v(dout1_26) AT=1380.1n

* CHECK dout1_27 Vdout1_27ck68 = 1.8 time = 1380
.meas tran vdout1_27ck68 FIND v(dout1_27) AT=1380.1n

* CHECK dout1_28 Vdout1_28ck68 = 0 time = 1380
.meas tran vdout1_28ck68 FIND v(dout1_28) AT=1380.1n

* CHECK dout1_29 Vdout1_29ck68 = 0 time = 1380
.meas tran vdout1_29ck68 FIND v(dout1_29) AT=1380.1n

* CHECK dout1_30 Vdout1_30ck68 = 1.8 time = 1380
.meas tran vdout1_30ck68 FIND v(dout1_30) AT=1380.1n

* CHECK dout1_31 Vdout1_31ck68 = 0 time = 1380
.meas tran vdout1_31ck68 FIND v(dout1_31) AT=1380.1n

* CHECK dout1_0 Vdout1_0ck69 = 1.8 time = 1400
.meas tran vdout1_0ck69 FIND v(dout1_0) AT=1400.1n

* CHECK dout1_1 Vdout1_1ck69 = 1.8 time = 1400
.meas tran vdout1_1ck69 FIND v(dout1_1) AT=1400.1n

* CHECK dout1_2 Vdout1_2ck69 = 0 time = 1400
.meas tran vdout1_2ck69 FIND v(dout1_2) AT=1400.1n

* CHECK dout1_3 Vdout1_3ck69 = 1.8 time = 1400
.meas tran vdout1_3ck69 FIND v(dout1_3) AT=1400.1n

* CHECK dout1_4 Vdout1_4ck69 = 0 time = 1400
.meas tran vdout1_4ck69 FIND v(dout1_4) AT=1400.1n

* CHECK dout1_5 Vdout1_5ck69 = 0 time = 1400
.meas tran vdout1_5ck69 FIND v(dout1_5) AT=1400.1n

* CHECK dout1_6 Vdout1_6ck69 = 0 time = 1400
.meas tran vdout1_6ck69 FIND v(dout1_6) AT=1400.1n

* CHECK dout1_7 Vdout1_7ck69 = 1.8 time = 1400
.meas tran vdout1_7ck69 FIND v(dout1_7) AT=1400.1n

* CHECK dout1_8 Vdout1_8ck69 = 0 time = 1400
.meas tran vdout1_8ck69 FIND v(dout1_8) AT=1400.1n

* CHECK dout1_9 Vdout1_9ck69 = 1.8 time = 1400
.meas tran vdout1_9ck69 FIND v(dout1_9) AT=1400.1n

* CHECK dout1_10 Vdout1_10ck69 = 1.8 time = 1400
.meas tran vdout1_10ck69 FIND v(dout1_10) AT=1400.1n

* CHECK dout1_11 Vdout1_11ck69 = 1.8 time = 1400
.meas tran vdout1_11ck69 FIND v(dout1_11) AT=1400.1n

* CHECK dout1_12 Vdout1_12ck69 = 0 time = 1400
.meas tran vdout1_12ck69 FIND v(dout1_12) AT=1400.1n

* CHECK dout1_13 Vdout1_13ck69 = 0 time = 1400
.meas tran vdout1_13ck69 FIND v(dout1_13) AT=1400.1n

* CHECK dout1_14 Vdout1_14ck69 = 1.8 time = 1400
.meas tran vdout1_14ck69 FIND v(dout1_14) AT=1400.1n

* CHECK dout1_15 Vdout1_15ck69 = 1.8 time = 1400
.meas tran vdout1_15ck69 FIND v(dout1_15) AT=1400.1n

* CHECK dout1_16 Vdout1_16ck69 = 1.8 time = 1400
.meas tran vdout1_16ck69 FIND v(dout1_16) AT=1400.1n

* CHECK dout1_17 Vdout1_17ck69 = 1.8 time = 1400
.meas tran vdout1_17ck69 FIND v(dout1_17) AT=1400.1n

* CHECK dout1_18 Vdout1_18ck69 = 0 time = 1400
.meas tran vdout1_18ck69 FIND v(dout1_18) AT=1400.1n

* CHECK dout1_19 Vdout1_19ck69 = 0 time = 1400
.meas tran vdout1_19ck69 FIND v(dout1_19) AT=1400.1n

* CHECK dout1_20 Vdout1_20ck69 = 1.8 time = 1400
.meas tran vdout1_20ck69 FIND v(dout1_20) AT=1400.1n

* CHECK dout1_21 Vdout1_21ck69 = 0 time = 1400
.meas tran vdout1_21ck69 FIND v(dout1_21) AT=1400.1n

* CHECK dout1_22 Vdout1_22ck69 = 1.8 time = 1400
.meas tran vdout1_22ck69 FIND v(dout1_22) AT=1400.1n

* CHECK dout1_23 Vdout1_23ck69 = 1.8 time = 1400
.meas tran vdout1_23ck69 FIND v(dout1_23) AT=1400.1n

* CHECK dout1_24 Vdout1_24ck69 = 0 time = 1400
.meas tran vdout1_24ck69 FIND v(dout1_24) AT=1400.1n

* CHECK dout1_25 Vdout1_25ck69 = 0 time = 1400
.meas tran vdout1_25ck69 FIND v(dout1_25) AT=1400.1n

* CHECK dout1_26 Vdout1_26ck69 = 0 time = 1400
.meas tran vdout1_26ck69 FIND v(dout1_26) AT=1400.1n

* CHECK dout1_27 Vdout1_27ck69 = 1.8 time = 1400
.meas tran vdout1_27ck69 FIND v(dout1_27) AT=1400.1n

* CHECK dout1_28 Vdout1_28ck69 = 0 time = 1400
.meas tran vdout1_28ck69 FIND v(dout1_28) AT=1400.1n

* CHECK dout1_29 Vdout1_29ck69 = 0 time = 1400
.meas tran vdout1_29ck69 FIND v(dout1_29) AT=1400.1n

* CHECK dout1_30 Vdout1_30ck69 = 1.8 time = 1400
.meas tran vdout1_30ck69 FIND v(dout1_30) AT=1400.1n

* CHECK dout1_31 Vdout1_31ck69 = 0 time = 1400
.meas tran vdout1_31ck69 FIND v(dout1_31) AT=1400.1n

* CHECK dout2_0 Vdout2_0ck69 = 1.8 time = 1400
.meas tran vdout2_0ck69 FIND v(dout2_0) AT=1400.1n

* CHECK dout2_1 Vdout2_1ck69 = 0 time = 1400
.meas tran vdout2_1ck69 FIND v(dout2_1) AT=1400.1n

* CHECK dout2_2 Vdout2_2ck69 = 0 time = 1400
.meas tran vdout2_2ck69 FIND v(dout2_2) AT=1400.1n

* CHECK dout2_3 Vdout2_3ck69 = 1.8 time = 1400
.meas tran vdout2_3ck69 FIND v(dout2_3) AT=1400.1n

* CHECK dout2_4 Vdout2_4ck69 = 0 time = 1400
.meas tran vdout2_4ck69 FIND v(dout2_4) AT=1400.1n

* CHECK dout2_5 Vdout2_5ck69 = 0 time = 1400
.meas tran vdout2_5ck69 FIND v(dout2_5) AT=1400.1n

* CHECK dout2_6 Vdout2_6ck69 = 0 time = 1400
.meas tran vdout2_6ck69 FIND v(dout2_6) AT=1400.1n

* CHECK dout2_7 Vdout2_7ck69 = 0 time = 1400
.meas tran vdout2_7ck69 FIND v(dout2_7) AT=1400.1n

* CHECK dout2_8 Vdout2_8ck69 = 1.8 time = 1400
.meas tran vdout2_8ck69 FIND v(dout2_8) AT=1400.1n

* CHECK dout2_9 Vdout2_9ck69 = 0 time = 1400
.meas tran vdout2_9ck69 FIND v(dout2_9) AT=1400.1n

* CHECK dout2_10 Vdout2_10ck69 = 1.8 time = 1400
.meas tran vdout2_10ck69 FIND v(dout2_10) AT=1400.1n

* CHECK dout2_11 Vdout2_11ck69 = 1.8 time = 1400
.meas tran vdout2_11ck69 FIND v(dout2_11) AT=1400.1n

* CHECK dout2_12 Vdout2_12ck69 = 0 time = 1400
.meas tran vdout2_12ck69 FIND v(dout2_12) AT=1400.1n

* CHECK dout2_13 Vdout2_13ck69 = 0 time = 1400
.meas tran vdout2_13ck69 FIND v(dout2_13) AT=1400.1n

* CHECK dout2_14 Vdout2_14ck69 = 1.8 time = 1400
.meas tran vdout2_14ck69 FIND v(dout2_14) AT=1400.1n

* CHECK dout2_15 Vdout2_15ck69 = 1.8 time = 1400
.meas tran vdout2_15ck69 FIND v(dout2_15) AT=1400.1n

* CHECK dout2_16 Vdout2_16ck69 = 0 time = 1400
.meas tran vdout2_16ck69 FIND v(dout2_16) AT=1400.1n

* CHECK dout2_17 Vdout2_17ck69 = 0 time = 1400
.meas tran vdout2_17ck69 FIND v(dout2_17) AT=1400.1n

* CHECK dout2_18 Vdout2_18ck69 = 0 time = 1400
.meas tran vdout2_18ck69 FIND v(dout2_18) AT=1400.1n

* CHECK dout2_19 Vdout2_19ck69 = 1.8 time = 1400
.meas tran vdout2_19ck69 FIND v(dout2_19) AT=1400.1n

* CHECK dout2_20 Vdout2_20ck69 = 1.8 time = 1400
.meas tran vdout2_20ck69 FIND v(dout2_20) AT=1400.1n

* CHECK dout2_21 Vdout2_21ck69 = 0 time = 1400
.meas tran vdout2_21ck69 FIND v(dout2_21) AT=1400.1n

* CHECK dout2_22 Vdout2_22ck69 = 0 time = 1400
.meas tran vdout2_22ck69 FIND v(dout2_22) AT=1400.1n

* CHECK dout2_23 Vdout2_23ck69 = 1.8 time = 1400
.meas tran vdout2_23ck69 FIND v(dout2_23) AT=1400.1n

* CHECK dout2_24 Vdout2_24ck69 = 0 time = 1400
.meas tran vdout2_24ck69 FIND v(dout2_24) AT=1400.1n

* CHECK dout2_25 Vdout2_25ck69 = 0 time = 1400
.meas tran vdout2_25ck69 FIND v(dout2_25) AT=1400.1n

* CHECK dout2_26 Vdout2_26ck69 = 1.8 time = 1400
.meas tran vdout2_26ck69 FIND v(dout2_26) AT=1400.1n

* CHECK dout2_27 Vdout2_27ck69 = 1.8 time = 1400
.meas tran vdout2_27ck69 FIND v(dout2_27) AT=1400.1n

* CHECK dout2_28 Vdout2_28ck69 = 1.8 time = 1400
.meas tran vdout2_28ck69 FIND v(dout2_28) AT=1400.1n

* CHECK dout2_29 Vdout2_29ck69 = 1.8 time = 1400
.meas tran vdout2_29ck69 FIND v(dout2_29) AT=1400.1n

* CHECK dout2_30 Vdout2_30ck69 = 0 time = 1400
.meas tran vdout2_30ck69 FIND v(dout2_30) AT=1400.1n

* CHECK dout2_31 Vdout2_31ck69 = 1.8 time = 1400
.meas tran vdout2_31ck69 FIND v(dout2_31) AT=1400.1n

* CHECK dout2_0 Vdout2_0ck70 = 1.8 time = 1420
.meas tran vdout2_0ck70 FIND v(dout2_0) AT=1420.1n

* CHECK dout2_1 Vdout2_1ck70 = 1.8 time = 1420
.meas tran vdout2_1ck70 FIND v(dout2_1) AT=1420.1n

* CHECK dout2_2 Vdout2_2ck70 = 0 time = 1420
.meas tran vdout2_2ck70 FIND v(dout2_2) AT=1420.1n

* CHECK dout2_3 Vdout2_3ck70 = 1.8 time = 1420
.meas tran vdout2_3ck70 FIND v(dout2_3) AT=1420.1n

* CHECK dout2_4 Vdout2_4ck70 = 0 time = 1420
.meas tran vdout2_4ck70 FIND v(dout2_4) AT=1420.1n

* CHECK dout2_5 Vdout2_5ck70 = 0 time = 1420
.meas tran vdout2_5ck70 FIND v(dout2_5) AT=1420.1n

* CHECK dout2_6 Vdout2_6ck70 = 0 time = 1420
.meas tran vdout2_6ck70 FIND v(dout2_6) AT=1420.1n

* CHECK dout2_7 Vdout2_7ck70 = 1.8 time = 1420
.meas tran vdout2_7ck70 FIND v(dout2_7) AT=1420.1n

* CHECK dout2_8 Vdout2_8ck70 = 0 time = 1420
.meas tran vdout2_8ck70 FIND v(dout2_8) AT=1420.1n

* CHECK dout2_9 Vdout2_9ck70 = 1.8 time = 1420
.meas tran vdout2_9ck70 FIND v(dout2_9) AT=1420.1n

* CHECK dout2_10 Vdout2_10ck70 = 1.8 time = 1420
.meas tran vdout2_10ck70 FIND v(dout2_10) AT=1420.1n

* CHECK dout2_11 Vdout2_11ck70 = 1.8 time = 1420
.meas tran vdout2_11ck70 FIND v(dout2_11) AT=1420.1n

* CHECK dout2_12 Vdout2_12ck70 = 0 time = 1420
.meas tran vdout2_12ck70 FIND v(dout2_12) AT=1420.1n

* CHECK dout2_13 Vdout2_13ck70 = 0 time = 1420
.meas tran vdout2_13ck70 FIND v(dout2_13) AT=1420.1n

* CHECK dout2_14 Vdout2_14ck70 = 1.8 time = 1420
.meas tran vdout2_14ck70 FIND v(dout2_14) AT=1420.1n

* CHECK dout2_15 Vdout2_15ck70 = 1.8 time = 1420
.meas tran vdout2_15ck70 FIND v(dout2_15) AT=1420.1n

* CHECK dout2_16 Vdout2_16ck70 = 1.8 time = 1420
.meas tran vdout2_16ck70 FIND v(dout2_16) AT=1420.1n

* CHECK dout2_17 Vdout2_17ck70 = 1.8 time = 1420
.meas tran vdout2_17ck70 FIND v(dout2_17) AT=1420.1n

* CHECK dout2_18 Vdout2_18ck70 = 0 time = 1420
.meas tran vdout2_18ck70 FIND v(dout2_18) AT=1420.1n

* CHECK dout2_19 Vdout2_19ck70 = 0 time = 1420
.meas tran vdout2_19ck70 FIND v(dout2_19) AT=1420.1n

* CHECK dout2_20 Vdout2_20ck70 = 1.8 time = 1420
.meas tran vdout2_20ck70 FIND v(dout2_20) AT=1420.1n

* CHECK dout2_21 Vdout2_21ck70 = 0 time = 1420
.meas tran vdout2_21ck70 FIND v(dout2_21) AT=1420.1n

* CHECK dout2_22 Vdout2_22ck70 = 1.8 time = 1420
.meas tran vdout2_22ck70 FIND v(dout2_22) AT=1420.1n

* CHECK dout2_23 Vdout2_23ck70 = 1.8 time = 1420
.meas tran vdout2_23ck70 FIND v(dout2_23) AT=1420.1n

* CHECK dout2_24 Vdout2_24ck70 = 0 time = 1420
.meas tran vdout2_24ck70 FIND v(dout2_24) AT=1420.1n

* CHECK dout2_25 Vdout2_25ck70 = 0 time = 1420
.meas tran vdout2_25ck70 FIND v(dout2_25) AT=1420.1n

* CHECK dout2_26 Vdout2_26ck70 = 0 time = 1420
.meas tran vdout2_26ck70 FIND v(dout2_26) AT=1420.1n

* CHECK dout2_27 Vdout2_27ck70 = 1.8 time = 1420
.meas tran vdout2_27ck70 FIND v(dout2_27) AT=1420.1n

* CHECK dout2_28 Vdout2_28ck70 = 0 time = 1420
.meas tran vdout2_28ck70 FIND v(dout2_28) AT=1420.1n

* CHECK dout2_29 Vdout2_29ck70 = 0 time = 1420
.meas tran vdout2_29ck70 FIND v(dout2_29) AT=1420.1n

* CHECK dout2_30 Vdout2_30ck70 = 1.8 time = 1420
.meas tran vdout2_30ck70 FIND v(dout2_30) AT=1420.1n

* CHECK dout2_31 Vdout2_31ck70 = 0 time = 1420
.meas tran vdout2_31ck70 FIND v(dout2_31) AT=1420.1n

* CHECK dout1_0 Vdout1_0ck71 = 1.8 time = 1440
.meas tran vdout1_0ck71 FIND v(dout1_0) AT=1440.1n

* CHECK dout1_1 Vdout1_1ck71 = 0 time = 1440
.meas tran vdout1_1ck71 FIND v(dout1_1) AT=1440.1n

* CHECK dout1_2 Vdout1_2ck71 = 1.8 time = 1440
.meas tran vdout1_2ck71 FIND v(dout1_2) AT=1440.1n

* CHECK dout1_3 Vdout1_3ck71 = 1.8 time = 1440
.meas tran vdout1_3ck71 FIND v(dout1_3) AT=1440.1n

* CHECK dout1_4 Vdout1_4ck71 = 1.8 time = 1440
.meas tran vdout1_4ck71 FIND v(dout1_4) AT=1440.1n

* CHECK dout1_5 Vdout1_5ck71 = 0 time = 1440
.meas tran vdout1_5ck71 FIND v(dout1_5) AT=1440.1n

* CHECK dout1_6 Vdout1_6ck71 = 1.8 time = 1440
.meas tran vdout1_6ck71 FIND v(dout1_6) AT=1440.1n

* CHECK dout1_7 Vdout1_7ck71 = 1.8 time = 1440
.meas tran vdout1_7ck71 FIND v(dout1_7) AT=1440.1n

* CHECK dout1_8 Vdout1_8ck71 = 1.8 time = 1440
.meas tran vdout1_8ck71 FIND v(dout1_8) AT=1440.1n

* CHECK dout1_9 Vdout1_9ck71 = 1.8 time = 1440
.meas tran vdout1_9ck71 FIND v(dout1_9) AT=1440.1n

* CHECK dout1_10 Vdout1_10ck71 = 0 time = 1440
.meas tran vdout1_10ck71 FIND v(dout1_10) AT=1440.1n

* CHECK dout1_11 Vdout1_11ck71 = 1.8 time = 1440
.meas tran vdout1_11ck71 FIND v(dout1_11) AT=1440.1n

* CHECK dout1_12 Vdout1_12ck71 = 0 time = 1440
.meas tran vdout1_12ck71 FIND v(dout1_12) AT=1440.1n

* CHECK dout1_13 Vdout1_13ck71 = 1.8 time = 1440
.meas tran vdout1_13ck71 FIND v(dout1_13) AT=1440.1n

* CHECK dout1_14 Vdout1_14ck71 = 0 time = 1440
.meas tran vdout1_14ck71 FIND v(dout1_14) AT=1440.1n

* CHECK dout1_15 Vdout1_15ck71 = 1.8 time = 1440
.meas tran vdout1_15ck71 FIND v(dout1_15) AT=1440.1n

* CHECK dout1_16 Vdout1_16ck71 = 0 time = 1440
.meas tran vdout1_16ck71 FIND v(dout1_16) AT=1440.1n

* CHECK dout1_17 Vdout1_17ck71 = 0 time = 1440
.meas tran vdout1_17ck71 FIND v(dout1_17) AT=1440.1n

* CHECK dout1_18 Vdout1_18ck71 = 0 time = 1440
.meas tran vdout1_18ck71 FIND v(dout1_18) AT=1440.1n

* CHECK dout1_19 Vdout1_19ck71 = 0 time = 1440
.meas tran vdout1_19ck71 FIND v(dout1_19) AT=1440.1n

* CHECK dout1_20 Vdout1_20ck71 = 0 time = 1440
.meas tran vdout1_20ck71 FIND v(dout1_20) AT=1440.1n

* CHECK dout1_21 Vdout1_21ck71 = 0 time = 1440
.meas tran vdout1_21ck71 FIND v(dout1_21) AT=1440.1n

* CHECK dout1_22 Vdout1_22ck71 = 0 time = 1440
.meas tran vdout1_22ck71 FIND v(dout1_22) AT=1440.1n

* CHECK dout1_23 Vdout1_23ck71 = 0 time = 1440
.meas tran vdout1_23ck71 FIND v(dout1_23) AT=1440.1n

* CHECK dout1_24 Vdout1_24ck71 = 1.8 time = 1440
.meas tran vdout1_24ck71 FIND v(dout1_24) AT=1440.1n

* CHECK dout1_25 Vdout1_25ck71 = 1.8 time = 1440
.meas tran vdout1_25ck71 FIND v(dout1_25) AT=1440.1n

* CHECK dout1_26 Vdout1_26ck71 = 1.8 time = 1440
.meas tran vdout1_26ck71 FIND v(dout1_26) AT=1440.1n

* CHECK dout1_27 Vdout1_27ck71 = 1.8 time = 1440
.meas tran vdout1_27ck71 FIND v(dout1_27) AT=1440.1n

* CHECK dout1_28 Vdout1_28ck71 = 0 time = 1440
.meas tran vdout1_28ck71 FIND v(dout1_28) AT=1440.1n

* CHECK dout1_29 Vdout1_29ck71 = 0 time = 1440
.meas tran vdout1_29ck71 FIND v(dout1_29) AT=1440.1n

* CHECK dout1_30 Vdout1_30ck71 = 1.8 time = 1440
.meas tran vdout1_30ck71 FIND v(dout1_30) AT=1440.1n

* CHECK dout1_31 Vdout1_31ck71 = 1.8 time = 1440
.meas tran vdout1_31ck71 FIND v(dout1_31) AT=1440.1n

* CHECK dout2_0 Vdout2_0ck71 = 1.8 time = 1440
.meas tran vdout2_0ck71 FIND v(dout2_0) AT=1440.1n

* CHECK dout2_1 Vdout2_1ck71 = 0 time = 1440
.meas tran vdout2_1ck71 FIND v(dout2_1) AT=1440.1n

* CHECK dout2_2 Vdout2_2ck71 = 0 time = 1440
.meas tran vdout2_2ck71 FIND v(dout2_2) AT=1440.1n

* CHECK dout2_3 Vdout2_3ck71 = 1.8 time = 1440
.meas tran vdout2_3ck71 FIND v(dout2_3) AT=1440.1n

* CHECK dout2_4 Vdout2_4ck71 = 0 time = 1440
.meas tran vdout2_4ck71 FIND v(dout2_4) AT=1440.1n

* CHECK dout2_5 Vdout2_5ck71 = 0 time = 1440
.meas tran vdout2_5ck71 FIND v(dout2_5) AT=1440.1n

* CHECK dout2_6 Vdout2_6ck71 = 0 time = 1440
.meas tran vdout2_6ck71 FIND v(dout2_6) AT=1440.1n

* CHECK dout2_7 Vdout2_7ck71 = 0 time = 1440
.meas tran vdout2_7ck71 FIND v(dout2_7) AT=1440.1n

* CHECK dout2_8 Vdout2_8ck71 = 1.8 time = 1440
.meas tran vdout2_8ck71 FIND v(dout2_8) AT=1440.1n

* CHECK dout2_9 Vdout2_9ck71 = 0 time = 1440
.meas tran vdout2_9ck71 FIND v(dout2_9) AT=1440.1n

* CHECK dout2_10 Vdout2_10ck71 = 1.8 time = 1440
.meas tran vdout2_10ck71 FIND v(dout2_10) AT=1440.1n

* CHECK dout2_11 Vdout2_11ck71 = 1.8 time = 1440
.meas tran vdout2_11ck71 FIND v(dout2_11) AT=1440.1n

* CHECK dout2_12 Vdout2_12ck71 = 0 time = 1440
.meas tran vdout2_12ck71 FIND v(dout2_12) AT=1440.1n

* CHECK dout2_13 Vdout2_13ck71 = 0 time = 1440
.meas tran vdout2_13ck71 FIND v(dout2_13) AT=1440.1n

* CHECK dout2_14 Vdout2_14ck71 = 1.8 time = 1440
.meas tran vdout2_14ck71 FIND v(dout2_14) AT=1440.1n

* CHECK dout2_15 Vdout2_15ck71 = 1.8 time = 1440
.meas tran vdout2_15ck71 FIND v(dout2_15) AT=1440.1n

* CHECK dout2_16 Vdout2_16ck71 = 0 time = 1440
.meas tran vdout2_16ck71 FIND v(dout2_16) AT=1440.1n

* CHECK dout2_17 Vdout2_17ck71 = 0 time = 1440
.meas tran vdout2_17ck71 FIND v(dout2_17) AT=1440.1n

* CHECK dout2_18 Vdout2_18ck71 = 0 time = 1440
.meas tran vdout2_18ck71 FIND v(dout2_18) AT=1440.1n

* CHECK dout2_19 Vdout2_19ck71 = 1.8 time = 1440
.meas tran vdout2_19ck71 FIND v(dout2_19) AT=1440.1n

* CHECK dout2_20 Vdout2_20ck71 = 1.8 time = 1440
.meas tran vdout2_20ck71 FIND v(dout2_20) AT=1440.1n

* CHECK dout2_21 Vdout2_21ck71 = 0 time = 1440
.meas tran vdout2_21ck71 FIND v(dout2_21) AT=1440.1n

* CHECK dout2_22 Vdout2_22ck71 = 0 time = 1440
.meas tran vdout2_22ck71 FIND v(dout2_22) AT=1440.1n

* CHECK dout2_23 Vdout2_23ck71 = 1.8 time = 1440
.meas tran vdout2_23ck71 FIND v(dout2_23) AT=1440.1n

* CHECK dout2_24 Vdout2_24ck71 = 0 time = 1440
.meas tran vdout2_24ck71 FIND v(dout2_24) AT=1440.1n

* CHECK dout2_25 Vdout2_25ck71 = 0 time = 1440
.meas tran vdout2_25ck71 FIND v(dout2_25) AT=1440.1n

* CHECK dout2_26 Vdout2_26ck71 = 1.8 time = 1440
.meas tran vdout2_26ck71 FIND v(dout2_26) AT=1440.1n

* CHECK dout2_27 Vdout2_27ck71 = 1.8 time = 1440
.meas tran vdout2_27ck71 FIND v(dout2_27) AT=1440.1n

* CHECK dout2_28 Vdout2_28ck71 = 1.8 time = 1440
.meas tran vdout2_28ck71 FIND v(dout2_28) AT=1440.1n

* CHECK dout2_29 Vdout2_29ck71 = 1.8 time = 1440
.meas tran vdout2_29ck71 FIND v(dout2_29) AT=1440.1n

* CHECK dout2_30 Vdout2_30ck71 = 0 time = 1440
.meas tran vdout2_30ck71 FIND v(dout2_30) AT=1440.1n

* CHECK dout2_31 Vdout2_31ck71 = 1.8 time = 1440
.meas tran vdout2_31ck71 FIND v(dout2_31) AT=1440.1n

* CHECK dout1_0 Vdout1_0ck72 = 1.8 time = 1460
.meas tran vdout1_0ck72 FIND v(dout1_0) AT=1460.1n

* CHECK dout1_1 Vdout1_1ck72 = 0 time = 1460
.meas tran vdout1_1ck72 FIND v(dout1_1) AT=1460.1n

* CHECK dout1_2 Vdout1_2ck72 = 1.8 time = 1460
.meas tran vdout1_2ck72 FIND v(dout1_2) AT=1460.1n

* CHECK dout1_3 Vdout1_3ck72 = 1.8 time = 1460
.meas tran vdout1_3ck72 FIND v(dout1_3) AT=1460.1n

* CHECK dout1_4 Vdout1_4ck72 = 1.8 time = 1460
.meas tran vdout1_4ck72 FIND v(dout1_4) AT=1460.1n

* CHECK dout1_5 Vdout1_5ck72 = 0 time = 1460
.meas tran vdout1_5ck72 FIND v(dout1_5) AT=1460.1n

* CHECK dout1_6 Vdout1_6ck72 = 1.8 time = 1460
.meas tran vdout1_6ck72 FIND v(dout1_6) AT=1460.1n

* CHECK dout1_7 Vdout1_7ck72 = 1.8 time = 1460
.meas tran vdout1_7ck72 FIND v(dout1_7) AT=1460.1n

* CHECK dout1_8 Vdout1_8ck72 = 1.8 time = 1460
.meas tran vdout1_8ck72 FIND v(dout1_8) AT=1460.1n

* CHECK dout1_9 Vdout1_9ck72 = 1.8 time = 1460
.meas tran vdout1_9ck72 FIND v(dout1_9) AT=1460.1n

* CHECK dout1_10 Vdout1_10ck72 = 0 time = 1460
.meas tran vdout1_10ck72 FIND v(dout1_10) AT=1460.1n

* CHECK dout1_11 Vdout1_11ck72 = 1.8 time = 1460
.meas tran vdout1_11ck72 FIND v(dout1_11) AT=1460.1n

* CHECK dout1_12 Vdout1_12ck72 = 0 time = 1460
.meas tran vdout1_12ck72 FIND v(dout1_12) AT=1460.1n

* CHECK dout1_13 Vdout1_13ck72 = 1.8 time = 1460
.meas tran vdout1_13ck72 FIND v(dout1_13) AT=1460.1n

* CHECK dout1_14 Vdout1_14ck72 = 0 time = 1460
.meas tran vdout1_14ck72 FIND v(dout1_14) AT=1460.1n

* CHECK dout1_15 Vdout1_15ck72 = 1.8 time = 1460
.meas tran vdout1_15ck72 FIND v(dout1_15) AT=1460.1n

* CHECK dout1_16 Vdout1_16ck72 = 0 time = 1460
.meas tran vdout1_16ck72 FIND v(dout1_16) AT=1460.1n

* CHECK dout1_17 Vdout1_17ck72 = 0 time = 1460
.meas tran vdout1_17ck72 FIND v(dout1_17) AT=1460.1n

* CHECK dout1_18 Vdout1_18ck72 = 0 time = 1460
.meas tran vdout1_18ck72 FIND v(dout1_18) AT=1460.1n

* CHECK dout1_19 Vdout1_19ck72 = 0 time = 1460
.meas tran vdout1_19ck72 FIND v(dout1_19) AT=1460.1n

* CHECK dout1_20 Vdout1_20ck72 = 0 time = 1460
.meas tran vdout1_20ck72 FIND v(dout1_20) AT=1460.1n

* CHECK dout1_21 Vdout1_21ck72 = 0 time = 1460
.meas tran vdout1_21ck72 FIND v(dout1_21) AT=1460.1n

* CHECK dout1_22 Vdout1_22ck72 = 0 time = 1460
.meas tran vdout1_22ck72 FIND v(dout1_22) AT=1460.1n

* CHECK dout1_23 Vdout1_23ck72 = 0 time = 1460
.meas tran vdout1_23ck72 FIND v(dout1_23) AT=1460.1n

* CHECK dout1_24 Vdout1_24ck72 = 1.8 time = 1460
.meas tran vdout1_24ck72 FIND v(dout1_24) AT=1460.1n

* CHECK dout1_25 Vdout1_25ck72 = 1.8 time = 1460
.meas tran vdout1_25ck72 FIND v(dout1_25) AT=1460.1n

* CHECK dout1_26 Vdout1_26ck72 = 1.8 time = 1460
.meas tran vdout1_26ck72 FIND v(dout1_26) AT=1460.1n

* CHECK dout1_27 Vdout1_27ck72 = 1.8 time = 1460
.meas tran vdout1_27ck72 FIND v(dout1_27) AT=1460.1n

* CHECK dout1_28 Vdout1_28ck72 = 0 time = 1460
.meas tran vdout1_28ck72 FIND v(dout1_28) AT=1460.1n

* CHECK dout1_29 Vdout1_29ck72 = 0 time = 1460
.meas tran vdout1_29ck72 FIND v(dout1_29) AT=1460.1n

* CHECK dout1_30 Vdout1_30ck72 = 1.8 time = 1460
.meas tran vdout1_30ck72 FIND v(dout1_30) AT=1460.1n

* CHECK dout1_31 Vdout1_31ck72 = 1.8 time = 1460
.meas tran vdout1_31ck72 FIND v(dout1_31) AT=1460.1n

* CHECK dout1_0 Vdout1_0ck73 = 1.8 time = 1480
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=1480.1n

* CHECK dout1_1 Vdout1_1ck73 = 0 time = 1480
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=1480.1n

* CHECK dout1_2 Vdout1_2ck73 = 1.8 time = 1480
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=1480.1n

* CHECK dout1_3 Vdout1_3ck73 = 0 time = 1480
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=1480.1n

* CHECK dout1_4 Vdout1_4ck73 = 1.8 time = 1480
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=1480.1n

* CHECK dout1_5 Vdout1_5ck73 = 1.8 time = 1480
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=1480.1n

* CHECK dout1_6 Vdout1_6ck73 = 1.8 time = 1480
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=1480.1n

* CHECK dout1_7 Vdout1_7ck73 = 1.8 time = 1480
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=1480.1n

* CHECK dout1_8 Vdout1_8ck73 = 0 time = 1480
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=1480.1n

* CHECK dout1_9 Vdout1_9ck73 = 0 time = 1480
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=1480.1n

* CHECK dout1_10 Vdout1_10ck73 = 0 time = 1480
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=1480.1n

* CHECK dout1_11 Vdout1_11ck73 = 1.8 time = 1480
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=1480.1n

* CHECK dout1_12 Vdout1_12ck73 = 1.8 time = 1480
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=1480.1n

* CHECK dout1_13 Vdout1_13ck73 = 0 time = 1480
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=1480.1n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 1480
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=1480.1n

* CHECK dout1_15 Vdout1_15ck73 = 0 time = 1480
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=1480.1n

* CHECK dout1_16 Vdout1_16ck73 = 0 time = 1480
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=1480.1n

* CHECK dout1_17 Vdout1_17ck73 = 0 time = 1480
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=1480.1n

* CHECK dout1_18 Vdout1_18ck73 = 1.8 time = 1480
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=1480.1n

* CHECK dout1_19 Vdout1_19ck73 = 0 time = 1480
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=1480.1n

* CHECK dout1_20 Vdout1_20ck73 = 1.8 time = 1480
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=1480.1n

* CHECK dout1_21 Vdout1_21ck73 = 0 time = 1480
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=1480.1n

* CHECK dout1_22 Vdout1_22ck73 = 0 time = 1480
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=1480.1n

* CHECK dout1_23 Vdout1_23ck73 = 0 time = 1480
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=1480.1n

* CHECK dout1_24 Vdout1_24ck73 = 0 time = 1480
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=1480.1n

* CHECK dout1_25 Vdout1_25ck73 = 1.8 time = 1480
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=1480.1n

* CHECK dout1_26 Vdout1_26ck73 = 1.8 time = 1480
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=1480.1n

* CHECK dout1_27 Vdout1_27ck73 = 1.8 time = 1480
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=1480.1n

* CHECK dout1_28 Vdout1_28ck73 = 1.8 time = 1480
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=1480.1n

* CHECK dout1_29 Vdout1_29ck73 = 0 time = 1480
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=1480.1n

* CHECK dout1_30 Vdout1_30ck73 = 1.8 time = 1480
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=1480.1n

* CHECK dout1_31 Vdout1_31ck73 = 0 time = 1480
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=1480.1n

* CHECK dout2_0 Vdout2_0ck73 = 1.8 time = 1480
.meas tran vdout2_0ck73 FIND v(dout2_0) AT=1480.1n

* CHECK dout2_1 Vdout2_1ck73 = 0 time = 1480
.meas tran vdout2_1ck73 FIND v(dout2_1) AT=1480.1n

* CHECK dout2_2 Vdout2_2ck73 = 1.8 time = 1480
.meas tran vdout2_2ck73 FIND v(dout2_2) AT=1480.1n

* CHECK dout2_3 Vdout2_3ck73 = 0 time = 1480
.meas tran vdout2_3ck73 FIND v(dout2_3) AT=1480.1n

* CHECK dout2_4 Vdout2_4ck73 = 1.8 time = 1480
.meas tran vdout2_4ck73 FIND v(dout2_4) AT=1480.1n

* CHECK dout2_5 Vdout2_5ck73 = 1.8 time = 1480
.meas tran vdout2_5ck73 FIND v(dout2_5) AT=1480.1n

* CHECK dout2_6 Vdout2_6ck73 = 1.8 time = 1480
.meas tran vdout2_6ck73 FIND v(dout2_6) AT=1480.1n

* CHECK dout2_7 Vdout2_7ck73 = 1.8 time = 1480
.meas tran vdout2_7ck73 FIND v(dout2_7) AT=1480.1n

* CHECK dout2_8 Vdout2_8ck73 = 0 time = 1480
.meas tran vdout2_8ck73 FIND v(dout2_8) AT=1480.1n

* CHECK dout2_9 Vdout2_9ck73 = 0 time = 1480
.meas tran vdout2_9ck73 FIND v(dout2_9) AT=1480.1n

* CHECK dout2_10 Vdout2_10ck73 = 0 time = 1480
.meas tran vdout2_10ck73 FIND v(dout2_10) AT=1480.1n

* CHECK dout2_11 Vdout2_11ck73 = 1.8 time = 1480
.meas tran vdout2_11ck73 FIND v(dout2_11) AT=1480.1n

* CHECK dout2_12 Vdout2_12ck73 = 1.8 time = 1480
.meas tran vdout2_12ck73 FIND v(dout2_12) AT=1480.1n

* CHECK dout2_13 Vdout2_13ck73 = 0 time = 1480
.meas tran vdout2_13ck73 FIND v(dout2_13) AT=1480.1n

* CHECK dout2_14 Vdout2_14ck73 = 0 time = 1480
.meas tran vdout2_14ck73 FIND v(dout2_14) AT=1480.1n

* CHECK dout2_15 Vdout2_15ck73 = 0 time = 1480
.meas tran vdout2_15ck73 FIND v(dout2_15) AT=1480.1n

* CHECK dout2_16 Vdout2_16ck73 = 0 time = 1480
.meas tran vdout2_16ck73 FIND v(dout2_16) AT=1480.1n

* CHECK dout2_17 Vdout2_17ck73 = 0 time = 1480
.meas tran vdout2_17ck73 FIND v(dout2_17) AT=1480.1n

* CHECK dout2_18 Vdout2_18ck73 = 1.8 time = 1480
.meas tran vdout2_18ck73 FIND v(dout2_18) AT=1480.1n

* CHECK dout2_19 Vdout2_19ck73 = 0 time = 1480
.meas tran vdout2_19ck73 FIND v(dout2_19) AT=1480.1n

* CHECK dout2_20 Vdout2_20ck73 = 1.8 time = 1480
.meas tran vdout2_20ck73 FIND v(dout2_20) AT=1480.1n

* CHECK dout2_21 Vdout2_21ck73 = 0 time = 1480
.meas tran vdout2_21ck73 FIND v(dout2_21) AT=1480.1n

* CHECK dout2_22 Vdout2_22ck73 = 0 time = 1480
.meas tran vdout2_22ck73 FIND v(dout2_22) AT=1480.1n

* CHECK dout2_23 Vdout2_23ck73 = 0 time = 1480
.meas tran vdout2_23ck73 FIND v(dout2_23) AT=1480.1n

* CHECK dout2_24 Vdout2_24ck73 = 0 time = 1480
.meas tran vdout2_24ck73 FIND v(dout2_24) AT=1480.1n

* CHECK dout2_25 Vdout2_25ck73 = 1.8 time = 1480
.meas tran vdout2_25ck73 FIND v(dout2_25) AT=1480.1n

* CHECK dout2_26 Vdout2_26ck73 = 1.8 time = 1480
.meas tran vdout2_26ck73 FIND v(dout2_26) AT=1480.1n

* CHECK dout2_27 Vdout2_27ck73 = 1.8 time = 1480
.meas tran vdout2_27ck73 FIND v(dout2_27) AT=1480.1n

* CHECK dout2_28 Vdout2_28ck73 = 1.8 time = 1480
.meas tran vdout2_28ck73 FIND v(dout2_28) AT=1480.1n

* CHECK dout2_29 Vdout2_29ck73 = 0 time = 1480
.meas tran vdout2_29ck73 FIND v(dout2_29) AT=1480.1n

* CHECK dout2_30 Vdout2_30ck73 = 1.8 time = 1480
.meas tran vdout2_30ck73 FIND v(dout2_30) AT=1480.1n

* CHECK dout2_31 Vdout2_31ck73 = 0 time = 1480
.meas tran vdout2_31ck73 FIND v(dout2_31) AT=1480.1n

* CHECK dout1_0 Vdout1_0ck74 = 1.8 time = 1500
.meas tran vdout1_0ck74 FIND v(dout1_0) AT=1500.1n

* CHECK dout1_1 Vdout1_1ck74 = 0 time = 1500
.meas tran vdout1_1ck74 FIND v(dout1_1) AT=1500.1n

* CHECK dout1_2 Vdout1_2ck74 = 0 time = 1500
.meas tran vdout1_2ck74 FIND v(dout1_2) AT=1500.1n

* CHECK dout1_3 Vdout1_3ck74 = 1.8 time = 1500
.meas tran vdout1_3ck74 FIND v(dout1_3) AT=1500.1n

* CHECK dout1_4 Vdout1_4ck74 = 0 time = 1500
.meas tran vdout1_4ck74 FIND v(dout1_4) AT=1500.1n

* CHECK dout1_5 Vdout1_5ck74 = 0 time = 1500
.meas tran vdout1_5ck74 FIND v(dout1_5) AT=1500.1n

* CHECK dout1_6 Vdout1_6ck74 = 0 time = 1500
.meas tran vdout1_6ck74 FIND v(dout1_6) AT=1500.1n

* CHECK dout1_7 Vdout1_7ck74 = 0 time = 1500
.meas tran vdout1_7ck74 FIND v(dout1_7) AT=1500.1n

* CHECK dout1_8 Vdout1_8ck74 = 1.8 time = 1500
.meas tran vdout1_8ck74 FIND v(dout1_8) AT=1500.1n

* CHECK dout1_9 Vdout1_9ck74 = 0 time = 1500
.meas tran vdout1_9ck74 FIND v(dout1_9) AT=1500.1n

* CHECK dout1_10 Vdout1_10ck74 = 1.8 time = 1500
.meas tran vdout1_10ck74 FIND v(dout1_10) AT=1500.1n

* CHECK dout1_11 Vdout1_11ck74 = 1.8 time = 1500
.meas tran vdout1_11ck74 FIND v(dout1_11) AT=1500.1n

* CHECK dout1_12 Vdout1_12ck74 = 0 time = 1500
.meas tran vdout1_12ck74 FIND v(dout1_12) AT=1500.1n

* CHECK dout1_13 Vdout1_13ck74 = 0 time = 1500
.meas tran vdout1_13ck74 FIND v(dout1_13) AT=1500.1n

* CHECK dout1_14 Vdout1_14ck74 = 1.8 time = 1500
.meas tran vdout1_14ck74 FIND v(dout1_14) AT=1500.1n

* CHECK dout1_15 Vdout1_15ck74 = 1.8 time = 1500
.meas tran vdout1_15ck74 FIND v(dout1_15) AT=1500.1n

* CHECK dout1_16 Vdout1_16ck74 = 0 time = 1500
.meas tran vdout1_16ck74 FIND v(dout1_16) AT=1500.1n

* CHECK dout1_17 Vdout1_17ck74 = 0 time = 1500
.meas tran vdout1_17ck74 FIND v(dout1_17) AT=1500.1n

* CHECK dout1_18 Vdout1_18ck74 = 0 time = 1500
.meas tran vdout1_18ck74 FIND v(dout1_18) AT=1500.1n

* CHECK dout1_19 Vdout1_19ck74 = 1.8 time = 1500
.meas tran vdout1_19ck74 FIND v(dout1_19) AT=1500.1n

* CHECK dout1_20 Vdout1_20ck74 = 1.8 time = 1500
.meas tran vdout1_20ck74 FIND v(dout1_20) AT=1500.1n

* CHECK dout1_21 Vdout1_21ck74 = 0 time = 1500
.meas tran vdout1_21ck74 FIND v(dout1_21) AT=1500.1n

* CHECK dout1_22 Vdout1_22ck74 = 0 time = 1500
.meas tran vdout1_22ck74 FIND v(dout1_22) AT=1500.1n

* CHECK dout1_23 Vdout1_23ck74 = 1.8 time = 1500
.meas tran vdout1_23ck74 FIND v(dout1_23) AT=1500.1n

* CHECK dout1_24 Vdout1_24ck74 = 0 time = 1500
.meas tran vdout1_24ck74 FIND v(dout1_24) AT=1500.1n

* CHECK dout1_25 Vdout1_25ck74 = 0 time = 1500
.meas tran vdout1_25ck74 FIND v(dout1_25) AT=1500.1n

* CHECK dout1_26 Vdout1_26ck74 = 1.8 time = 1500
.meas tran vdout1_26ck74 FIND v(dout1_26) AT=1500.1n

* CHECK dout1_27 Vdout1_27ck74 = 1.8 time = 1500
.meas tran vdout1_27ck74 FIND v(dout1_27) AT=1500.1n

* CHECK dout1_28 Vdout1_28ck74 = 1.8 time = 1500
.meas tran vdout1_28ck74 FIND v(dout1_28) AT=1500.1n

* CHECK dout1_29 Vdout1_29ck74 = 1.8 time = 1500
.meas tran vdout1_29ck74 FIND v(dout1_29) AT=1500.1n

* CHECK dout1_30 Vdout1_30ck74 = 0 time = 1500
.meas tran vdout1_30ck74 FIND v(dout1_30) AT=1500.1n

* CHECK dout1_31 Vdout1_31ck74 = 1.8 time = 1500
.meas tran vdout1_31ck74 FIND v(dout1_31) AT=1500.1n

* CHECK dout2_0 Vdout2_0ck74 = 1.8 time = 1500
.meas tran vdout2_0ck74 FIND v(dout2_0) AT=1500.1n

* CHECK dout2_1 Vdout2_1ck74 = 0 time = 1500
.meas tran vdout2_1ck74 FIND v(dout2_1) AT=1500.1n

* CHECK dout2_2 Vdout2_2ck74 = 1.8 time = 1500
.meas tran vdout2_2ck74 FIND v(dout2_2) AT=1500.1n

* CHECK dout2_3 Vdout2_3ck74 = 0 time = 1500
.meas tran vdout2_3ck74 FIND v(dout2_3) AT=1500.1n

* CHECK dout2_4 Vdout2_4ck74 = 1.8 time = 1500
.meas tran vdout2_4ck74 FIND v(dout2_4) AT=1500.1n

* CHECK dout2_5 Vdout2_5ck74 = 1.8 time = 1500
.meas tran vdout2_5ck74 FIND v(dout2_5) AT=1500.1n

* CHECK dout2_6 Vdout2_6ck74 = 1.8 time = 1500
.meas tran vdout2_6ck74 FIND v(dout2_6) AT=1500.1n

* CHECK dout2_7 Vdout2_7ck74 = 1.8 time = 1500
.meas tran vdout2_7ck74 FIND v(dout2_7) AT=1500.1n

* CHECK dout2_8 Vdout2_8ck74 = 0 time = 1500
.meas tran vdout2_8ck74 FIND v(dout2_8) AT=1500.1n

* CHECK dout2_9 Vdout2_9ck74 = 0 time = 1500
.meas tran vdout2_9ck74 FIND v(dout2_9) AT=1500.1n

* CHECK dout2_10 Vdout2_10ck74 = 0 time = 1500
.meas tran vdout2_10ck74 FIND v(dout2_10) AT=1500.1n

* CHECK dout2_11 Vdout2_11ck74 = 1.8 time = 1500
.meas tran vdout2_11ck74 FIND v(dout2_11) AT=1500.1n

* CHECK dout2_12 Vdout2_12ck74 = 1.8 time = 1500
.meas tran vdout2_12ck74 FIND v(dout2_12) AT=1500.1n

* CHECK dout2_13 Vdout2_13ck74 = 0 time = 1500
.meas tran vdout2_13ck74 FIND v(dout2_13) AT=1500.1n

* CHECK dout2_14 Vdout2_14ck74 = 0 time = 1500
.meas tran vdout2_14ck74 FIND v(dout2_14) AT=1500.1n

* CHECK dout2_15 Vdout2_15ck74 = 0 time = 1500
.meas tran vdout2_15ck74 FIND v(dout2_15) AT=1500.1n

* CHECK dout2_16 Vdout2_16ck74 = 0 time = 1500
.meas tran vdout2_16ck74 FIND v(dout2_16) AT=1500.1n

* CHECK dout2_17 Vdout2_17ck74 = 0 time = 1500
.meas tran vdout2_17ck74 FIND v(dout2_17) AT=1500.1n

* CHECK dout2_18 Vdout2_18ck74 = 1.8 time = 1500
.meas tran vdout2_18ck74 FIND v(dout2_18) AT=1500.1n

* CHECK dout2_19 Vdout2_19ck74 = 0 time = 1500
.meas tran vdout2_19ck74 FIND v(dout2_19) AT=1500.1n

* CHECK dout2_20 Vdout2_20ck74 = 1.8 time = 1500
.meas tran vdout2_20ck74 FIND v(dout2_20) AT=1500.1n

* CHECK dout2_21 Vdout2_21ck74 = 0 time = 1500
.meas tran vdout2_21ck74 FIND v(dout2_21) AT=1500.1n

* CHECK dout2_22 Vdout2_22ck74 = 0 time = 1500
.meas tran vdout2_22ck74 FIND v(dout2_22) AT=1500.1n

* CHECK dout2_23 Vdout2_23ck74 = 0 time = 1500
.meas tran vdout2_23ck74 FIND v(dout2_23) AT=1500.1n

* CHECK dout2_24 Vdout2_24ck74 = 0 time = 1500
.meas tran vdout2_24ck74 FIND v(dout2_24) AT=1500.1n

* CHECK dout2_25 Vdout2_25ck74 = 1.8 time = 1500
.meas tran vdout2_25ck74 FIND v(dout2_25) AT=1500.1n

* CHECK dout2_26 Vdout2_26ck74 = 1.8 time = 1500
.meas tran vdout2_26ck74 FIND v(dout2_26) AT=1500.1n

* CHECK dout2_27 Vdout2_27ck74 = 1.8 time = 1500
.meas tran vdout2_27ck74 FIND v(dout2_27) AT=1500.1n

* CHECK dout2_28 Vdout2_28ck74 = 1.8 time = 1500
.meas tran vdout2_28ck74 FIND v(dout2_28) AT=1500.1n

* CHECK dout2_29 Vdout2_29ck74 = 0 time = 1500
.meas tran vdout2_29ck74 FIND v(dout2_29) AT=1500.1n

* CHECK dout2_30 Vdout2_30ck74 = 1.8 time = 1500
.meas tran vdout2_30ck74 FIND v(dout2_30) AT=1500.1n

* CHECK dout2_31 Vdout2_31ck74 = 0 time = 1500
.meas tran vdout2_31ck74 FIND v(dout2_31) AT=1500.1n

* CHECK dout1_0 Vdout1_0ck75 = 0 time = 1520
.meas tran vdout1_0ck75 FIND v(dout1_0) AT=1520.1n

* CHECK dout1_1 Vdout1_1ck75 = 0 time = 1520
.meas tran vdout1_1ck75 FIND v(dout1_1) AT=1520.1n

* CHECK dout1_2 Vdout1_2ck75 = 0 time = 1520
.meas tran vdout1_2ck75 FIND v(dout1_2) AT=1520.1n

* CHECK dout1_3 Vdout1_3ck75 = 1.8 time = 1520
.meas tran vdout1_3ck75 FIND v(dout1_3) AT=1520.1n

* CHECK dout1_4 Vdout1_4ck75 = 1.8 time = 1520
.meas tran vdout1_4ck75 FIND v(dout1_4) AT=1520.1n

* CHECK dout1_5 Vdout1_5ck75 = 1.8 time = 1520
.meas tran vdout1_5ck75 FIND v(dout1_5) AT=1520.1n

* CHECK dout1_6 Vdout1_6ck75 = 0 time = 1520
.meas tran vdout1_6ck75 FIND v(dout1_6) AT=1520.1n

* CHECK dout1_7 Vdout1_7ck75 = 0 time = 1520
.meas tran vdout1_7ck75 FIND v(dout1_7) AT=1520.1n

* CHECK dout1_8 Vdout1_8ck75 = 1.8 time = 1520
.meas tran vdout1_8ck75 FIND v(dout1_8) AT=1520.1n

* CHECK dout1_9 Vdout1_9ck75 = 0 time = 1520
.meas tran vdout1_9ck75 FIND v(dout1_9) AT=1520.1n

* CHECK dout1_10 Vdout1_10ck75 = 0 time = 1520
.meas tran vdout1_10ck75 FIND v(dout1_10) AT=1520.1n

* CHECK dout1_11 Vdout1_11ck75 = 0 time = 1520
.meas tran vdout1_11ck75 FIND v(dout1_11) AT=1520.1n

* CHECK dout1_12 Vdout1_12ck75 = 1.8 time = 1520
.meas tran vdout1_12ck75 FIND v(dout1_12) AT=1520.1n

* CHECK dout1_13 Vdout1_13ck75 = 0 time = 1520
.meas tran vdout1_13ck75 FIND v(dout1_13) AT=1520.1n

* CHECK dout1_14 Vdout1_14ck75 = 1.8 time = 1520
.meas tran vdout1_14ck75 FIND v(dout1_14) AT=1520.1n

* CHECK dout1_15 Vdout1_15ck75 = 0 time = 1520
.meas tran vdout1_15ck75 FIND v(dout1_15) AT=1520.1n

* CHECK dout1_16 Vdout1_16ck75 = 1.8 time = 1520
.meas tran vdout1_16ck75 FIND v(dout1_16) AT=1520.1n

* CHECK dout1_17 Vdout1_17ck75 = 0 time = 1520
.meas tran vdout1_17ck75 FIND v(dout1_17) AT=1520.1n

* CHECK dout1_18 Vdout1_18ck75 = 0 time = 1520
.meas tran vdout1_18ck75 FIND v(dout1_18) AT=1520.1n

* CHECK dout1_19 Vdout1_19ck75 = 1.8 time = 1520
.meas tran vdout1_19ck75 FIND v(dout1_19) AT=1520.1n

* CHECK dout1_20 Vdout1_20ck75 = 1.8 time = 1520
.meas tran vdout1_20ck75 FIND v(dout1_20) AT=1520.1n

* CHECK dout1_21 Vdout1_21ck75 = 1.8 time = 1520
.meas tran vdout1_21ck75 FIND v(dout1_21) AT=1520.1n

* CHECK dout1_22 Vdout1_22ck75 = 0 time = 1520
.meas tran vdout1_22ck75 FIND v(dout1_22) AT=1520.1n

* CHECK dout1_23 Vdout1_23ck75 = 1.8 time = 1520
.meas tran vdout1_23ck75 FIND v(dout1_23) AT=1520.1n

* CHECK dout1_24 Vdout1_24ck75 = 0 time = 1520
.meas tran vdout1_24ck75 FIND v(dout1_24) AT=1520.1n

* CHECK dout1_25 Vdout1_25ck75 = 1.8 time = 1520
.meas tran vdout1_25ck75 FIND v(dout1_25) AT=1520.1n

* CHECK dout1_26 Vdout1_26ck75 = 1.8 time = 1520
.meas tran vdout1_26ck75 FIND v(dout1_26) AT=1520.1n

* CHECK dout1_27 Vdout1_27ck75 = 0 time = 1520
.meas tran vdout1_27ck75 FIND v(dout1_27) AT=1520.1n

* CHECK dout1_28 Vdout1_28ck75 = 1.8 time = 1520
.meas tran vdout1_28ck75 FIND v(dout1_28) AT=1520.1n

* CHECK dout1_29 Vdout1_29ck75 = 1.8 time = 1520
.meas tran vdout1_29ck75 FIND v(dout1_29) AT=1520.1n

* CHECK dout1_30 Vdout1_30ck75 = 1.8 time = 1520
.meas tran vdout1_30ck75 FIND v(dout1_30) AT=1520.1n

* CHECK dout1_31 Vdout1_31ck75 = 0 time = 1520
.meas tran vdout1_31ck75 FIND v(dout1_31) AT=1520.1n

* CHECK dout2_0 Vdout2_0ck75 = 0 time = 1520
.meas tran vdout2_0ck75 FIND v(dout2_0) AT=1520.1n

* CHECK dout2_1 Vdout2_1ck75 = 0 time = 1520
.meas tran vdout2_1ck75 FIND v(dout2_1) AT=1520.1n

* CHECK dout2_2 Vdout2_2ck75 = 0 time = 1520
.meas tran vdout2_2ck75 FIND v(dout2_2) AT=1520.1n

* CHECK dout2_3 Vdout2_3ck75 = 1.8 time = 1520
.meas tran vdout2_3ck75 FIND v(dout2_3) AT=1520.1n

* CHECK dout2_4 Vdout2_4ck75 = 1.8 time = 1520
.meas tran vdout2_4ck75 FIND v(dout2_4) AT=1520.1n

* CHECK dout2_5 Vdout2_5ck75 = 1.8 time = 1520
.meas tran vdout2_5ck75 FIND v(dout2_5) AT=1520.1n

* CHECK dout2_6 Vdout2_6ck75 = 0 time = 1520
.meas tran vdout2_6ck75 FIND v(dout2_6) AT=1520.1n

* CHECK dout2_7 Vdout2_7ck75 = 0 time = 1520
.meas tran vdout2_7ck75 FIND v(dout2_7) AT=1520.1n

* CHECK dout2_8 Vdout2_8ck75 = 1.8 time = 1520
.meas tran vdout2_8ck75 FIND v(dout2_8) AT=1520.1n

* CHECK dout2_9 Vdout2_9ck75 = 0 time = 1520
.meas tran vdout2_9ck75 FIND v(dout2_9) AT=1520.1n

* CHECK dout2_10 Vdout2_10ck75 = 0 time = 1520
.meas tran vdout2_10ck75 FIND v(dout2_10) AT=1520.1n

* CHECK dout2_11 Vdout2_11ck75 = 0 time = 1520
.meas tran vdout2_11ck75 FIND v(dout2_11) AT=1520.1n

* CHECK dout2_12 Vdout2_12ck75 = 1.8 time = 1520
.meas tran vdout2_12ck75 FIND v(dout2_12) AT=1520.1n

* CHECK dout2_13 Vdout2_13ck75 = 0 time = 1520
.meas tran vdout2_13ck75 FIND v(dout2_13) AT=1520.1n

* CHECK dout2_14 Vdout2_14ck75 = 1.8 time = 1520
.meas tran vdout2_14ck75 FIND v(dout2_14) AT=1520.1n

* CHECK dout2_15 Vdout2_15ck75 = 0 time = 1520
.meas tran vdout2_15ck75 FIND v(dout2_15) AT=1520.1n

* CHECK dout2_16 Vdout2_16ck75 = 1.8 time = 1520
.meas tran vdout2_16ck75 FIND v(dout2_16) AT=1520.1n

* CHECK dout2_17 Vdout2_17ck75 = 0 time = 1520
.meas tran vdout2_17ck75 FIND v(dout2_17) AT=1520.1n

* CHECK dout2_18 Vdout2_18ck75 = 0 time = 1520
.meas tran vdout2_18ck75 FIND v(dout2_18) AT=1520.1n

* CHECK dout2_19 Vdout2_19ck75 = 1.8 time = 1520
.meas tran vdout2_19ck75 FIND v(dout2_19) AT=1520.1n

* CHECK dout2_20 Vdout2_20ck75 = 1.8 time = 1520
.meas tran vdout2_20ck75 FIND v(dout2_20) AT=1520.1n

* CHECK dout2_21 Vdout2_21ck75 = 1.8 time = 1520
.meas tran vdout2_21ck75 FIND v(dout2_21) AT=1520.1n

* CHECK dout2_22 Vdout2_22ck75 = 0 time = 1520
.meas tran vdout2_22ck75 FIND v(dout2_22) AT=1520.1n

* CHECK dout2_23 Vdout2_23ck75 = 1.8 time = 1520
.meas tran vdout2_23ck75 FIND v(dout2_23) AT=1520.1n

* CHECK dout2_24 Vdout2_24ck75 = 0 time = 1520
.meas tran vdout2_24ck75 FIND v(dout2_24) AT=1520.1n

* CHECK dout2_25 Vdout2_25ck75 = 1.8 time = 1520
.meas tran vdout2_25ck75 FIND v(dout2_25) AT=1520.1n

* CHECK dout2_26 Vdout2_26ck75 = 1.8 time = 1520
.meas tran vdout2_26ck75 FIND v(dout2_26) AT=1520.1n

* CHECK dout2_27 Vdout2_27ck75 = 0 time = 1520
.meas tran vdout2_27ck75 FIND v(dout2_27) AT=1520.1n

* CHECK dout2_28 Vdout2_28ck75 = 1.8 time = 1520
.meas tran vdout2_28ck75 FIND v(dout2_28) AT=1520.1n

* CHECK dout2_29 Vdout2_29ck75 = 1.8 time = 1520
.meas tran vdout2_29ck75 FIND v(dout2_29) AT=1520.1n

* CHECK dout2_30 Vdout2_30ck75 = 1.8 time = 1520
.meas tran vdout2_30ck75 FIND v(dout2_30) AT=1520.1n

* CHECK dout2_31 Vdout2_31ck75 = 0 time = 1520
.meas tran vdout2_31ck75 FIND v(dout2_31) AT=1520.1n

* CHECK dout2_0 Vdout2_0ck76 = 1.8 time = 1540
.meas tran vdout2_0ck76 FIND v(dout2_0) AT=1540.1n

* CHECK dout2_1 Vdout2_1ck76 = 1.8 time = 1540
.meas tran vdout2_1ck76 FIND v(dout2_1) AT=1540.1n

* CHECK dout2_2 Vdout2_2ck76 = 0 time = 1540
.meas tran vdout2_2ck76 FIND v(dout2_2) AT=1540.1n

* CHECK dout2_3 Vdout2_3ck76 = 1.8 time = 1540
.meas tran vdout2_3ck76 FIND v(dout2_3) AT=1540.1n

* CHECK dout2_4 Vdout2_4ck76 = 0 time = 1540
.meas tran vdout2_4ck76 FIND v(dout2_4) AT=1540.1n

* CHECK dout2_5 Vdout2_5ck76 = 1.8 time = 1540
.meas tran vdout2_5ck76 FIND v(dout2_5) AT=1540.1n

* CHECK dout2_6 Vdout2_6ck76 = 1.8 time = 1540
.meas tran vdout2_6ck76 FIND v(dout2_6) AT=1540.1n

* CHECK dout2_7 Vdout2_7ck76 = 1.8 time = 1540
.meas tran vdout2_7ck76 FIND v(dout2_7) AT=1540.1n

* CHECK dout2_8 Vdout2_8ck76 = 0 time = 1540
.meas tran vdout2_8ck76 FIND v(dout2_8) AT=1540.1n

* CHECK dout2_9 Vdout2_9ck76 = 0 time = 1540
.meas tran vdout2_9ck76 FIND v(dout2_9) AT=1540.1n

* CHECK dout2_10 Vdout2_10ck76 = 0 time = 1540
.meas tran vdout2_10ck76 FIND v(dout2_10) AT=1540.1n

* CHECK dout2_11 Vdout2_11ck76 = 1.8 time = 1540
.meas tran vdout2_11ck76 FIND v(dout2_11) AT=1540.1n

* CHECK dout2_12 Vdout2_12ck76 = 1.8 time = 1540
.meas tran vdout2_12ck76 FIND v(dout2_12) AT=1540.1n

* CHECK dout2_13 Vdout2_13ck76 = 0 time = 1540
.meas tran vdout2_13ck76 FIND v(dout2_13) AT=1540.1n

* CHECK dout2_14 Vdout2_14ck76 = 0 time = 1540
.meas tran vdout2_14ck76 FIND v(dout2_14) AT=1540.1n

* CHECK dout2_15 Vdout2_15ck76 = 0 time = 1540
.meas tran vdout2_15ck76 FIND v(dout2_15) AT=1540.1n

* CHECK dout2_16 Vdout2_16ck76 = 0 time = 1540
.meas tran vdout2_16ck76 FIND v(dout2_16) AT=1540.1n

* CHECK dout2_17 Vdout2_17ck76 = 0 time = 1540
.meas tran vdout2_17ck76 FIND v(dout2_17) AT=1540.1n

* CHECK dout2_18 Vdout2_18ck76 = 1.8 time = 1540
.meas tran vdout2_18ck76 FIND v(dout2_18) AT=1540.1n

* CHECK dout2_19 Vdout2_19ck76 = 1.8 time = 1540
.meas tran vdout2_19ck76 FIND v(dout2_19) AT=1540.1n

* CHECK dout2_20 Vdout2_20ck76 = 0 time = 1540
.meas tran vdout2_20ck76 FIND v(dout2_20) AT=1540.1n

* CHECK dout2_21 Vdout2_21ck76 = 1.8 time = 1540
.meas tran vdout2_21ck76 FIND v(dout2_21) AT=1540.1n

* CHECK dout2_22 Vdout2_22ck76 = 1.8 time = 1540
.meas tran vdout2_22ck76 FIND v(dout2_22) AT=1540.1n

* CHECK dout2_23 Vdout2_23ck76 = 1.8 time = 1540
.meas tran vdout2_23ck76 FIND v(dout2_23) AT=1540.1n

* CHECK dout2_24 Vdout2_24ck76 = 1.8 time = 1540
.meas tran vdout2_24ck76 FIND v(dout2_24) AT=1540.1n

* CHECK dout2_25 Vdout2_25ck76 = 0 time = 1540
.meas tran vdout2_25ck76 FIND v(dout2_25) AT=1540.1n

* CHECK dout2_26 Vdout2_26ck76 = 1.8 time = 1540
.meas tran vdout2_26ck76 FIND v(dout2_26) AT=1540.1n

* CHECK dout2_27 Vdout2_27ck76 = 0 time = 1540
.meas tran vdout2_27ck76 FIND v(dout2_27) AT=1540.1n

* CHECK dout2_28 Vdout2_28ck76 = 1.8 time = 1540
.meas tran vdout2_28ck76 FIND v(dout2_28) AT=1540.1n

* CHECK dout2_29 Vdout2_29ck76 = 0 time = 1540
.meas tran vdout2_29ck76 FIND v(dout2_29) AT=1540.1n

* CHECK dout2_30 Vdout2_30ck76 = 1.8 time = 1540
.meas tran vdout2_30ck76 FIND v(dout2_30) AT=1540.1n

* CHECK dout2_31 Vdout2_31ck76 = 0 time = 1540
.meas tran vdout2_31ck76 FIND v(dout2_31) AT=1540.1n

* CHECK dout1_0 Vdout1_0ck77 = 1.8 time = 1560
.meas tran vdout1_0ck77 FIND v(dout1_0) AT=1560.1n

* CHECK dout1_1 Vdout1_1ck77 = 1.8 time = 1560
.meas tran vdout1_1ck77 FIND v(dout1_1) AT=1560.1n

* CHECK dout1_2 Vdout1_2ck77 = 0 time = 1560
.meas tran vdout1_2ck77 FIND v(dout1_2) AT=1560.1n

* CHECK dout1_3 Vdout1_3ck77 = 1.8 time = 1560
.meas tran vdout1_3ck77 FIND v(dout1_3) AT=1560.1n

* CHECK dout1_4 Vdout1_4ck77 = 1.8 time = 1560
.meas tran vdout1_4ck77 FIND v(dout1_4) AT=1560.1n

* CHECK dout1_5 Vdout1_5ck77 = 1.8 time = 1560
.meas tran vdout1_5ck77 FIND v(dout1_5) AT=1560.1n

* CHECK dout1_6 Vdout1_6ck77 = 1.8 time = 1560
.meas tran vdout1_6ck77 FIND v(dout1_6) AT=1560.1n

* CHECK dout1_7 Vdout1_7ck77 = 0 time = 1560
.meas tran vdout1_7ck77 FIND v(dout1_7) AT=1560.1n

* CHECK dout1_8 Vdout1_8ck77 = 0 time = 1560
.meas tran vdout1_8ck77 FIND v(dout1_8) AT=1560.1n

* CHECK dout1_9 Vdout1_9ck77 = 0 time = 1560
.meas tran vdout1_9ck77 FIND v(dout1_9) AT=1560.1n

* CHECK dout1_10 Vdout1_10ck77 = 0 time = 1560
.meas tran vdout1_10ck77 FIND v(dout1_10) AT=1560.1n

* CHECK dout1_11 Vdout1_11ck77 = 1.8 time = 1560
.meas tran vdout1_11ck77 FIND v(dout1_11) AT=1560.1n

* CHECK dout1_12 Vdout1_12ck77 = 1.8 time = 1560
.meas tran vdout1_12ck77 FIND v(dout1_12) AT=1560.1n

* CHECK dout1_13 Vdout1_13ck77 = 1.8 time = 1560
.meas tran vdout1_13ck77 FIND v(dout1_13) AT=1560.1n

* CHECK dout1_14 Vdout1_14ck77 = 0 time = 1560
.meas tran vdout1_14ck77 FIND v(dout1_14) AT=1560.1n

* CHECK dout1_15 Vdout1_15ck77 = 1.8 time = 1560
.meas tran vdout1_15ck77 FIND v(dout1_15) AT=1560.1n

* CHECK dout1_16 Vdout1_16ck77 = 0 time = 1560
.meas tran vdout1_16ck77 FIND v(dout1_16) AT=1560.1n

* CHECK dout1_17 Vdout1_17ck77 = 1.8 time = 1560
.meas tran vdout1_17ck77 FIND v(dout1_17) AT=1560.1n

* CHECK dout1_18 Vdout1_18ck77 = 0 time = 1560
.meas tran vdout1_18ck77 FIND v(dout1_18) AT=1560.1n

* CHECK dout1_19 Vdout1_19ck77 = 1.8 time = 1560
.meas tran vdout1_19ck77 FIND v(dout1_19) AT=1560.1n

* CHECK dout1_20 Vdout1_20ck77 = 1.8 time = 1560
.meas tran vdout1_20ck77 FIND v(dout1_20) AT=1560.1n

* CHECK dout1_21 Vdout1_21ck77 = 1.8 time = 1560
.meas tran vdout1_21ck77 FIND v(dout1_21) AT=1560.1n

* CHECK dout1_22 Vdout1_22ck77 = 1.8 time = 1560
.meas tran vdout1_22ck77 FIND v(dout1_22) AT=1560.1n

* CHECK dout1_23 Vdout1_23ck77 = 1.8 time = 1560
.meas tran vdout1_23ck77 FIND v(dout1_23) AT=1560.1n

* CHECK dout1_24 Vdout1_24ck77 = 1.8 time = 1560
.meas tran vdout1_24ck77 FIND v(dout1_24) AT=1560.1n

* CHECK dout1_25 Vdout1_25ck77 = 1.8 time = 1560
.meas tran vdout1_25ck77 FIND v(dout1_25) AT=1560.1n

* CHECK dout1_26 Vdout1_26ck77 = 0 time = 1560
.meas tran vdout1_26ck77 FIND v(dout1_26) AT=1560.1n

* CHECK dout1_27 Vdout1_27ck77 = 0 time = 1560
.meas tran vdout1_27ck77 FIND v(dout1_27) AT=1560.1n

* CHECK dout1_28 Vdout1_28ck77 = 0 time = 1560
.meas tran vdout1_28ck77 FIND v(dout1_28) AT=1560.1n

* CHECK dout1_29 Vdout1_29ck77 = 0 time = 1560
.meas tran vdout1_29ck77 FIND v(dout1_29) AT=1560.1n

* CHECK dout1_30 Vdout1_30ck77 = 0 time = 1560
.meas tran vdout1_30ck77 FIND v(dout1_30) AT=1560.1n

* CHECK dout1_31 Vdout1_31ck77 = 1.8 time = 1560
.meas tran vdout1_31ck77 FIND v(dout1_31) AT=1560.1n

* CHECK dout2_0 Vdout2_0ck77 = 1.8 time = 1560
.meas tran vdout2_0ck77 FIND v(dout2_0) AT=1560.1n

* CHECK dout2_1 Vdout2_1ck77 = 1.8 time = 1560
.meas tran vdout2_1ck77 FIND v(dout2_1) AT=1560.1n

* CHECK dout2_2 Vdout2_2ck77 = 0 time = 1560
.meas tran vdout2_2ck77 FIND v(dout2_2) AT=1560.1n

* CHECK dout2_3 Vdout2_3ck77 = 1.8 time = 1560
.meas tran vdout2_3ck77 FIND v(dout2_3) AT=1560.1n

* CHECK dout2_4 Vdout2_4ck77 = 1.8 time = 1560
.meas tran vdout2_4ck77 FIND v(dout2_4) AT=1560.1n

* CHECK dout2_5 Vdout2_5ck77 = 1.8 time = 1560
.meas tran vdout2_5ck77 FIND v(dout2_5) AT=1560.1n

* CHECK dout2_6 Vdout2_6ck77 = 1.8 time = 1560
.meas tran vdout2_6ck77 FIND v(dout2_6) AT=1560.1n

* CHECK dout2_7 Vdout2_7ck77 = 0 time = 1560
.meas tran vdout2_7ck77 FIND v(dout2_7) AT=1560.1n

* CHECK dout2_8 Vdout2_8ck77 = 0 time = 1560
.meas tran vdout2_8ck77 FIND v(dout2_8) AT=1560.1n

* CHECK dout2_9 Vdout2_9ck77 = 0 time = 1560
.meas tran vdout2_9ck77 FIND v(dout2_9) AT=1560.1n

* CHECK dout2_10 Vdout2_10ck77 = 0 time = 1560
.meas tran vdout2_10ck77 FIND v(dout2_10) AT=1560.1n

* CHECK dout2_11 Vdout2_11ck77 = 1.8 time = 1560
.meas tran vdout2_11ck77 FIND v(dout2_11) AT=1560.1n

* CHECK dout2_12 Vdout2_12ck77 = 1.8 time = 1560
.meas tran vdout2_12ck77 FIND v(dout2_12) AT=1560.1n

* CHECK dout2_13 Vdout2_13ck77 = 1.8 time = 1560
.meas tran vdout2_13ck77 FIND v(dout2_13) AT=1560.1n

* CHECK dout2_14 Vdout2_14ck77 = 0 time = 1560
.meas tran vdout2_14ck77 FIND v(dout2_14) AT=1560.1n

* CHECK dout2_15 Vdout2_15ck77 = 1.8 time = 1560
.meas tran vdout2_15ck77 FIND v(dout2_15) AT=1560.1n

* CHECK dout2_16 Vdout2_16ck77 = 0 time = 1560
.meas tran vdout2_16ck77 FIND v(dout2_16) AT=1560.1n

* CHECK dout2_17 Vdout2_17ck77 = 1.8 time = 1560
.meas tran vdout2_17ck77 FIND v(dout2_17) AT=1560.1n

* CHECK dout2_18 Vdout2_18ck77 = 0 time = 1560
.meas tran vdout2_18ck77 FIND v(dout2_18) AT=1560.1n

* CHECK dout2_19 Vdout2_19ck77 = 1.8 time = 1560
.meas tran vdout2_19ck77 FIND v(dout2_19) AT=1560.1n

* CHECK dout2_20 Vdout2_20ck77 = 1.8 time = 1560
.meas tran vdout2_20ck77 FIND v(dout2_20) AT=1560.1n

* CHECK dout2_21 Vdout2_21ck77 = 1.8 time = 1560
.meas tran vdout2_21ck77 FIND v(dout2_21) AT=1560.1n

* CHECK dout2_22 Vdout2_22ck77 = 1.8 time = 1560
.meas tran vdout2_22ck77 FIND v(dout2_22) AT=1560.1n

* CHECK dout2_23 Vdout2_23ck77 = 1.8 time = 1560
.meas tran vdout2_23ck77 FIND v(dout2_23) AT=1560.1n

* CHECK dout2_24 Vdout2_24ck77 = 1.8 time = 1560
.meas tran vdout2_24ck77 FIND v(dout2_24) AT=1560.1n

* CHECK dout2_25 Vdout2_25ck77 = 1.8 time = 1560
.meas tran vdout2_25ck77 FIND v(dout2_25) AT=1560.1n

* CHECK dout2_26 Vdout2_26ck77 = 0 time = 1560
.meas tran vdout2_26ck77 FIND v(dout2_26) AT=1560.1n

* CHECK dout2_27 Vdout2_27ck77 = 0 time = 1560
.meas tran vdout2_27ck77 FIND v(dout2_27) AT=1560.1n

* CHECK dout2_28 Vdout2_28ck77 = 0 time = 1560
.meas tran vdout2_28ck77 FIND v(dout2_28) AT=1560.1n

* CHECK dout2_29 Vdout2_29ck77 = 0 time = 1560
.meas tran vdout2_29ck77 FIND v(dout2_29) AT=1560.1n

* CHECK dout2_30 Vdout2_30ck77 = 0 time = 1560
.meas tran vdout2_30ck77 FIND v(dout2_30) AT=1560.1n

* CHECK dout2_31 Vdout2_31ck77 = 1.8 time = 1560
.meas tran vdout2_31ck77 FIND v(dout2_31) AT=1560.1n

* CHECK dout1_0 Vdout1_0ck80 = 1.8 time = 1620
.meas tran vdout1_0ck80 FIND v(dout1_0) AT=1620.1n

* CHECK dout1_1 Vdout1_1ck80 = 0 time = 1620
.meas tran vdout1_1ck80 FIND v(dout1_1) AT=1620.1n

* CHECK dout1_2 Vdout1_2ck80 = 0 time = 1620
.meas tran vdout1_2ck80 FIND v(dout1_2) AT=1620.1n

* CHECK dout1_3 Vdout1_3ck80 = 0 time = 1620
.meas tran vdout1_3ck80 FIND v(dout1_3) AT=1620.1n

* CHECK dout1_4 Vdout1_4ck80 = 1.8 time = 1620
.meas tran vdout1_4ck80 FIND v(dout1_4) AT=1620.1n

* CHECK dout1_5 Vdout1_5ck80 = 0 time = 1620
.meas tran vdout1_5ck80 FIND v(dout1_5) AT=1620.1n

* CHECK dout1_6 Vdout1_6ck80 = 1.8 time = 1620
.meas tran vdout1_6ck80 FIND v(dout1_6) AT=1620.1n

* CHECK dout1_7 Vdout1_7ck80 = 0 time = 1620
.meas tran vdout1_7ck80 FIND v(dout1_7) AT=1620.1n

* CHECK dout1_8 Vdout1_8ck80 = 0 time = 1620
.meas tran vdout1_8ck80 FIND v(dout1_8) AT=1620.1n

* CHECK dout1_9 Vdout1_9ck80 = 0 time = 1620
.meas tran vdout1_9ck80 FIND v(dout1_9) AT=1620.1n

* CHECK dout1_10 Vdout1_10ck80 = 1.8 time = 1620
.meas tran vdout1_10ck80 FIND v(dout1_10) AT=1620.1n

* CHECK dout1_11 Vdout1_11ck80 = 0 time = 1620
.meas tran vdout1_11ck80 FIND v(dout1_11) AT=1620.1n

* CHECK dout1_12 Vdout1_12ck80 = 0 time = 1620
.meas tran vdout1_12ck80 FIND v(dout1_12) AT=1620.1n

* CHECK dout1_13 Vdout1_13ck80 = 1.8 time = 1620
.meas tran vdout1_13ck80 FIND v(dout1_13) AT=1620.1n

* CHECK dout1_14 Vdout1_14ck80 = 0 time = 1620
.meas tran vdout1_14ck80 FIND v(dout1_14) AT=1620.1n

* CHECK dout1_15 Vdout1_15ck80 = 0 time = 1620
.meas tran vdout1_15ck80 FIND v(dout1_15) AT=1620.1n

* CHECK dout1_16 Vdout1_16ck80 = 0 time = 1620
.meas tran vdout1_16ck80 FIND v(dout1_16) AT=1620.1n

* CHECK dout1_17 Vdout1_17ck80 = 0 time = 1620
.meas tran vdout1_17ck80 FIND v(dout1_17) AT=1620.1n

* CHECK dout1_18 Vdout1_18ck80 = 1.8 time = 1620
.meas tran vdout1_18ck80 FIND v(dout1_18) AT=1620.1n

* CHECK dout1_19 Vdout1_19ck80 = 0 time = 1620
.meas tran vdout1_19ck80 FIND v(dout1_19) AT=1620.1n

* CHECK dout1_20 Vdout1_20ck80 = 0 time = 1620
.meas tran vdout1_20ck80 FIND v(dout1_20) AT=1620.1n

* CHECK dout1_21 Vdout1_21ck80 = 0 time = 1620
.meas tran vdout1_21ck80 FIND v(dout1_21) AT=1620.1n

* CHECK dout1_22 Vdout1_22ck80 = 1.8 time = 1620
.meas tran vdout1_22ck80 FIND v(dout1_22) AT=1620.1n

* CHECK dout1_23 Vdout1_23ck80 = 0 time = 1620
.meas tran vdout1_23ck80 FIND v(dout1_23) AT=1620.1n

* CHECK dout1_24 Vdout1_24ck80 = 0 time = 1620
.meas tran vdout1_24ck80 FIND v(dout1_24) AT=1620.1n

* CHECK dout1_25 Vdout1_25ck80 = 1.8 time = 1620
.meas tran vdout1_25ck80 FIND v(dout1_25) AT=1620.1n

* CHECK dout1_26 Vdout1_26ck80 = 0 time = 1620
.meas tran vdout1_26ck80 FIND v(dout1_26) AT=1620.1n

* CHECK dout1_27 Vdout1_27ck80 = 1.8 time = 1620
.meas tran vdout1_27ck80 FIND v(dout1_27) AT=1620.1n

* CHECK dout1_28 Vdout1_28ck80 = 0 time = 1620
.meas tran vdout1_28ck80 FIND v(dout1_28) AT=1620.1n

* CHECK dout1_29 Vdout1_29ck80 = 1.8 time = 1620
.meas tran vdout1_29ck80 FIND v(dout1_29) AT=1620.1n

* CHECK dout1_30 Vdout1_30ck80 = 0 time = 1620
.meas tran vdout1_30ck80 FIND v(dout1_30) AT=1620.1n

* CHECK dout1_31 Vdout1_31ck80 = 0 time = 1620
.meas tran vdout1_31ck80 FIND v(dout1_31) AT=1620.1n

* CHECK dout2_0 Vdout2_0ck80 = 1.8 time = 1620
.meas tran vdout2_0ck80 FIND v(dout2_0) AT=1620.1n

* CHECK dout2_1 Vdout2_1ck80 = 1.8 time = 1620
.meas tran vdout2_1ck80 FIND v(dout2_1) AT=1620.1n

* CHECK dout2_2 Vdout2_2ck80 = 0 time = 1620
.meas tran vdout2_2ck80 FIND v(dout2_2) AT=1620.1n

* CHECK dout2_3 Vdout2_3ck80 = 1.8 time = 1620
.meas tran vdout2_3ck80 FIND v(dout2_3) AT=1620.1n

* CHECK dout2_4 Vdout2_4ck80 = 0 time = 1620
.meas tran vdout2_4ck80 FIND v(dout2_4) AT=1620.1n

* CHECK dout2_5 Vdout2_5ck80 = 0 time = 1620
.meas tran vdout2_5ck80 FIND v(dout2_5) AT=1620.1n

* CHECK dout2_6 Vdout2_6ck80 = 1.8 time = 1620
.meas tran vdout2_6ck80 FIND v(dout2_6) AT=1620.1n

* CHECK dout2_7 Vdout2_7ck80 = 1.8 time = 1620
.meas tran vdout2_7ck80 FIND v(dout2_7) AT=1620.1n

* CHECK dout2_8 Vdout2_8ck80 = 1.8 time = 1620
.meas tran vdout2_8ck80 FIND v(dout2_8) AT=1620.1n

* CHECK dout2_9 Vdout2_9ck80 = 1.8 time = 1620
.meas tran vdout2_9ck80 FIND v(dout2_9) AT=1620.1n

* CHECK dout2_10 Vdout2_10ck80 = 1.8 time = 1620
.meas tran vdout2_10ck80 FIND v(dout2_10) AT=1620.1n

* CHECK dout2_11 Vdout2_11ck80 = 0 time = 1620
.meas tran vdout2_11ck80 FIND v(dout2_11) AT=1620.1n

* CHECK dout2_12 Vdout2_12ck80 = 1.8 time = 1620
.meas tran vdout2_12ck80 FIND v(dout2_12) AT=1620.1n

* CHECK dout2_13 Vdout2_13ck80 = 1.8 time = 1620
.meas tran vdout2_13ck80 FIND v(dout2_13) AT=1620.1n

* CHECK dout2_14 Vdout2_14ck80 = 0 time = 1620
.meas tran vdout2_14ck80 FIND v(dout2_14) AT=1620.1n

* CHECK dout2_15 Vdout2_15ck80 = 1.8 time = 1620
.meas tran vdout2_15ck80 FIND v(dout2_15) AT=1620.1n

* CHECK dout2_16 Vdout2_16ck80 = 1.8 time = 1620
.meas tran vdout2_16ck80 FIND v(dout2_16) AT=1620.1n

* CHECK dout2_17 Vdout2_17ck80 = 0 time = 1620
.meas tran vdout2_17ck80 FIND v(dout2_17) AT=1620.1n

* CHECK dout2_18 Vdout2_18ck80 = 1.8 time = 1620
.meas tran vdout2_18ck80 FIND v(dout2_18) AT=1620.1n

* CHECK dout2_19 Vdout2_19ck80 = 1.8 time = 1620
.meas tran vdout2_19ck80 FIND v(dout2_19) AT=1620.1n

* CHECK dout2_20 Vdout2_20ck80 = 1.8 time = 1620
.meas tran vdout2_20ck80 FIND v(dout2_20) AT=1620.1n

* CHECK dout2_21 Vdout2_21ck80 = 0 time = 1620
.meas tran vdout2_21ck80 FIND v(dout2_21) AT=1620.1n

* CHECK dout2_22 Vdout2_22ck80 = 0 time = 1620
.meas tran vdout2_22ck80 FIND v(dout2_22) AT=1620.1n

* CHECK dout2_23 Vdout2_23ck80 = 1.8 time = 1620
.meas tran vdout2_23ck80 FIND v(dout2_23) AT=1620.1n

* CHECK dout2_24 Vdout2_24ck80 = 1.8 time = 1620
.meas tran vdout2_24ck80 FIND v(dout2_24) AT=1620.1n

* CHECK dout2_25 Vdout2_25ck80 = 0 time = 1620
.meas tran vdout2_25ck80 FIND v(dout2_25) AT=1620.1n

* CHECK dout2_26 Vdout2_26ck80 = 0 time = 1620
.meas tran vdout2_26ck80 FIND v(dout2_26) AT=1620.1n

* CHECK dout2_27 Vdout2_27ck80 = 1.8 time = 1620
.meas tran vdout2_27ck80 FIND v(dout2_27) AT=1620.1n

* CHECK dout2_28 Vdout2_28ck80 = 0 time = 1620
.meas tran vdout2_28ck80 FIND v(dout2_28) AT=1620.1n

* CHECK dout2_29 Vdout2_29ck80 = 1.8 time = 1620
.meas tran vdout2_29ck80 FIND v(dout2_29) AT=1620.1n

* CHECK dout2_30 Vdout2_30ck80 = 0 time = 1620
.meas tran vdout2_30ck80 FIND v(dout2_30) AT=1620.1n

* CHECK dout2_31 Vdout2_31ck80 = 1.8 time = 1620
.meas tran vdout2_31ck80 FIND v(dout2_31) AT=1620.1n

* CHECK dout1_0 Vdout1_0ck81 = 1.8 time = 1640
.meas tran vdout1_0ck81 FIND v(dout1_0) AT=1640.1n

* CHECK dout1_1 Vdout1_1ck81 = 1.8 time = 1640
.meas tran vdout1_1ck81 FIND v(dout1_1) AT=1640.1n

* CHECK dout1_2 Vdout1_2ck81 = 0 time = 1640
.meas tran vdout1_2ck81 FIND v(dout1_2) AT=1640.1n

* CHECK dout1_3 Vdout1_3ck81 = 1.8 time = 1640
.meas tran vdout1_3ck81 FIND v(dout1_3) AT=1640.1n

* CHECK dout1_4 Vdout1_4ck81 = 0 time = 1640
.meas tran vdout1_4ck81 FIND v(dout1_4) AT=1640.1n

* CHECK dout1_5 Vdout1_5ck81 = 0 time = 1640
.meas tran vdout1_5ck81 FIND v(dout1_5) AT=1640.1n

* CHECK dout1_6 Vdout1_6ck81 = 1.8 time = 1640
.meas tran vdout1_6ck81 FIND v(dout1_6) AT=1640.1n

* CHECK dout1_7 Vdout1_7ck81 = 1.8 time = 1640
.meas tran vdout1_7ck81 FIND v(dout1_7) AT=1640.1n

* CHECK dout1_8 Vdout1_8ck81 = 1.8 time = 1640
.meas tran vdout1_8ck81 FIND v(dout1_8) AT=1640.1n

* CHECK dout1_9 Vdout1_9ck81 = 1.8 time = 1640
.meas tran vdout1_9ck81 FIND v(dout1_9) AT=1640.1n

* CHECK dout1_10 Vdout1_10ck81 = 1.8 time = 1640
.meas tran vdout1_10ck81 FIND v(dout1_10) AT=1640.1n

* CHECK dout1_11 Vdout1_11ck81 = 0 time = 1640
.meas tran vdout1_11ck81 FIND v(dout1_11) AT=1640.1n

* CHECK dout1_12 Vdout1_12ck81 = 1.8 time = 1640
.meas tran vdout1_12ck81 FIND v(dout1_12) AT=1640.1n

* CHECK dout1_13 Vdout1_13ck81 = 1.8 time = 1640
.meas tran vdout1_13ck81 FIND v(dout1_13) AT=1640.1n

* CHECK dout1_14 Vdout1_14ck81 = 0 time = 1640
.meas tran vdout1_14ck81 FIND v(dout1_14) AT=1640.1n

* CHECK dout1_15 Vdout1_15ck81 = 1.8 time = 1640
.meas tran vdout1_15ck81 FIND v(dout1_15) AT=1640.1n

* CHECK dout1_16 Vdout1_16ck81 = 1.8 time = 1640
.meas tran vdout1_16ck81 FIND v(dout1_16) AT=1640.1n

* CHECK dout1_17 Vdout1_17ck81 = 0 time = 1640
.meas tran vdout1_17ck81 FIND v(dout1_17) AT=1640.1n

* CHECK dout1_18 Vdout1_18ck81 = 1.8 time = 1640
.meas tran vdout1_18ck81 FIND v(dout1_18) AT=1640.1n

* CHECK dout1_19 Vdout1_19ck81 = 1.8 time = 1640
.meas tran vdout1_19ck81 FIND v(dout1_19) AT=1640.1n

* CHECK dout1_20 Vdout1_20ck81 = 1.8 time = 1640
.meas tran vdout1_20ck81 FIND v(dout1_20) AT=1640.1n

* CHECK dout1_21 Vdout1_21ck81 = 0 time = 1640
.meas tran vdout1_21ck81 FIND v(dout1_21) AT=1640.1n

* CHECK dout1_22 Vdout1_22ck81 = 0 time = 1640
.meas tran vdout1_22ck81 FIND v(dout1_22) AT=1640.1n

* CHECK dout1_23 Vdout1_23ck81 = 1.8 time = 1640
.meas tran vdout1_23ck81 FIND v(dout1_23) AT=1640.1n

* CHECK dout1_24 Vdout1_24ck81 = 1.8 time = 1640
.meas tran vdout1_24ck81 FIND v(dout1_24) AT=1640.1n

* CHECK dout1_25 Vdout1_25ck81 = 0 time = 1640
.meas tran vdout1_25ck81 FIND v(dout1_25) AT=1640.1n

* CHECK dout1_26 Vdout1_26ck81 = 0 time = 1640
.meas tran vdout1_26ck81 FIND v(dout1_26) AT=1640.1n

* CHECK dout1_27 Vdout1_27ck81 = 1.8 time = 1640
.meas tran vdout1_27ck81 FIND v(dout1_27) AT=1640.1n

* CHECK dout1_28 Vdout1_28ck81 = 0 time = 1640
.meas tran vdout1_28ck81 FIND v(dout1_28) AT=1640.1n

* CHECK dout1_29 Vdout1_29ck81 = 1.8 time = 1640
.meas tran vdout1_29ck81 FIND v(dout1_29) AT=1640.1n

* CHECK dout1_30 Vdout1_30ck81 = 0 time = 1640
.meas tran vdout1_30ck81 FIND v(dout1_30) AT=1640.1n

* CHECK dout1_31 Vdout1_31ck81 = 1.8 time = 1640
.meas tran vdout1_31ck81 FIND v(dout1_31) AT=1640.1n

* CHECK dout2_0 Vdout2_0ck81 = 1.8 time = 1640
.meas tran vdout2_0ck81 FIND v(dout2_0) AT=1640.1n

* CHECK dout2_1 Vdout2_1ck81 = 0 time = 1640
.meas tran vdout2_1ck81 FIND v(dout2_1) AT=1640.1n

* CHECK dout2_2 Vdout2_2ck81 = 0 time = 1640
.meas tran vdout2_2ck81 FIND v(dout2_2) AT=1640.1n

* CHECK dout2_3 Vdout2_3ck81 = 0 time = 1640
.meas tran vdout2_3ck81 FIND v(dout2_3) AT=1640.1n

* CHECK dout2_4 Vdout2_4ck81 = 1.8 time = 1640
.meas tran vdout2_4ck81 FIND v(dout2_4) AT=1640.1n

* CHECK dout2_5 Vdout2_5ck81 = 0 time = 1640
.meas tran vdout2_5ck81 FIND v(dout2_5) AT=1640.1n

* CHECK dout2_6 Vdout2_6ck81 = 1.8 time = 1640
.meas tran vdout2_6ck81 FIND v(dout2_6) AT=1640.1n

* CHECK dout2_7 Vdout2_7ck81 = 0 time = 1640
.meas tran vdout2_7ck81 FIND v(dout2_7) AT=1640.1n

* CHECK dout2_8 Vdout2_8ck81 = 0 time = 1640
.meas tran vdout2_8ck81 FIND v(dout2_8) AT=1640.1n

* CHECK dout2_9 Vdout2_9ck81 = 0 time = 1640
.meas tran vdout2_9ck81 FIND v(dout2_9) AT=1640.1n

* CHECK dout2_10 Vdout2_10ck81 = 1.8 time = 1640
.meas tran vdout2_10ck81 FIND v(dout2_10) AT=1640.1n

* CHECK dout2_11 Vdout2_11ck81 = 0 time = 1640
.meas tran vdout2_11ck81 FIND v(dout2_11) AT=1640.1n

* CHECK dout2_12 Vdout2_12ck81 = 0 time = 1640
.meas tran vdout2_12ck81 FIND v(dout2_12) AT=1640.1n

* CHECK dout2_13 Vdout2_13ck81 = 1.8 time = 1640
.meas tran vdout2_13ck81 FIND v(dout2_13) AT=1640.1n

* CHECK dout2_14 Vdout2_14ck81 = 0 time = 1640
.meas tran vdout2_14ck81 FIND v(dout2_14) AT=1640.1n

* CHECK dout2_15 Vdout2_15ck81 = 0 time = 1640
.meas tran vdout2_15ck81 FIND v(dout2_15) AT=1640.1n

* CHECK dout2_16 Vdout2_16ck81 = 0 time = 1640
.meas tran vdout2_16ck81 FIND v(dout2_16) AT=1640.1n

* CHECK dout2_17 Vdout2_17ck81 = 0 time = 1640
.meas tran vdout2_17ck81 FIND v(dout2_17) AT=1640.1n

* CHECK dout2_18 Vdout2_18ck81 = 1.8 time = 1640
.meas tran vdout2_18ck81 FIND v(dout2_18) AT=1640.1n

* CHECK dout2_19 Vdout2_19ck81 = 0 time = 1640
.meas tran vdout2_19ck81 FIND v(dout2_19) AT=1640.1n

* CHECK dout2_20 Vdout2_20ck81 = 0 time = 1640
.meas tran vdout2_20ck81 FIND v(dout2_20) AT=1640.1n

* CHECK dout2_21 Vdout2_21ck81 = 0 time = 1640
.meas tran vdout2_21ck81 FIND v(dout2_21) AT=1640.1n

* CHECK dout2_22 Vdout2_22ck81 = 1.8 time = 1640
.meas tran vdout2_22ck81 FIND v(dout2_22) AT=1640.1n

* CHECK dout2_23 Vdout2_23ck81 = 0 time = 1640
.meas tran vdout2_23ck81 FIND v(dout2_23) AT=1640.1n

* CHECK dout2_24 Vdout2_24ck81 = 0 time = 1640
.meas tran vdout2_24ck81 FIND v(dout2_24) AT=1640.1n

* CHECK dout2_25 Vdout2_25ck81 = 1.8 time = 1640
.meas tran vdout2_25ck81 FIND v(dout2_25) AT=1640.1n

* CHECK dout2_26 Vdout2_26ck81 = 0 time = 1640
.meas tran vdout2_26ck81 FIND v(dout2_26) AT=1640.1n

* CHECK dout2_27 Vdout2_27ck81 = 1.8 time = 1640
.meas tran vdout2_27ck81 FIND v(dout2_27) AT=1640.1n

* CHECK dout2_28 Vdout2_28ck81 = 0 time = 1640
.meas tran vdout2_28ck81 FIND v(dout2_28) AT=1640.1n

* CHECK dout2_29 Vdout2_29ck81 = 1.8 time = 1640
.meas tran vdout2_29ck81 FIND v(dout2_29) AT=1640.1n

* CHECK dout2_30 Vdout2_30ck81 = 0 time = 1640
.meas tran vdout2_30ck81 FIND v(dout2_30) AT=1640.1n

* CHECK dout2_31 Vdout2_31ck81 = 0 time = 1640
.meas tran vdout2_31ck81 FIND v(dout2_31) AT=1640.1n

* CHECK dout1_0 Vdout1_0ck82 = 1.8 time = 1660
.meas tran vdout1_0ck82 FIND v(dout1_0) AT=1660.1n

* CHECK dout1_1 Vdout1_1ck82 = 1.8 time = 1660
.meas tran vdout1_1ck82 FIND v(dout1_1) AT=1660.1n

* CHECK dout1_2 Vdout1_2ck82 = 0 time = 1660
.meas tran vdout1_2ck82 FIND v(dout1_2) AT=1660.1n

* CHECK dout1_3 Vdout1_3ck82 = 1.8 time = 1660
.meas tran vdout1_3ck82 FIND v(dout1_3) AT=1660.1n

* CHECK dout1_4 Vdout1_4ck82 = 0 time = 1660
.meas tran vdout1_4ck82 FIND v(dout1_4) AT=1660.1n

* CHECK dout1_5 Vdout1_5ck82 = 0 time = 1660
.meas tran vdout1_5ck82 FIND v(dout1_5) AT=1660.1n

* CHECK dout1_6 Vdout1_6ck82 = 1.8 time = 1660
.meas tran vdout1_6ck82 FIND v(dout1_6) AT=1660.1n

* CHECK dout1_7 Vdout1_7ck82 = 1.8 time = 1660
.meas tran vdout1_7ck82 FIND v(dout1_7) AT=1660.1n

* CHECK dout1_8 Vdout1_8ck82 = 1.8 time = 1660
.meas tran vdout1_8ck82 FIND v(dout1_8) AT=1660.1n

* CHECK dout1_9 Vdout1_9ck82 = 1.8 time = 1660
.meas tran vdout1_9ck82 FIND v(dout1_9) AT=1660.1n

* CHECK dout1_10 Vdout1_10ck82 = 1.8 time = 1660
.meas tran vdout1_10ck82 FIND v(dout1_10) AT=1660.1n

* CHECK dout1_11 Vdout1_11ck82 = 0 time = 1660
.meas tran vdout1_11ck82 FIND v(dout1_11) AT=1660.1n

* CHECK dout1_12 Vdout1_12ck82 = 1.8 time = 1660
.meas tran vdout1_12ck82 FIND v(dout1_12) AT=1660.1n

* CHECK dout1_13 Vdout1_13ck82 = 1.8 time = 1660
.meas tran vdout1_13ck82 FIND v(dout1_13) AT=1660.1n

* CHECK dout1_14 Vdout1_14ck82 = 0 time = 1660
.meas tran vdout1_14ck82 FIND v(dout1_14) AT=1660.1n

* CHECK dout1_15 Vdout1_15ck82 = 1.8 time = 1660
.meas tran vdout1_15ck82 FIND v(dout1_15) AT=1660.1n

* CHECK dout1_16 Vdout1_16ck82 = 1.8 time = 1660
.meas tran vdout1_16ck82 FIND v(dout1_16) AT=1660.1n

* CHECK dout1_17 Vdout1_17ck82 = 0 time = 1660
.meas tran vdout1_17ck82 FIND v(dout1_17) AT=1660.1n

* CHECK dout1_18 Vdout1_18ck82 = 1.8 time = 1660
.meas tran vdout1_18ck82 FIND v(dout1_18) AT=1660.1n

* CHECK dout1_19 Vdout1_19ck82 = 1.8 time = 1660
.meas tran vdout1_19ck82 FIND v(dout1_19) AT=1660.1n

* CHECK dout1_20 Vdout1_20ck82 = 1.8 time = 1660
.meas tran vdout1_20ck82 FIND v(dout1_20) AT=1660.1n

* CHECK dout1_21 Vdout1_21ck82 = 0 time = 1660
.meas tran vdout1_21ck82 FIND v(dout1_21) AT=1660.1n

* CHECK dout1_22 Vdout1_22ck82 = 0 time = 1660
.meas tran vdout1_22ck82 FIND v(dout1_22) AT=1660.1n

* CHECK dout1_23 Vdout1_23ck82 = 1.8 time = 1660
.meas tran vdout1_23ck82 FIND v(dout1_23) AT=1660.1n

* CHECK dout1_24 Vdout1_24ck82 = 1.8 time = 1660
.meas tran vdout1_24ck82 FIND v(dout1_24) AT=1660.1n

* CHECK dout1_25 Vdout1_25ck82 = 0 time = 1660
.meas tran vdout1_25ck82 FIND v(dout1_25) AT=1660.1n

* CHECK dout1_26 Vdout1_26ck82 = 0 time = 1660
.meas tran vdout1_26ck82 FIND v(dout1_26) AT=1660.1n

* CHECK dout1_27 Vdout1_27ck82 = 1.8 time = 1660
.meas tran vdout1_27ck82 FIND v(dout1_27) AT=1660.1n

* CHECK dout1_28 Vdout1_28ck82 = 0 time = 1660
.meas tran vdout1_28ck82 FIND v(dout1_28) AT=1660.1n

* CHECK dout1_29 Vdout1_29ck82 = 1.8 time = 1660
.meas tran vdout1_29ck82 FIND v(dout1_29) AT=1660.1n

* CHECK dout1_30 Vdout1_30ck82 = 0 time = 1660
.meas tran vdout1_30ck82 FIND v(dout1_30) AT=1660.1n

* CHECK dout1_31 Vdout1_31ck82 = 1.8 time = 1660
.meas tran vdout1_31ck82 FIND v(dout1_31) AT=1660.1n

* CHECK dout2_0 Vdout2_0ck82 = 1.8 time = 1660
.meas tran vdout2_0ck82 FIND v(dout2_0) AT=1660.1n

* CHECK dout2_1 Vdout2_1ck82 = 1.8 time = 1660
.meas tran vdout2_1ck82 FIND v(dout2_1) AT=1660.1n

* CHECK dout2_2 Vdout2_2ck82 = 1.8 time = 1660
.meas tran vdout2_2ck82 FIND v(dout2_2) AT=1660.1n

* CHECK dout2_3 Vdout2_3ck82 = 0 time = 1660
.meas tran vdout2_3ck82 FIND v(dout2_3) AT=1660.1n

* CHECK dout2_4 Vdout2_4ck82 = 0 time = 1660
.meas tran vdout2_4ck82 FIND v(dout2_4) AT=1660.1n

* CHECK dout2_5 Vdout2_5ck82 = 0 time = 1660
.meas tran vdout2_5ck82 FIND v(dout2_5) AT=1660.1n

* CHECK dout2_6 Vdout2_6ck82 = 0 time = 1660
.meas tran vdout2_6ck82 FIND v(dout2_6) AT=1660.1n

* CHECK dout2_7 Vdout2_7ck82 = 1.8 time = 1660
.meas tran vdout2_7ck82 FIND v(dout2_7) AT=1660.1n

* CHECK dout2_8 Vdout2_8ck82 = 1.8 time = 1660
.meas tran vdout2_8ck82 FIND v(dout2_8) AT=1660.1n

* CHECK dout2_9 Vdout2_9ck82 = 0 time = 1660
.meas tran vdout2_9ck82 FIND v(dout2_9) AT=1660.1n

* CHECK dout2_10 Vdout2_10ck82 = 1.8 time = 1660
.meas tran vdout2_10ck82 FIND v(dout2_10) AT=1660.1n

* CHECK dout2_11 Vdout2_11ck82 = 1.8 time = 1660
.meas tran vdout2_11ck82 FIND v(dout2_11) AT=1660.1n

* CHECK dout2_12 Vdout2_12ck82 = 0 time = 1660
.meas tran vdout2_12ck82 FIND v(dout2_12) AT=1660.1n

* CHECK dout2_13 Vdout2_13ck82 = 0 time = 1660
.meas tran vdout2_13ck82 FIND v(dout2_13) AT=1660.1n

* CHECK dout2_14 Vdout2_14ck82 = 0 time = 1660
.meas tran vdout2_14ck82 FIND v(dout2_14) AT=1660.1n

* CHECK dout2_15 Vdout2_15ck82 = 0 time = 1660
.meas tran vdout2_15ck82 FIND v(dout2_15) AT=1660.1n

* CHECK dout2_16 Vdout2_16ck82 = 1.8 time = 1660
.meas tran vdout2_16ck82 FIND v(dout2_16) AT=1660.1n

* CHECK dout2_17 Vdout2_17ck82 = 0 time = 1660
.meas tran vdout2_17ck82 FIND v(dout2_17) AT=1660.1n

* CHECK dout2_18 Vdout2_18ck82 = 0 time = 1660
.meas tran vdout2_18ck82 FIND v(dout2_18) AT=1660.1n

* CHECK dout2_19 Vdout2_19ck82 = 0 time = 1660
.meas tran vdout2_19ck82 FIND v(dout2_19) AT=1660.1n

* CHECK dout2_20 Vdout2_20ck82 = 1.8 time = 1660
.meas tran vdout2_20ck82 FIND v(dout2_20) AT=1660.1n

* CHECK dout2_21 Vdout2_21ck82 = 1.8 time = 1660
.meas tran vdout2_21ck82 FIND v(dout2_21) AT=1660.1n

* CHECK dout2_22 Vdout2_22ck82 = 0 time = 1660
.meas tran vdout2_22ck82 FIND v(dout2_22) AT=1660.1n

* CHECK dout2_23 Vdout2_23ck82 = 0 time = 1660
.meas tran vdout2_23ck82 FIND v(dout2_23) AT=1660.1n

* CHECK dout2_24 Vdout2_24ck82 = 0 time = 1660
.meas tran vdout2_24ck82 FIND v(dout2_24) AT=1660.1n

* CHECK dout2_25 Vdout2_25ck82 = 0 time = 1660
.meas tran vdout2_25ck82 FIND v(dout2_25) AT=1660.1n

* CHECK dout2_26 Vdout2_26ck82 = 0 time = 1660
.meas tran vdout2_26ck82 FIND v(dout2_26) AT=1660.1n

* CHECK dout2_27 Vdout2_27ck82 = 0 time = 1660
.meas tran vdout2_27ck82 FIND v(dout2_27) AT=1660.1n

* CHECK dout2_28 Vdout2_28ck82 = 1.8 time = 1660
.meas tran vdout2_28ck82 FIND v(dout2_28) AT=1660.1n

* CHECK dout2_29 Vdout2_29ck82 = 1.8 time = 1660
.meas tran vdout2_29ck82 FIND v(dout2_29) AT=1660.1n

* CHECK dout2_30 Vdout2_30ck82 = 0 time = 1660
.meas tran vdout2_30ck82 FIND v(dout2_30) AT=1660.1n

* CHECK dout2_31 Vdout2_31ck82 = 0 time = 1660
.meas tran vdout2_31ck82 FIND v(dout2_31) AT=1660.1n

* CHECK dout1_0 Vdout1_0ck84 = 1.8 time = 1700
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=1700.1n

* CHECK dout1_1 Vdout1_1ck84 = 0 time = 1700
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=1700.1n

* CHECK dout1_2 Vdout1_2ck84 = 1.8 time = 1700
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=1700.1n

* CHECK dout1_3 Vdout1_3ck84 = 0 time = 1700
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=1700.1n

* CHECK dout1_4 Vdout1_4ck84 = 0 time = 1700
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=1700.1n

* CHECK dout1_5 Vdout1_5ck84 = 1.8 time = 1700
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=1700.1n

* CHECK dout1_6 Vdout1_6ck84 = 0 time = 1700
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=1700.1n

* CHECK dout1_7 Vdout1_7ck84 = 1.8 time = 1700
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=1700.1n

* CHECK dout1_8 Vdout1_8ck84 = 1.8 time = 1700
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=1700.1n

* CHECK dout1_9 Vdout1_9ck84 = 0 time = 1700
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=1700.1n

* CHECK dout1_10 Vdout1_10ck84 = 1.8 time = 1700
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=1700.1n

* CHECK dout1_11 Vdout1_11ck84 = 0 time = 1700
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=1700.1n

* CHECK dout1_12 Vdout1_12ck84 = 1.8 time = 1700
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=1700.1n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 1700
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=1700.1n

* CHECK dout1_14 Vdout1_14ck84 = 1.8 time = 1700
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=1700.1n

* CHECK dout1_15 Vdout1_15ck84 = 1.8 time = 1700
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=1700.1n

* CHECK dout1_16 Vdout1_16ck84 = 0 time = 1700
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=1700.1n

* CHECK dout1_17 Vdout1_17ck84 = 0 time = 1700
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=1700.1n

* CHECK dout1_18 Vdout1_18ck84 = 0 time = 1700
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=1700.1n

* CHECK dout1_19 Vdout1_19ck84 = 0 time = 1700
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=1700.1n

* CHECK dout1_20 Vdout1_20ck84 = 1.8 time = 1700
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=1700.1n

* CHECK dout1_21 Vdout1_21ck84 = 1.8 time = 1700
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=1700.1n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 1700
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=1700.1n

* CHECK dout1_23 Vdout1_23ck84 = 1.8 time = 1700
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=1700.1n

* CHECK dout1_24 Vdout1_24ck84 = 1.8 time = 1700
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=1700.1n

* CHECK dout1_25 Vdout1_25ck84 = 1.8 time = 1700
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=1700.1n

* CHECK dout1_26 Vdout1_26ck84 = 0 time = 1700
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=1700.1n

* CHECK dout1_27 Vdout1_27ck84 = 0 time = 1700
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=1700.1n

* CHECK dout1_28 Vdout1_28ck84 = 0 time = 1700
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=1700.1n

* CHECK dout1_29 Vdout1_29ck84 = 0 time = 1700
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=1700.1n

* CHECK dout1_30 Vdout1_30ck84 = 1.8 time = 1700
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=1700.1n

* CHECK dout1_31 Vdout1_31ck84 = 1.8 time = 1700
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=1700.1n

* CHECK dout2_0 Vdout2_0ck84 = 1.8 time = 1700
.meas tran vdout2_0ck84 FIND v(dout2_0) AT=1700.1n

* CHECK dout2_1 Vdout2_1ck84 = 1.8 time = 1700
.meas tran vdout2_1ck84 FIND v(dout2_1) AT=1700.1n

* CHECK dout2_2 Vdout2_2ck84 = 0 time = 1700
.meas tran vdout2_2ck84 FIND v(dout2_2) AT=1700.1n

* CHECK dout2_3 Vdout2_3ck84 = 1.8 time = 1700
.meas tran vdout2_3ck84 FIND v(dout2_3) AT=1700.1n

* CHECK dout2_4 Vdout2_4ck84 = 0 time = 1700
.meas tran vdout2_4ck84 FIND v(dout2_4) AT=1700.1n

* CHECK dout2_5 Vdout2_5ck84 = 0 time = 1700
.meas tran vdout2_5ck84 FIND v(dout2_5) AT=1700.1n

* CHECK dout2_6 Vdout2_6ck84 = 1.8 time = 1700
.meas tran vdout2_6ck84 FIND v(dout2_6) AT=1700.1n

* CHECK dout2_7 Vdout2_7ck84 = 1.8 time = 1700
.meas tran vdout2_7ck84 FIND v(dout2_7) AT=1700.1n

* CHECK dout2_8 Vdout2_8ck84 = 1.8 time = 1700
.meas tran vdout2_8ck84 FIND v(dout2_8) AT=1700.1n

* CHECK dout2_9 Vdout2_9ck84 = 1.8 time = 1700
.meas tran vdout2_9ck84 FIND v(dout2_9) AT=1700.1n

* CHECK dout2_10 Vdout2_10ck84 = 1.8 time = 1700
.meas tran vdout2_10ck84 FIND v(dout2_10) AT=1700.1n

* CHECK dout2_11 Vdout2_11ck84 = 0 time = 1700
.meas tran vdout2_11ck84 FIND v(dout2_11) AT=1700.1n

* CHECK dout2_12 Vdout2_12ck84 = 1.8 time = 1700
.meas tran vdout2_12ck84 FIND v(dout2_12) AT=1700.1n

* CHECK dout2_13 Vdout2_13ck84 = 1.8 time = 1700
.meas tran vdout2_13ck84 FIND v(dout2_13) AT=1700.1n

* CHECK dout2_14 Vdout2_14ck84 = 0 time = 1700
.meas tran vdout2_14ck84 FIND v(dout2_14) AT=1700.1n

* CHECK dout2_15 Vdout2_15ck84 = 1.8 time = 1700
.meas tran vdout2_15ck84 FIND v(dout2_15) AT=1700.1n

* CHECK dout2_16 Vdout2_16ck84 = 1.8 time = 1700
.meas tran vdout2_16ck84 FIND v(dout2_16) AT=1700.1n

* CHECK dout2_17 Vdout2_17ck84 = 0 time = 1700
.meas tran vdout2_17ck84 FIND v(dout2_17) AT=1700.1n

* CHECK dout2_18 Vdout2_18ck84 = 1.8 time = 1700
.meas tran vdout2_18ck84 FIND v(dout2_18) AT=1700.1n

* CHECK dout2_19 Vdout2_19ck84 = 1.8 time = 1700
.meas tran vdout2_19ck84 FIND v(dout2_19) AT=1700.1n

* CHECK dout2_20 Vdout2_20ck84 = 1.8 time = 1700
.meas tran vdout2_20ck84 FIND v(dout2_20) AT=1700.1n

* CHECK dout2_21 Vdout2_21ck84 = 0 time = 1700
.meas tran vdout2_21ck84 FIND v(dout2_21) AT=1700.1n

* CHECK dout2_22 Vdout2_22ck84 = 0 time = 1700
.meas tran vdout2_22ck84 FIND v(dout2_22) AT=1700.1n

* CHECK dout2_23 Vdout2_23ck84 = 1.8 time = 1700
.meas tran vdout2_23ck84 FIND v(dout2_23) AT=1700.1n

* CHECK dout2_24 Vdout2_24ck84 = 1.8 time = 1700
.meas tran vdout2_24ck84 FIND v(dout2_24) AT=1700.1n

* CHECK dout2_25 Vdout2_25ck84 = 0 time = 1700
.meas tran vdout2_25ck84 FIND v(dout2_25) AT=1700.1n

* CHECK dout2_26 Vdout2_26ck84 = 0 time = 1700
.meas tran vdout2_26ck84 FIND v(dout2_26) AT=1700.1n

* CHECK dout2_27 Vdout2_27ck84 = 1.8 time = 1700
.meas tran vdout2_27ck84 FIND v(dout2_27) AT=1700.1n

* CHECK dout2_28 Vdout2_28ck84 = 0 time = 1700
.meas tran vdout2_28ck84 FIND v(dout2_28) AT=1700.1n

* CHECK dout2_29 Vdout2_29ck84 = 1.8 time = 1700
.meas tran vdout2_29ck84 FIND v(dout2_29) AT=1700.1n

* CHECK dout2_30 Vdout2_30ck84 = 0 time = 1700
.meas tran vdout2_30ck84 FIND v(dout2_30) AT=1700.1n

* CHECK dout2_31 Vdout2_31ck84 = 1.8 time = 1700
.meas tran vdout2_31ck84 FIND v(dout2_31) AT=1700.1n

* CHECK dout1_0 Vdout1_0ck85 = 1.8 time = 1720
.meas tran vdout1_0ck85 FIND v(dout1_0) AT=1720.1n

* CHECK dout1_1 Vdout1_1ck85 = 1.8 time = 1720
.meas tran vdout1_1ck85 FIND v(dout1_1) AT=1720.1n

* CHECK dout1_2 Vdout1_2ck85 = 1.8 time = 1720
.meas tran vdout1_2ck85 FIND v(dout1_2) AT=1720.1n

* CHECK dout1_3 Vdout1_3ck85 = 0 time = 1720
.meas tran vdout1_3ck85 FIND v(dout1_3) AT=1720.1n

* CHECK dout1_4 Vdout1_4ck85 = 0 time = 1720
.meas tran vdout1_4ck85 FIND v(dout1_4) AT=1720.1n

* CHECK dout1_5 Vdout1_5ck85 = 0 time = 1720
.meas tran vdout1_5ck85 FIND v(dout1_5) AT=1720.1n

* CHECK dout1_6 Vdout1_6ck85 = 0 time = 1720
.meas tran vdout1_6ck85 FIND v(dout1_6) AT=1720.1n

* CHECK dout1_7 Vdout1_7ck85 = 1.8 time = 1720
.meas tran vdout1_7ck85 FIND v(dout1_7) AT=1720.1n

* CHECK dout1_8 Vdout1_8ck85 = 1.8 time = 1720
.meas tran vdout1_8ck85 FIND v(dout1_8) AT=1720.1n

* CHECK dout1_9 Vdout1_9ck85 = 1.8 time = 1720
.meas tran vdout1_9ck85 FIND v(dout1_9) AT=1720.1n

* CHECK dout1_10 Vdout1_10ck85 = 0 time = 1720
.meas tran vdout1_10ck85 FIND v(dout1_10) AT=1720.1n

* CHECK dout1_11 Vdout1_11ck85 = 0 time = 1720
.meas tran vdout1_11ck85 FIND v(dout1_11) AT=1720.1n

* CHECK dout1_12 Vdout1_12ck85 = 0 time = 1720
.meas tran vdout1_12ck85 FIND v(dout1_12) AT=1720.1n

* CHECK dout1_13 Vdout1_13ck85 = 0 time = 1720
.meas tran vdout1_13ck85 FIND v(dout1_13) AT=1720.1n

* CHECK dout1_14 Vdout1_14ck85 = 0 time = 1720
.meas tran vdout1_14ck85 FIND v(dout1_14) AT=1720.1n

* CHECK dout1_15 Vdout1_15ck85 = 1.8 time = 1720
.meas tran vdout1_15ck85 FIND v(dout1_15) AT=1720.1n

* CHECK dout1_16 Vdout1_16ck85 = 1.8 time = 1720
.meas tran vdout1_16ck85 FIND v(dout1_16) AT=1720.1n

* CHECK dout1_17 Vdout1_17ck85 = 1.8 time = 1720
.meas tran vdout1_17ck85 FIND v(dout1_17) AT=1720.1n

* CHECK dout1_18 Vdout1_18ck85 = 1.8 time = 1720
.meas tran vdout1_18ck85 FIND v(dout1_18) AT=1720.1n

* CHECK dout1_19 Vdout1_19ck85 = 1.8 time = 1720
.meas tran vdout1_19ck85 FIND v(dout1_19) AT=1720.1n

* CHECK dout1_20 Vdout1_20ck85 = 0 time = 1720
.meas tran vdout1_20ck85 FIND v(dout1_20) AT=1720.1n

* CHECK dout1_21 Vdout1_21ck85 = 0 time = 1720
.meas tran vdout1_21ck85 FIND v(dout1_21) AT=1720.1n

* CHECK dout1_22 Vdout1_22ck85 = 0 time = 1720
.meas tran vdout1_22ck85 FIND v(dout1_22) AT=1720.1n

* CHECK dout1_23 Vdout1_23ck85 = 1.8 time = 1720
.meas tran vdout1_23ck85 FIND v(dout1_23) AT=1720.1n

* CHECK dout1_24 Vdout1_24ck85 = 0 time = 1720
.meas tran vdout1_24ck85 FIND v(dout1_24) AT=1720.1n

* CHECK dout1_25 Vdout1_25ck85 = 0 time = 1720
.meas tran vdout1_25ck85 FIND v(dout1_25) AT=1720.1n

* CHECK dout1_26 Vdout1_26ck85 = 0 time = 1720
.meas tran vdout1_26ck85 FIND v(dout1_26) AT=1720.1n

* CHECK dout1_27 Vdout1_27ck85 = 1.8 time = 1720
.meas tran vdout1_27ck85 FIND v(dout1_27) AT=1720.1n

* CHECK dout1_28 Vdout1_28ck85 = 0 time = 1720
.meas tran vdout1_28ck85 FIND v(dout1_28) AT=1720.1n

* CHECK dout1_29 Vdout1_29ck85 = 1.8 time = 1720
.meas tran vdout1_29ck85 FIND v(dout1_29) AT=1720.1n

* CHECK dout1_30 Vdout1_30ck85 = 1.8 time = 1720
.meas tran vdout1_30ck85 FIND v(dout1_30) AT=1720.1n

* CHECK dout1_31 Vdout1_31ck85 = 1.8 time = 1720
.meas tran vdout1_31ck85 FIND v(dout1_31) AT=1720.1n

* CHECK dout2_0 Vdout2_0ck85 = 1.8 time = 1720
.meas tran vdout2_0ck85 FIND v(dout2_0) AT=1720.1n

* CHECK dout2_1 Vdout2_1ck85 = 1.8 time = 1720
.meas tran vdout2_1ck85 FIND v(dout2_1) AT=1720.1n

* CHECK dout2_2 Vdout2_2ck85 = 0 time = 1720
.meas tran vdout2_2ck85 FIND v(dout2_2) AT=1720.1n

* CHECK dout2_3 Vdout2_3ck85 = 1.8 time = 1720
.meas tran vdout2_3ck85 FIND v(dout2_3) AT=1720.1n

* CHECK dout2_4 Vdout2_4ck85 = 0 time = 1720
.meas tran vdout2_4ck85 FIND v(dout2_4) AT=1720.1n

* CHECK dout2_5 Vdout2_5ck85 = 0 time = 1720
.meas tran vdout2_5ck85 FIND v(dout2_5) AT=1720.1n

* CHECK dout2_6 Vdout2_6ck85 = 1.8 time = 1720
.meas tran vdout2_6ck85 FIND v(dout2_6) AT=1720.1n

* CHECK dout2_7 Vdout2_7ck85 = 1.8 time = 1720
.meas tran vdout2_7ck85 FIND v(dout2_7) AT=1720.1n

* CHECK dout2_8 Vdout2_8ck85 = 1.8 time = 1720
.meas tran vdout2_8ck85 FIND v(dout2_8) AT=1720.1n

* CHECK dout2_9 Vdout2_9ck85 = 1.8 time = 1720
.meas tran vdout2_9ck85 FIND v(dout2_9) AT=1720.1n

* CHECK dout2_10 Vdout2_10ck85 = 1.8 time = 1720
.meas tran vdout2_10ck85 FIND v(dout2_10) AT=1720.1n

* CHECK dout2_11 Vdout2_11ck85 = 0 time = 1720
.meas tran vdout2_11ck85 FIND v(dout2_11) AT=1720.1n

* CHECK dout2_12 Vdout2_12ck85 = 1.8 time = 1720
.meas tran vdout2_12ck85 FIND v(dout2_12) AT=1720.1n

* CHECK dout2_13 Vdout2_13ck85 = 1.8 time = 1720
.meas tran vdout2_13ck85 FIND v(dout2_13) AT=1720.1n

* CHECK dout2_14 Vdout2_14ck85 = 0 time = 1720
.meas tran vdout2_14ck85 FIND v(dout2_14) AT=1720.1n

* CHECK dout2_15 Vdout2_15ck85 = 1.8 time = 1720
.meas tran vdout2_15ck85 FIND v(dout2_15) AT=1720.1n

* CHECK dout2_16 Vdout2_16ck85 = 1.8 time = 1720
.meas tran vdout2_16ck85 FIND v(dout2_16) AT=1720.1n

* CHECK dout2_17 Vdout2_17ck85 = 0 time = 1720
.meas tran vdout2_17ck85 FIND v(dout2_17) AT=1720.1n

* CHECK dout2_18 Vdout2_18ck85 = 1.8 time = 1720
.meas tran vdout2_18ck85 FIND v(dout2_18) AT=1720.1n

* CHECK dout2_19 Vdout2_19ck85 = 1.8 time = 1720
.meas tran vdout2_19ck85 FIND v(dout2_19) AT=1720.1n

* CHECK dout2_20 Vdout2_20ck85 = 1.8 time = 1720
.meas tran vdout2_20ck85 FIND v(dout2_20) AT=1720.1n

* CHECK dout2_21 Vdout2_21ck85 = 0 time = 1720
.meas tran vdout2_21ck85 FIND v(dout2_21) AT=1720.1n

* CHECK dout2_22 Vdout2_22ck85 = 0 time = 1720
.meas tran vdout2_22ck85 FIND v(dout2_22) AT=1720.1n

* CHECK dout2_23 Vdout2_23ck85 = 1.8 time = 1720
.meas tran vdout2_23ck85 FIND v(dout2_23) AT=1720.1n

* CHECK dout2_24 Vdout2_24ck85 = 1.8 time = 1720
.meas tran vdout2_24ck85 FIND v(dout2_24) AT=1720.1n

* CHECK dout2_25 Vdout2_25ck85 = 0 time = 1720
.meas tran vdout2_25ck85 FIND v(dout2_25) AT=1720.1n

* CHECK dout2_26 Vdout2_26ck85 = 0 time = 1720
.meas tran vdout2_26ck85 FIND v(dout2_26) AT=1720.1n

* CHECK dout2_27 Vdout2_27ck85 = 1.8 time = 1720
.meas tran vdout2_27ck85 FIND v(dout2_27) AT=1720.1n

* CHECK dout2_28 Vdout2_28ck85 = 0 time = 1720
.meas tran vdout2_28ck85 FIND v(dout2_28) AT=1720.1n

* CHECK dout2_29 Vdout2_29ck85 = 1.8 time = 1720
.meas tran vdout2_29ck85 FIND v(dout2_29) AT=1720.1n

* CHECK dout2_30 Vdout2_30ck85 = 0 time = 1720
.meas tran vdout2_30ck85 FIND v(dout2_30) AT=1720.1n

* CHECK dout2_31 Vdout2_31ck85 = 1.8 time = 1720
.meas tran vdout2_31ck85 FIND v(dout2_31) AT=1720.1n

* CHECK dout1_0 Vdout1_0ck86 = 1.8 time = 1740
.meas tran vdout1_0ck86 FIND v(dout1_0) AT=1740.1n

* CHECK dout1_1 Vdout1_1ck86 = 0 time = 1740
.meas tran vdout1_1ck86 FIND v(dout1_1) AT=1740.1n

* CHECK dout1_2 Vdout1_2ck86 = 1.8 time = 1740
.meas tran vdout1_2ck86 FIND v(dout1_2) AT=1740.1n

* CHECK dout1_3 Vdout1_3ck86 = 1.8 time = 1740
.meas tran vdout1_3ck86 FIND v(dout1_3) AT=1740.1n

* CHECK dout1_4 Vdout1_4ck86 = 1.8 time = 1740
.meas tran vdout1_4ck86 FIND v(dout1_4) AT=1740.1n

* CHECK dout1_5 Vdout1_5ck86 = 1.8 time = 1740
.meas tran vdout1_5ck86 FIND v(dout1_5) AT=1740.1n

* CHECK dout1_6 Vdout1_6ck86 = 0 time = 1740
.meas tran vdout1_6ck86 FIND v(dout1_6) AT=1740.1n

* CHECK dout1_7 Vdout1_7ck86 = 1.8 time = 1740
.meas tran vdout1_7ck86 FIND v(dout1_7) AT=1740.1n

* CHECK dout1_8 Vdout1_8ck86 = 0 time = 1740
.meas tran vdout1_8ck86 FIND v(dout1_8) AT=1740.1n

* CHECK dout1_9 Vdout1_9ck86 = 1.8 time = 1740
.meas tran vdout1_9ck86 FIND v(dout1_9) AT=1740.1n

* CHECK dout1_10 Vdout1_10ck86 = 0 time = 1740
.meas tran vdout1_10ck86 FIND v(dout1_10) AT=1740.1n

* CHECK dout1_11 Vdout1_11ck86 = 1.8 time = 1740
.meas tran vdout1_11ck86 FIND v(dout1_11) AT=1740.1n

* CHECK dout1_12 Vdout1_12ck86 = 0 time = 1740
.meas tran vdout1_12ck86 FIND v(dout1_12) AT=1740.1n

* CHECK dout1_13 Vdout1_13ck86 = 0 time = 1740
.meas tran vdout1_13ck86 FIND v(dout1_13) AT=1740.1n

* CHECK dout1_14 Vdout1_14ck86 = 1.8 time = 1740
.meas tran vdout1_14ck86 FIND v(dout1_14) AT=1740.1n

* CHECK dout1_15 Vdout1_15ck86 = 1.8 time = 1740
.meas tran vdout1_15ck86 FIND v(dout1_15) AT=1740.1n

* CHECK dout1_16 Vdout1_16ck86 = 1.8 time = 1740
.meas tran vdout1_16ck86 FIND v(dout1_16) AT=1740.1n

* CHECK dout1_17 Vdout1_17ck86 = 1.8 time = 1740
.meas tran vdout1_17ck86 FIND v(dout1_17) AT=1740.1n

* CHECK dout1_18 Vdout1_18ck86 = 1.8 time = 1740
.meas tran vdout1_18ck86 FIND v(dout1_18) AT=1740.1n

* CHECK dout1_19 Vdout1_19ck86 = 1.8 time = 1740
.meas tran vdout1_19ck86 FIND v(dout1_19) AT=1740.1n

* CHECK dout1_20 Vdout1_20ck86 = 1.8 time = 1740
.meas tran vdout1_20ck86 FIND v(dout1_20) AT=1740.1n

* CHECK dout1_21 Vdout1_21ck86 = 0 time = 1740
.meas tran vdout1_21ck86 FIND v(dout1_21) AT=1740.1n

* CHECK dout1_22 Vdout1_22ck86 = 0 time = 1740
.meas tran vdout1_22ck86 FIND v(dout1_22) AT=1740.1n

* CHECK dout1_23 Vdout1_23ck86 = 0 time = 1740
.meas tran vdout1_23ck86 FIND v(dout1_23) AT=1740.1n

* CHECK dout1_24 Vdout1_24ck86 = 1.8 time = 1740
.meas tran vdout1_24ck86 FIND v(dout1_24) AT=1740.1n

* CHECK dout1_25 Vdout1_25ck86 = 1.8 time = 1740
.meas tran vdout1_25ck86 FIND v(dout1_25) AT=1740.1n

* CHECK dout1_26 Vdout1_26ck86 = 0 time = 1740
.meas tran vdout1_26ck86 FIND v(dout1_26) AT=1740.1n

* CHECK dout1_27 Vdout1_27ck86 = 1.8 time = 1740
.meas tran vdout1_27ck86 FIND v(dout1_27) AT=1740.1n

* CHECK dout1_28 Vdout1_28ck86 = 0 time = 1740
.meas tran vdout1_28ck86 FIND v(dout1_28) AT=1740.1n

* CHECK dout1_29 Vdout1_29ck86 = 1.8 time = 1740
.meas tran vdout1_29ck86 FIND v(dout1_29) AT=1740.1n

* CHECK dout1_30 Vdout1_30ck86 = 0 time = 1740
.meas tran vdout1_30ck86 FIND v(dout1_30) AT=1740.1n

* CHECK dout1_31 Vdout1_31ck86 = 0 time = 1740
.meas tran vdout1_31ck86 FIND v(dout1_31) AT=1740.1n

* CHECK dout2_0 Vdout2_0ck86 = 1.8 time = 1740
.meas tran vdout2_0ck86 FIND v(dout2_0) AT=1740.1n

* CHECK dout2_1 Vdout2_1ck86 = 1.8 time = 1740
.meas tran vdout2_1ck86 FIND v(dout2_1) AT=1740.1n

* CHECK dout2_2 Vdout2_2ck86 = 0 time = 1740
.meas tran vdout2_2ck86 FIND v(dout2_2) AT=1740.1n

* CHECK dout2_3 Vdout2_3ck86 = 1.8 time = 1740
.meas tran vdout2_3ck86 FIND v(dout2_3) AT=1740.1n

* CHECK dout2_4 Vdout2_4ck86 = 0 time = 1740
.meas tran vdout2_4ck86 FIND v(dout2_4) AT=1740.1n

* CHECK dout2_5 Vdout2_5ck86 = 0 time = 1740
.meas tran vdout2_5ck86 FIND v(dout2_5) AT=1740.1n

* CHECK dout2_6 Vdout2_6ck86 = 1.8 time = 1740
.meas tran vdout2_6ck86 FIND v(dout2_6) AT=1740.1n

* CHECK dout2_7 Vdout2_7ck86 = 1.8 time = 1740
.meas tran vdout2_7ck86 FIND v(dout2_7) AT=1740.1n

* CHECK dout2_8 Vdout2_8ck86 = 1.8 time = 1740
.meas tran vdout2_8ck86 FIND v(dout2_8) AT=1740.1n

* CHECK dout2_9 Vdout2_9ck86 = 1.8 time = 1740
.meas tran vdout2_9ck86 FIND v(dout2_9) AT=1740.1n

* CHECK dout2_10 Vdout2_10ck86 = 1.8 time = 1740
.meas tran vdout2_10ck86 FIND v(dout2_10) AT=1740.1n

* CHECK dout2_11 Vdout2_11ck86 = 0 time = 1740
.meas tran vdout2_11ck86 FIND v(dout2_11) AT=1740.1n

* CHECK dout2_12 Vdout2_12ck86 = 1.8 time = 1740
.meas tran vdout2_12ck86 FIND v(dout2_12) AT=1740.1n

* CHECK dout2_13 Vdout2_13ck86 = 1.8 time = 1740
.meas tran vdout2_13ck86 FIND v(dout2_13) AT=1740.1n

* CHECK dout2_14 Vdout2_14ck86 = 0 time = 1740
.meas tran vdout2_14ck86 FIND v(dout2_14) AT=1740.1n

* CHECK dout2_15 Vdout2_15ck86 = 1.8 time = 1740
.meas tran vdout2_15ck86 FIND v(dout2_15) AT=1740.1n

* CHECK dout2_16 Vdout2_16ck86 = 1.8 time = 1740
.meas tran vdout2_16ck86 FIND v(dout2_16) AT=1740.1n

* CHECK dout2_17 Vdout2_17ck86 = 0 time = 1740
.meas tran vdout2_17ck86 FIND v(dout2_17) AT=1740.1n

* CHECK dout2_18 Vdout2_18ck86 = 1.8 time = 1740
.meas tran vdout2_18ck86 FIND v(dout2_18) AT=1740.1n

* CHECK dout2_19 Vdout2_19ck86 = 1.8 time = 1740
.meas tran vdout2_19ck86 FIND v(dout2_19) AT=1740.1n

* CHECK dout2_20 Vdout2_20ck86 = 1.8 time = 1740
.meas tran vdout2_20ck86 FIND v(dout2_20) AT=1740.1n

* CHECK dout2_21 Vdout2_21ck86 = 0 time = 1740
.meas tran vdout2_21ck86 FIND v(dout2_21) AT=1740.1n

* CHECK dout2_22 Vdout2_22ck86 = 0 time = 1740
.meas tran vdout2_22ck86 FIND v(dout2_22) AT=1740.1n

* CHECK dout2_23 Vdout2_23ck86 = 1.8 time = 1740
.meas tran vdout2_23ck86 FIND v(dout2_23) AT=1740.1n

* CHECK dout2_24 Vdout2_24ck86 = 1.8 time = 1740
.meas tran vdout2_24ck86 FIND v(dout2_24) AT=1740.1n

* CHECK dout2_25 Vdout2_25ck86 = 0 time = 1740
.meas tran vdout2_25ck86 FIND v(dout2_25) AT=1740.1n

* CHECK dout2_26 Vdout2_26ck86 = 0 time = 1740
.meas tran vdout2_26ck86 FIND v(dout2_26) AT=1740.1n

* CHECK dout2_27 Vdout2_27ck86 = 1.8 time = 1740
.meas tran vdout2_27ck86 FIND v(dout2_27) AT=1740.1n

* CHECK dout2_28 Vdout2_28ck86 = 0 time = 1740
.meas tran vdout2_28ck86 FIND v(dout2_28) AT=1740.1n

* CHECK dout2_29 Vdout2_29ck86 = 1.8 time = 1740
.meas tran vdout2_29ck86 FIND v(dout2_29) AT=1740.1n

* CHECK dout2_30 Vdout2_30ck86 = 0 time = 1740
.meas tran vdout2_30ck86 FIND v(dout2_30) AT=1740.1n

* CHECK dout2_31 Vdout2_31ck86 = 1.8 time = 1740
.meas tran vdout2_31ck86 FIND v(dout2_31) AT=1740.1n

* CHECK dout1_0 Vdout1_0ck87 = 1.8 time = 1760
.meas tran vdout1_0ck87 FIND v(dout1_0) AT=1760.1n

* CHECK dout1_1 Vdout1_1ck87 = 1.8 time = 1760
.meas tran vdout1_1ck87 FIND v(dout1_1) AT=1760.1n

* CHECK dout1_2 Vdout1_2ck87 = 0 time = 1760
.meas tran vdout1_2ck87 FIND v(dout1_2) AT=1760.1n

* CHECK dout1_3 Vdout1_3ck87 = 1.8 time = 1760
.meas tran vdout1_3ck87 FIND v(dout1_3) AT=1760.1n

* CHECK dout1_4 Vdout1_4ck87 = 0 time = 1760
.meas tran vdout1_4ck87 FIND v(dout1_4) AT=1760.1n

* CHECK dout1_5 Vdout1_5ck87 = 0 time = 1760
.meas tran vdout1_5ck87 FIND v(dout1_5) AT=1760.1n

* CHECK dout1_6 Vdout1_6ck87 = 1.8 time = 1760
.meas tran vdout1_6ck87 FIND v(dout1_6) AT=1760.1n

* CHECK dout1_7 Vdout1_7ck87 = 1.8 time = 1760
.meas tran vdout1_7ck87 FIND v(dout1_7) AT=1760.1n

* CHECK dout1_8 Vdout1_8ck87 = 1.8 time = 1760
.meas tran vdout1_8ck87 FIND v(dout1_8) AT=1760.1n

* CHECK dout1_9 Vdout1_9ck87 = 1.8 time = 1760
.meas tran vdout1_9ck87 FIND v(dout1_9) AT=1760.1n

* CHECK dout1_10 Vdout1_10ck87 = 1.8 time = 1760
.meas tran vdout1_10ck87 FIND v(dout1_10) AT=1760.1n

* CHECK dout1_11 Vdout1_11ck87 = 0 time = 1760
.meas tran vdout1_11ck87 FIND v(dout1_11) AT=1760.1n

* CHECK dout1_12 Vdout1_12ck87 = 1.8 time = 1760
.meas tran vdout1_12ck87 FIND v(dout1_12) AT=1760.1n

* CHECK dout1_13 Vdout1_13ck87 = 1.8 time = 1760
.meas tran vdout1_13ck87 FIND v(dout1_13) AT=1760.1n

* CHECK dout1_14 Vdout1_14ck87 = 0 time = 1760
.meas tran vdout1_14ck87 FIND v(dout1_14) AT=1760.1n

* CHECK dout1_15 Vdout1_15ck87 = 1.8 time = 1760
.meas tran vdout1_15ck87 FIND v(dout1_15) AT=1760.1n

* CHECK dout1_16 Vdout1_16ck87 = 1.8 time = 1760
.meas tran vdout1_16ck87 FIND v(dout1_16) AT=1760.1n

* CHECK dout1_17 Vdout1_17ck87 = 0 time = 1760
.meas tran vdout1_17ck87 FIND v(dout1_17) AT=1760.1n

* CHECK dout1_18 Vdout1_18ck87 = 1.8 time = 1760
.meas tran vdout1_18ck87 FIND v(dout1_18) AT=1760.1n

* CHECK dout1_19 Vdout1_19ck87 = 1.8 time = 1760
.meas tran vdout1_19ck87 FIND v(dout1_19) AT=1760.1n

* CHECK dout1_20 Vdout1_20ck87 = 1.8 time = 1760
.meas tran vdout1_20ck87 FIND v(dout1_20) AT=1760.1n

* CHECK dout1_21 Vdout1_21ck87 = 0 time = 1760
.meas tran vdout1_21ck87 FIND v(dout1_21) AT=1760.1n

* CHECK dout1_22 Vdout1_22ck87 = 0 time = 1760
.meas tran vdout1_22ck87 FIND v(dout1_22) AT=1760.1n

* CHECK dout1_23 Vdout1_23ck87 = 1.8 time = 1760
.meas tran vdout1_23ck87 FIND v(dout1_23) AT=1760.1n

* CHECK dout1_24 Vdout1_24ck87 = 1.8 time = 1760
.meas tran vdout1_24ck87 FIND v(dout1_24) AT=1760.1n

* CHECK dout1_25 Vdout1_25ck87 = 0 time = 1760
.meas tran vdout1_25ck87 FIND v(dout1_25) AT=1760.1n

* CHECK dout1_26 Vdout1_26ck87 = 0 time = 1760
.meas tran vdout1_26ck87 FIND v(dout1_26) AT=1760.1n

* CHECK dout1_27 Vdout1_27ck87 = 1.8 time = 1760
.meas tran vdout1_27ck87 FIND v(dout1_27) AT=1760.1n

* CHECK dout1_28 Vdout1_28ck87 = 0 time = 1760
.meas tran vdout1_28ck87 FIND v(dout1_28) AT=1760.1n

* CHECK dout1_29 Vdout1_29ck87 = 1.8 time = 1760
.meas tran vdout1_29ck87 FIND v(dout1_29) AT=1760.1n

* CHECK dout1_30 Vdout1_30ck87 = 0 time = 1760
.meas tran vdout1_30ck87 FIND v(dout1_30) AT=1760.1n

* CHECK dout1_31 Vdout1_31ck87 = 1.8 time = 1760
.meas tran vdout1_31ck87 FIND v(dout1_31) AT=1760.1n

* CHECK dout2_0 Vdout2_0ck87 = 1.8 time = 1760
.meas tran vdout2_0ck87 FIND v(dout2_0) AT=1760.1n

* CHECK dout2_1 Vdout2_1ck87 = 1.8 time = 1760
.meas tran vdout2_1ck87 FIND v(dout2_1) AT=1760.1n

* CHECK dout2_2 Vdout2_2ck87 = 1.8 time = 1760
.meas tran vdout2_2ck87 FIND v(dout2_2) AT=1760.1n

* CHECK dout2_3 Vdout2_3ck87 = 0 time = 1760
.meas tran vdout2_3ck87 FIND v(dout2_3) AT=1760.1n

* CHECK dout2_4 Vdout2_4ck87 = 0 time = 1760
.meas tran vdout2_4ck87 FIND v(dout2_4) AT=1760.1n

* CHECK dout2_5 Vdout2_5ck87 = 0 time = 1760
.meas tran vdout2_5ck87 FIND v(dout2_5) AT=1760.1n

* CHECK dout2_6 Vdout2_6ck87 = 0 time = 1760
.meas tran vdout2_6ck87 FIND v(dout2_6) AT=1760.1n

* CHECK dout2_7 Vdout2_7ck87 = 1.8 time = 1760
.meas tran vdout2_7ck87 FIND v(dout2_7) AT=1760.1n

* CHECK dout2_8 Vdout2_8ck87 = 1.8 time = 1760
.meas tran vdout2_8ck87 FIND v(dout2_8) AT=1760.1n

* CHECK dout2_9 Vdout2_9ck87 = 0 time = 1760
.meas tran vdout2_9ck87 FIND v(dout2_9) AT=1760.1n

* CHECK dout2_10 Vdout2_10ck87 = 1.8 time = 1760
.meas tran vdout2_10ck87 FIND v(dout2_10) AT=1760.1n

* CHECK dout2_11 Vdout2_11ck87 = 1.8 time = 1760
.meas tran vdout2_11ck87 FIND v(dout2_11) AT=1760.1n

* CHECK dout2_12 Vdout2_12ck87 = 0 time = 1760
.meas tran vdout2_12ck87 FIND v(dout2_12) AT=1760.1n

* CHECK dout2_13 Vdout2_13ck87 = 0 time = 1760
.meas tran vdout2_13ck87 FIND v(dout2_13) AT=1760.1n

* CHECK dout2_14 Vdout2_14ck87 = 0 time = 1760
.meas tran vdout2_14ck87 FIND v(dout2_14) AT=1760.1n

* CHECK dout2_15 Vdout2_15ck87 = 0 time = 1760
.meas tran vdout2_15ck87 FIND v(dout2_15) AT=1760.1n

* CHECK dout2_16 Vdout2_16ck87 = 1.8 time = 1760
.meas tran vdout2_16ck87 FIND v(dout2_16) AT=1760.1n

* CHECK dout2_17 Vdout2_17ck87 = 0 time = 1760
.meas tran vdout2_17ck87 FIND v(dout2_17) AT=1760.1n

* CHECK dout2_18 Vdout2_18ck87 = 0 time = 1760
.meas tran vdout2_18ck87 FIND v(dout2_18) AT=1760.1n

* CHECK dout2_19 Vdout2_19ck87 = 0 time = 1760
.meas tran vdout2_19ck87 FIND v(dout2_19) AT=1760.1n

* CHECK dout2_20 Vdout2_20ck87 = 1.8 time = 1760
.meas tran vdout2_20ck87 FIND v(dout2_20) AT=1760.1n

* CHECK dout2_21 Vdout2_21ck87 = 1.8 time = 1760
.meas tran vdout2_21ck87 FIND v(dout2_21) AT=1760.1n

* CHECK dout2_22 Vdout2_22ck87 = 0 time = 1760
.meas tran vdout2_22ck87 FIND v(dout2_22) AT=1760.1n

* CHECK dout2_23 Vdout2_23ck87 = 0 time = 1760
.meas tran vdout2_23ck87 FIND v(dout2_23) AT=1760.1n

* CHECK dout2_24 Vdout2_24ck87 = 0 time = 1760
.meas tran vdout2_24ck87 FIND v(dout2_24) AT=1760.1n

* CHECK dout2_25 Vdout2_25ck87 = 0 time = 1760
.meas tran vdout2_25ck87 FIND v(dout2_25) AT=1760.1n

* CHECK dout2_26 Vdout2_26ck87 = 0 time = 1760
.meas tran vdout2_26ck87 FIND v(dout2_26) AT=1760.1n

* CHECK dout2_27 Vdout2_27ck87 = 0 time = 1760
.meas tran vdout2_27ck87 FIND v(dout2_27) AT=1760.1n

* CHECK dout2_28 Vdout2_28ck87 = 1.8 time = 1760
.meas tran vdout2_28ck87 FIND v(dout2_28) AT=1760.1n

* CHECK dout2_29 Vdout2_29ck87 = 1.8 time = 1760
.meas tran vdout2_29ck87 FIND v(dout2_29) AT=1760.1n

* CHECK dout2_30 Vdout2_30ck87 = 0 time = 1760
.meas tran vdout2_30ck87 FIND v(dout2_30) AT=1760.1n

* CHECK dout2_31 Vdout2_31ck87 = 0 time = 1760
.meas tran vdout2_31ck87 FIND v(dout2_31) AT=1760.1n

* CHECK dout2_0 Vdout2_0ck88 = 0 time = 1780
.meas tran vdout2_0ck88 FIND v(dout2_0) AT=1780.1n

* CHECK dout2_1 Vdout2_1ck88 = 1.8 time = 1780
.meas tran vdout2_1ck88 FIND v(dout2_1) AT=1780.1n

* CHECK dout2_2 Vdout2_2ck88 = 0 time = 1780
.meas tran vdout2_2ck88 FIND v(dout2_2) AT=1780.1n

* CHECK dout2_3 Vdout2_3ck88 = 1.8 time = 1780
.meas tran vdout2_3ck88 FIND v(dout2_3) AT=1780.1n

* CHECK dout2_4 Vdout2_4ck88 = 0 time = 1780
.meas tran vdout2_4ck88 FIND v(dout2_4) AT=1780.1n

* CHECK dout2_5 Vdout2_5ck88 = 0 time = 1780
.meas tran vdout2_5ck88 FIND v(dout2_5) AT=1780.1n

* CHECK dout2_6 Vdout2_6ck88 = 0 time = 1780
.meas tran vdout2_6ck88 FIND v(dout2_6) AT=1780.1n

* CHECK dout2_7 Vdout2_7ck88 = 1.8 time = 1780
.meas tran vdout2_7ck88 FIND v(dout2_7) AT=1780.1n

* CHECK dout2_8 Vdout2_8ck88 = 1.8 time = 1780
.meas tran vdout2_8ck88 FIND v(dout2_8) AT=1780.1n

* CHECK dout2_9 Vdout2_9ck88 = 1.8 time = 1780
.meas tran vdout2_9ck88 FIND v(dout2_9) AT=1780.1n

* CHECK dout2_10 Vdout2_10ck88 = 0 time = 1780
.meas tran vdout2_10ck88 FIND v(dout2_10) AT=1780.1n

* CHECK dout2_11 Vdout2_11ck88 = 0 time = 1780
.meas tran vdout2_11ck88 FIND v(dout2_11) AT=1780.1n

* CHECK dout2_12 Vdout2_12ck88 = 1.8 time = 1780
.meas tran vdout2_12ck88 FIND v(dout2_12) AT=1780.1n

* CHECK dout2_13 Vdout2_13ck88 = 1.8 time = 1780
.meas tran vdout2_13ck88 FIND v(dout2_13) AT=1780.1n

* CHECK dout2_14 Vdout2_14ck88 = 1.8 time = 1780
.meas tran vdout2_14ck88 FIND v(dout2_14) AT=1780.1n

* CHECK dout2_15 Vdout2_15ck88 = 1.8 time = 1780
.meas tran vdout2_15ck88 FIND v(dout2_15) AT=1780.1n

* CHECK dout2_16 Vdout2_16ck88 = 0 time = 1780
.meas tran vdout2_16ck88 FIND v(dout2_16) AT=1780.1n

* CHECK dout2_17 Vdout2_17ck88 = 0 time = 1780
.meas tran vdout2_17ck88 FIND v(dout2_17) AT=1780.1n

* CHECK dout2_18 Vdout2_18ck88 = 1.8 time = 1780
.meas tran vdout2_18ck88 FIND v(dout2_18) AT=1780.1n

* CHECK dout2_19 Vdout2_19ck88 = 1.8 time = 1780
.meas tran vdout2_19ck88 FIND v(dout2_19) AT=1780.1n

* CHECK dout2_20 Vdout2_20ck88 = 0 time = 1780
.meas tran vdout2_20ck88 FIND v(dout2_20) AT=1780.1n

* CHECK dout2_21 Vdout2_21ck88 = 1.8 time = 1780
.meas tran vdout2_21ck88 FIND v(dout2_21) AT=1780.1n

* CHECK dout2_22 Vdout2_22ck88 = 0 time = 1780
.meas tran vdout2_22ck88 FIND v(dout2_22) AT=1780.1n

* CHECK dout2_23 Vdout2_23ck88 = 1.8 time = 1780
.meas tran vdout2_23ck88 FIND v(dout2_23) AT=1780.1n

* CHECK dout2_24 Vdout2_24ck88 = 0 time = 1780
.meas tran vdout2_24ck88 FIND v(dout2_24) AT=1780.1n

* CHECK dout2_25 Vdout2_25ck88 = 1.8 time = 1780
.meas tran vdout2_25ck88 FIND v(dout2_25) AT=1780.1n

* CHECK dout2_26 Vdout2_26ck88 = 0 time = 1780
.meas tran vdout2_26ck88 FIND v(dout2_26) AT=1780.1n

* CHECK dout2_27 Vdout2_27ck88 = 0 time = 1780
.meas tran vdout2_27ck88 FIND v(dout2_27) AT=1780.1n

* CHECK dout2_28 Vdout2_28ck88 = 0 time = 1780
.meas tran vdout2_28ck88 FIND v(dout2_28) AT=1780.1n

* CHECK dout2_29 Vdout2_29ck88 = 1.8 time = 1780
.meas tran vdout2_29ck88 FIND v(dout2_29) AT=1780.1n

* CHECK dout2_30 Vdout2_30ck88 = 0 time = 1780
.meas tran vdout2_30ck88 FIND v(dout2_30) AT=1780.1n

* CHECK dout2_31 Vdout2_31ck88 = 1.8 time = 1780
.meas tran vdout2_31ck88 FIND v(dout2_31) AT=1780.1n

* CHECK dout1_0 Vdout1_0ck89 = 1.8 time = 1800
.meas tran vdout1_0ck89 FIND v(dout1_0) AT=1800.1n

* CHECK dout1_1 Vdout1_1ck89 = 1.8 time = 1800
.meas tran vdout1_1ck89 FIND v(dout1_1) AT=1800.1n

* CHECK dout1_2 Vdout1_2ck89 = 1.8 time = 1800
.meas tran vdout1_2ck89 FIND v(dout1_2) AT=1800.1n

* CHECK dout1_3 Vdout1_3ck89 = 0 time = 1800
.meas tran vdout1_3ck89 FIND v(dout1_3) AT=1800.1n

* CHECK dout1_4 Vdout1_4ck89 = 0 time = 1800
.meas tran vdout1_4ck89 FIND v(dout1_4) AT=1800.1n

* CHECK dout1_5 Vdout1_5ck89 = 0 time = 1800
.meas tran vdout1_5ck89 FIND v(dout1_5) AT=1800.1n

* CHECK dout1_6 Vdout1_6ck89 = 0 time = 1800
.meas tran vdout1_6ck89 FIND v(dout1_6) AT=1800.1n

* CHECK dout1_7 Vdout1_7ck89 = 1.8 time = 1800
.meas tran vdout1_7ck89 FIND v(dout1_7) AT=1800.1n

* CHECK dout1_8 Vdout1_8ck89 = 1.8 time = 1800
.meas tran vdout1_8ck89 FIND v(dout1_8) AT=1800.1n

* CHECK dout1_9 Vdout1_9ck89 = 0 time = 1800
.meas tran vdout1_9ck89 FIND v(dout1_9) AT=1800.1n

* CHECK dout1_10 Vdout1_10ck89 = 1.8 time = 1800
.meas tran vdout1_10ck89 FIND v(dout1_10) AT=1800.1n

* CHECK dout1_11 Vdout1_11ck89 = 1.8 time = 1800
.meas tran vdout1_11ck89 FIND v(dout1_11) AT=1800.1n

* CHECK dout1_12 Vdout1_12ck89 = 0 time = 1800
.meas tran vdout1_12ck89 FIND v(dout1_12) AT=1800.1n

* CHECK dout1_13 Vdout1_13ck89 = 0 time = 1800
.meas tran vdout1_13ck89 FIND v(dout1_13) AT=1800.1n

* CHECK dout1_14 Vdout1_14ck89 = 0 time = 1800
.meas tran vdout1_14ck89 FIND v(dout1_14) AT=1800.1n

* CHECK dout1_15 Vdout1_15ck89 = 0 time = 1800
.meas tran vdout1_15ck89 FIND v(dout1_15) AT=1800.1n

* CHECK dout1_16 Vdout1_16ck89 = 1.8 time = 1800
.meas tran vdout1_16ck89 FIND v(dout1_16) AT=1800.1n

* CHECK dout1_17 Vdout1_17ck89 = 0 time = 1800
.meas tran vdout1_17ck89 FIND v(dout1_17) AT=1800.1n

* CHECK dout1_18 Vdout1_18ck89 = 0 time = 1800
.meas tran vdout1_18ck89 FIND v(dout1_18) AT=1800.1n

* CHECK dout1_19 Vdout1_19ck89 = 0 time = 1800
.meas tran vdout1_19ck89 FIND v(dout1_19) AT=1800.1n

* CHECK dout1_20 Vdout1_20ck89 = 1.8 time = 1800
.meas tran vdout1_20ck89 FIND v(dout1_20) AT=1800.1n

* CHECK dout1_21 Vdout1_21ck89 = 1.8 time = 1800
.meas tran vdout1_21ck89 FIND v(dout1_21) AT=1800.1n

* CHECK dout1_22 Vdout1_22ck89 = 0 time = 1800
.meas tran vdout1_22ck89 FIND v(dout1_22) AT=1800.1n

* CHECK dout1_23 Vdout1_23ck89 = 0 time = 1800
.meas tran vdout1_23ck89 FIND v(dout1_23) AT=1800.1n

* CHECK dout1_24 Vdout1_24ck89 = 0 time = 1800
.meas tran vdout1_24ck89 FIND v(dout1_24) AT=1800.1n

* CHECK dout1_25 Vdout1_25ck89 = 0 time = 1800
.meas tran vdout1_25ck89 FIND v(dout1_25) AT=1800.1n

* CHECK dout1_26 Vdout1_26ck89 = 0 time = 1800
.meas tran vdout1_26ck89 FIND v(dout1_26) AT=1800.1n

* CHECK dout1_27 Vdout1_27ck89 = 0 time = 1800
.meas tran vdout1_27ck89 FIND v(dout1_27) AT=1800.1n

* CHECK dout1_28 Vdout1_28ck89 = 1.8 time = 1800
.meas tran vdout1_28ck89 FIND v(dout1_28) AT=1800.1n

* CHECK dout1_29 Vdout1_29ck89 = 1.8 time = 1800
.meas tran vdout1_29ck89 FIND v(dout1_29) AT=1800.1n

* CHECK dout1_30 Vdout1_30ck89 = 0 time = 1800
.meas tran vdout1_30ck89 FIND v(dout1_30) AT=1800.1n

* CHECK dout1_31 Vdout1_31ck89 = 0 time = 1800
.meas tran vdout1_31ck89 FIND v(dout1_31) AT=1800.1n

* CHECK dout2_0 Vdout2_0ck89 = 1.8 time = 1800
.meas tran vdout2_0ck89 FIND v(dout2_0) AT=1800.1n

* CHECK dout2_1 Vdout2_1ck89 = 1.8 time = 1800
.meas tran vdout2_1ck89 FIND v(dout2_1) AT=1800.1n

* CHECK dout2_2 Vdout2_2ck89 = 1.8 time = 1800
.meas tran vdout2_2ck89 FIND v(dout2_2) AT=1800.1n

* CHECK dout2_3 Vdout2_3ck89 = 0 time = 1800
.meas tran vdout2_3ck89 FIND v(dout2_3) AT=1800.1n

* CHECK dout2_4 Vdout2_4ck89 = 0 time = 1800
.meas tran vdout2_4ck89 FIND v(dout2_4) AT=1800.1n

* CHECK dout2_5 Vdout2_5ck89 = 0 time = 1800
.meas tran vdout2_5ck89 FIND v(dout2_5) AT=1800.1n

* CHECK dout2_6 Vdout2_6ck89 = 0 time = 1800
.meas tran vdout2_6ck89 FIND v(dout2_6) AT=1800.1n

* CHECK dout2_7 Vdout2_7ck89 = 1.8 time = 1800
.meas tran vdout2_7ck89 FIND v(dout2_7) AT=1800.1n

* CHECK dout2_8 Vdout2_8ck89 = 1.8 time = 1800
.meas tran vdout2_8ck89 FIND v(dout2_8) AT=1800.1n

* CHECK dout2_9 Vdout2_9ck89 = 0 time = 1800
.meas tran vdout2_9ck89 FIND v(dout2_9) AT=1800.1n

* CHECK dout2_10 Vdout2_10ck89 = 1.8 time = 1800
.meas tran vdout2_10ck89 FIND v(dout2_10) AT=1800.1n

* CHECK dout2_11 Vdout2_11ck89 = 1.8 time = 1800
.meas tran vdout2_11ck89 FIND v(dout2_11) AT=1800.1n

* CHECK dout2_12 Vdout2_12ck89 = 0 time = 1800
.meas tran vdout2_12ck89 FIND v(dout2_12) AT=1800.1n

* CHECK dout2_13 Vdout2_13ck89 = 0 time = 1800
.meas tran vdout2_13ck89 FIND v(dout2_13) AT=1800.1n

* CHECK dout2_14 Vdout2_14ck89 = 0 time = 1800
.meas tran vdout2_14ck89 FIND v(dout2_14) AT=1800.1n

* CHECK dout2_15 Vdout2_15ck89 = 0 time = 1800
.meas tran vdout2_15ck89 FIND v(dout2_15) AT=1800.1n

* CHECK dout2_16 Vdout2_16ck89 = 1.8 time = 1800
.meas tran vdout2_16ck89 FIND v(dout2_16) AT=1800.1n

* CHECK dout2_17 Vdout2_17ck89 = 0 time = 1800
.meas tran vdout2_17ck89 FIND v(dout2_17) AT=1800.1n

* CHECK dout2_18 Vdout2_18ck89 = 0 time = 1800
.meas tran vdout2_18ck89 FIND v(dout2_18) AT=1800.1n

* CHECK dout2_19 Vdout2_19ck89 = 0 time = 1800
.meas tran vdout2_19ck89 FIND v(dout2_19) AT=1800.1n

* CHECK dout2_20 Vdout2_20ck89 = 1.8 time = 1800
.meas tran vdout2_20ck89 FIND v(dout2_20) AT=1800.1n

* CHECK dout2_21 Vdout2_21ck89 = 1.8 time = 1800
.meas tran vdout2_21ck89 FIND v(dout2_21) AT=1800.1n

* CHECK dout2_22 Vdout2_22ck89 = 0 time = 1800
.meas tran vdout2_22ck89 FIND v(dout2_22) AT=1800.1n

* CHECK dout2_23 Vdout2_23ck89 = 0 time = 1800
.meas tran vdout2_23ck89 FIND v(dout2_23) AT=1800.1n

* CHECK dout2_24 Vdout2_24ck89 = 0 time = 1800
.meas tran vdout2_24ck89 FIND v(dout2_24) AT=1800.1n

* CHECK dout2_25 Vdout2_25ck89 = 0 time = 1800
.meas tran vdout2_25ck89 FIND v(dout2_25) AT=1800.1n

* CHECK dout2_26 Vdout2_26ck89 = 0 time = 1800
.meas tran vdout2_26ck89 FIND v(dout2_26) AT=1800.1n

* CHECK dout2_27 Vdout2_27ck89 = 0 time = 1800
.meas tran vdout2_27ck89 FIND v(dout2_27) AT=1800.1n

* CHECK dout2_28 Vdout2_28ck89 = 1.8 time = 1800
.meas tran vdout2_28ck89 FIND v(dout2_28) AT=1800.1n

* CHECK dout2_29 Vdout2_29ck89 = 1.8 time = 1800
.meas tran vdout2_29ck89 FIND v(dout2_29) AT=1800.1n

* CHECK dout2_30 Vdout2_30ck89 = 0 time = 1800
.meas tran vdout2_30ck89 FIND v(dout2_30) AT=1800.1n

* CHECK dout2_31 Vdout2_31ck89 = 0 time = 1800
.meas tran vdout2_31ck89 FIND v(dout2_31) AT=1800.1n

* CHECK dout1_0 Vdout1_0ck90 = 0 time = 1820
.meas tran vdout1_0ck90 FIND v(dout1_0) AT=1820.1n

* CHECK dout1_1 Vdout1_1ck90 = 1.8 time = 1820
.meas tran vdout1_1ck90 FIND v(dout1_1) AT=1820.1n

* CHECK dout1_2 Vdout1_2ck90 = 0 time = 1820
.meas tran vdout1_2ck90 FIND v(dout1_2) AT=1820.1n

* CHECK dout1_3 Vdout1_3ck90 = 1.8 time = 1820
.meas tran vdout1_3ck90 FIND v(dout1_3) AT=1820.1n

* CHECK dout1_4 Vdout1_4ck90 = 0 time = 1820
.meas tran vdout1_4ck90 FIND v(dout1_4) AT=1820.1n

* CHECK dout1_5 Vdout1_5ck90 = 0 time = 1820
.meas tran vdout1_5ck90 FIND v(dout1_5) AT=1820.1n

* CHECK dout1_6 Vdout1_6ck90 = 0 time = 1820
.meas tran vdout1_6ck90 FIND v(dout1_6) AT=1820.1n

* CHECK dout1_7 Vdout1_7ck90 = 1.8 time = 1820
.meas tran vdout1_7ck90 FIND v(dout1_7) AT=1820.1n

* CHECK dout1_8 Vdout1_8ck90 = 1.8 time = 1820
.meas tran vdout1_8ck90 FIND v(dout1_8) AT=1820.1n

* CHECK dout1_9 Vdout1_9ck90 = 1.8 time = 1820
.meas tran vdout1_9ck90 FIND v(dout1_9) AT=1820.1n

* CHECK dout1_10 Vdout1_10ck90 = 0 time = 1820
.meas tran vdout1_10ck90 FIND v(dout1_10) AT=1820.1n

* CHECK dout1_11 Vdout1_11ck90 = 0 time = 1820
.meas tran vdout1_11ck90 FIND v(dout1_11) AT=1820.1n

* CHECK dout1_12 Vdout1_12ck90 = 1.8 time = 1820
.meas tran vdout1_12ck90 FIND v(dout1_12) AT=1820.1n

* CHECK dout1_13 Vdout1_13ck90 = 1.8 time = 1820
.meas tran vdout1_13ck90 FIND v(dout1_13) AT=1820.1n

* CHECK dout1_14 Vdout1_14ck90 = 1.8 time = 1820
.meas tran vdout1_14ck90 FIND v(dout1_14) AT=1820.1n

* CHECK dout1_15 Vdout1_15ck90 = 1.8 time = 1820
.meas tran vdout1_15ck90 FIND v(dout1_15) AT=1820.1n

* CHECK dout1_16 Vdout1_16ck90 = 0 time = 1820
.meas tran vdout1_16ck90 FIND v(dout1_16) AT=1820.1n

* CHECK dout1_17 Vdout1_17ck90 = 0 time = 1820
.meas tran vdout1_17ck90 FIND v(dout1_17) AT=1820.1n

* CHECK dout1_18 Vdout1_18ck90 = 1.8 time = 1820
.meas tran vdout1_18ck90 FIND v(dout1_18) AT=1820.1n

* CHECK dout1_19 Vdout1_19ck90 = 1.8 time = 1820
.meas tran vdout1_19ck90 FIND v(dout1_19) AT=1820.1n

* CHECK dout1_20 Vdout1_20ck90 = 0 time = 1820
.meas tran vdout1_20ck90 FIND v(dout1_20) AT=1820.1n

* CHECK dout1_21 Vdout1_21ck90 = 1.8 time = 1820
.meas tran vdout1_21ck90 FIND v(dout1_21) AT=1820.1n

* CHECK dout1_22 Vdout1_22ck90 = 0 time = 1820
.meas tran vdout1_22ck90 FIND v(dout1_22) AT=1820.1n

* CHECK dout1_23 Vdout1_23ck90 = 1.8 time = 1820
.meas tran vdout1_23ck90 FIND v(dout1_23) AT=1820.1n

* CHECK dout1_24 Vdout1_24ck90 = 0 time = 1820
.meas tran vdout1_24ck90 FIND v(dout1_24) AT=1820.1n

* CHECK dout1_25 Vdout1_25ck90 = 1.8 time = 1820
.meas tran vdout1_25ck90 FIND v(dout1_25) AT=1820.1n

* CHECK dout1_26 Vdout1_26ck90 = 0 time = 1820
.meas tran vdout1_26ck90 FIND v(dout1_26) AT=1820.1n

* CHECK dout1_27 Vdout1_27ck90 = 0 time = 1820
.meas tran vdout1_27ck90 FIND v(dout1_27) AT=1820.1n

* CHECK dout1_28 Vdout1_28ck90 = 0 time = 1820
.meas tran vdout1_28ck90 FIND v(dout1_28) AT=1820.1n

* CHECK dout1_29 Vdout1_29ck90 = 1.8 time = 1820
.meas tran vdout1_29ck90 FIND v(dout1_29) AT=1820.1n

* CHECK dout1_30 Vdout1_30ck90 = 0 time = 1820
.meas tran vdout1_30ck90 FIND v(dout1_30) AT=1820.1n

* CHECK dout1_31 Vdout1_31ck90 = 1.8 time = 1820
.meas tran vdout1_31ck90 FIND v(dout1_31) AT=1820.1n

* CHECK dout2_0 Vdout2_0ck90 = 1.8 time = 1820
.meas tran vdout2_0ck90 FIND v(dout2_0) AT=1820.1n

* CHECK dout2_1 Vdout2_1ck90 = 1.8 time = 1820
.meas tran vdout2_1ck90 FIND v(dout2_1) AT=1820.1n

* CHECK dout2_2 Vdout2_2ck90 = 1.8 time = 1820
.meas tran vdout2_2ck90 FIND v(dout2_2) AT=1820.1n

* CHECK dout2_3 Vdout2_3ck90 = 0 time = 1820
.meas tran vdout2_3ck90 FIND v(dout2_3) AT=1820.1n

* CHECK dout2_4 Vdout2_4ck90 = 0 time = 1820
.meas tran vdout2_4ck90 FIND v(dout2_4) AT=1820.1n

* CHECK dout2_5 Vdout2_5ck90 = 0 time = 1820
.meas tran vdout2_5ck90 FIND v(dout2_5) AT=1820.1n

* CHECK dout2_6 Vdout2_6ck90 = 0 time = 1820
.meas tran vdout2_6ck90 FIND v(dout2_6) AT=1820.1n

* CHECK dout2_7 Vdout2_7ck90 = 1.8 time = 1820
.meas tran vdout2_7ck90 FIND v(dout2_7) AT=1820.1n

* CHECK dout2_8 Vdout2_8ck90 = 1.8 time = 1820
.meas tran vdout2_8ck90 FIND v(dout2_8) AT=1820.1n

* CHECK dout2_9 Vdout2_9ck90 = 0 time = 1820
.meas tran vdout2_9ck90 FIND v(dout2_9) AT=1820.1n

* CHECK dout2_10 Vdout2_10ck90 = 1.8 time = 1820
.meas tran vdout2_10ck90 FIND v(dout2_10) AT=1820.1n

* CHECK dout2_11 Vdout2_11ck90 = 1.8 time = 1820
.meas tran vdout2_11ck90 FIND v(dout2_11) AT=1820.1n

* CHECK dout2_12 Vdout2_12ck90 = 0 time = 1820
.meas tran vdout2_12ck90 FIND v(dout2_12) AT=1820.1n

* CHECK dout2_13 Vdout2_13ck90 = 0 time = 1820
.meas tran vdout2_13ck90 FIND v(dout2_13) AT=1820.1n

* CHECK dout2_14 Vdout2_14ck90 = 0 time = 1820
.meas tran vdout2_14ck90 FIND v(dout2_14) AT=1820.1n

* CHECK dout2_15 Vdout2_15ck90 = 0 time = 1820
.meas tran vdout2_15ck90 FIND v(dout2_15) AT=1820.1n

* CHECK dout2_16 Vdout2_16ck90 = 1.8 time = 1820
.meas tran vdout2_16ck90 FIND v(dout2_16) AT=1820.1n

* CHECK dout2_17 Vdout2_17ck90 = 0 time = 1820
.meas tran vdout2_17ck90 FIND v(dout2_17) AT=1820.1n

* CHECK dout2_18 Vdout2_18ck90 = 0 time = 1820
.meas tran vdout2_18ck90 FIND v(dout2_18) AT=1820.1n

* CHECK dout2_19 Vdout2_19ck90 = 0 time = 1820
.meas tran vdout2_19ck90 FIND v(dout2_19) AT=1820.1n

* CHECK dout2_20 Vdout2_20ck90 = 1.8 time = 1820
.meas tran vdout2_20ck90 FIND v(dout2_20) AT=1820.1n

* CHECK dout2_21 Vdout2_21ck90 = 1.8 time = 1820
.meas tran vdout2_21ck90 FIND v(dout2_21) AT=1820.1n

* CHECK dout2_22 Vdout2_22ck90 = 0 time = 1820
.meas tran vdout2_22ck90 FIND v(dout2_22) AT=1820.1n

* CHECK dout2_23 Vdout2_23ck90 = 0 time = 1820
.meas tran vdout2_23ck90 FIND v(dout2_23) AT=1820.1n

* CHECK dout2_24 Vdout2_24ck90 = 0 time = 1820
.meas tran vdout2_24ck90 FIND v(dout2_24) AT=1820.1n

* CHECK dout2_25 Vdout2_25ck90 = 0 time = 1820
.meas tran vdout2_25ck90 FIND v(dout2_25) AT=1820.1n

* CHECK dout2_26 Vdout2_26ck90 = 0 time = 1820
.meas tran vdout2_26ck90 FIND v(dout2_26) AT=1820.1n

* CHECK dout2_27 Vdout2_27ck90 = 0 time = 1820
.meas tran vdout2_27ck90 FIND v(dout2_27) AT=1820.1n

* CHECK dout2_28 Vdout2_28ck90 = 1.8 time = 1820
.meas tran vdout2_28ck90 FIND v(dout2_28) AT=1820.1n

* CHECK dout2_29 Vdout2_29ck90 = 1.8 time = 1820
.meas tran vdout2_29ck90 FIND v(dout2_29) AT=1820.1n

* CHECK dout2_30 Vdout2_30ck90 = 0 time = 1820
.meas tran vdout2_30ck90 FIND v(dout2_30) AT=1820.1n

* CHECK dout2_31 Vdout2_31ck90 = 0 time = 1820
.meas tran vdout2_31ck90 FIND v(dout2_31) AT=1820.1n

* CHECK dout1_0 Vdout1_0ck91 = 0 time = 1840
.meas tran vdout1_0ck91 FIND v(dout1_0) AT=1840.1n

* CHECK dout1_1 Vdout1_1ck91 = 0 time = 1840
.meas tran vdout1_1ck91 FIND v(dout1_1) AT=1840.1n

* CHECK dout1_2 Vdout1_2ck91 = 0 time = 1840
.meas tran vdout1_2ck91 FIND v(dout1_2) AT=1840.1n

* CHECK dout1_3 Vdout1_3ck91 = 1.8 time = 1840
.meas tran vdout1_3ck91 FIND v(dout1_3) AT=1840.1n

* CHECK dout1_4 Vdout1_4ck91 = 0 time = 1840
.meas tran vdout1_4ck91 FIND v(dout1_4) AT=1840.1n

* CHECK dout1_5 Vdout1_5ck91 = 0 time = 1840
.meas tran vdout1_5ck91 FIND v(dout1_5) AT=1840.1n

* CHECK dout1_6 Vdout1_6ck91 = 0 time = 1840
.meas tran vdout1_6ck91 FIND v(dout1_6) AT=1840.1n

* CHECK dout1_7 Vdout1_7ck91 = 1.8 time = 1840
.meas tran vdout1_7ck91 FIND v(dout1_7) AT=1840.1n

* CHECK dout1_8 Vdout1_8ck91 = 0 time = 1840
.meas tran vdout1_8ck91 FIND v(dout1_8) AT=1840.1n

* CHECK dout1_9 Vdout1_9ck91 = 0 time = 1840
.meas tran vdout1_9ck91 FIND v(dout1_9) AT=1840.1n

* CHECK dout1_10 Vdout1_10ck91 = 0 time = 1840
.meas tran vdout1_10ck91 FIND v(dout1_10) AT=1840.1n

* CHECK dout1_11 Vdout1_11ck91 = 0 time = 1840
.meas tran vdout1_11ck91 FIND v(dout1_11) AT=1840.1n

* CHECK dout1_12 Vdout1_12ck91 = 0 time = 1840
.meas tran vdout1_12ck91 FIND v(dout1_12) AT=1840.1n

* CHECK dout1_13 Vdout1_13ck91 = 1.8 time = 1840
.meas tran vdout1_13ck91 FIND v(dout1_13) AT=1840.1n

* CHECK dout1_14 Vdout1_14ck91 = 1.8 time = 1840
.meas tran vdout1_14ck91 FIND v(dout1_14) AT=1840.1n

* CHECK dout1_15 Vdout1_15ck91 = 1.8 time = 1840
.meas tran vdout1_15ck91 FIND v(dout1_15) AT=1840.1n

* CHECK dout1_16 Vdout1_16ck91 = 0 time = 1840
.meas tran vdout1_16ck91 FIND v(dout1_16) AT=1840.1n

* CHECK dout1_17 Vdout1_17ck91 = 0 time = 1840
.meas tran vdout1_17ck91 FIND v(dout1_17) AT=1840.1n

* CHECK dout1_18 Vdout1_18ck91 = 1.8 time = 1840
.meas tran vdout1_18ck91 FIND v(dout1_18) AT=1840.1n

* CHECK dout1_19 Vdout1_19ck91 = 1.8 time = 1840
.meas tran vdout1_19ck91 FIND v(dout1_19) AT=1840.1n

* CHECK dout1_20 Vdout1_20ck91 = 0 time = 1840
.meas tran vdout1_20ck91 FIND v(dout1_20) AT=1840.1n

* CHECK dout1_21 Vdout1_21ck91 = 0 time = 1840
.meas tran vdout1_21ck91 FIND v(dout1_21) AT=1840.1n

* CHECK dout1_22 Vdout1_22ck91 = 1.8 time = 1840
.meas tran vdout1_22ck91 FIND v(dout1_22) AT=1840.1n

* CHECK dout1_23 Vdout1_23ck91 = 0 time = 1840
.meas tran vdout1_23ck91 FIND v(dout1_23) AT=1840.1n

* CHECK dout1_24 Vdout1_24ck91 = 0 time = 1840
.meas tran vdout1_24ck91 FIND v(dout1_24) AT=1840.1n

* CHECK dout1_25 Vdout1_25ck91 = 1.8 time = 1840
.meas tran vdout1_25ck91 FIND v(dout1_25) AT=1840.1n

* CHECK dout1_26 Vdout1_26ck91 = 1.8 time = 1840
.meas tran vdout1_26ck91 FIND v(dout1_26) AT=1840.1n

* CHECK dout1_27 Vdout1_27ck91 = 1.8 time = 1840
.meas tran vdout1_27ck91 FIND v(dout1_27) AT=1840.1n

* CHECK dout1_28 Vdout1_28ck91 = 1.8 time = 1840
.meas tran vdout1_28ck91 FIND v(dout1_28) AT=1840.1n

* CHECK dout1_29 Vdout1_29ck91 = 1.8 time = 1840
.meas tran vdout1_29ck91 FIND v(dout1_29) AT=1840.1n

* CHECK dout1_30 Vdout1_30ck91 = 0 time = 1840
.meas tran vdout1_30ck91 FIND v(dout1_30) AT=1840.1n

* CHECK dout1_31 Vdout1_31ck91 = 1.8 time = 1840
.meas tran vdout1_31ck91 FIND v(dout1_31) AT=1840.1n

* CHECK dout2_0 Vdout2_0ck91 = 0 time = 1840
.meas tran vdout2_0ck91 FIND v(dout2_0) AT=1840.1n

* CHECK dout2_1 Vdout2_1ck91 = 1.8 time = 1840
.meas tran vdout2_1ck91 FIND v(dout2_1) AT=1840.1n

* CHECK dout2_2 Vdout2_2ck91 = 1.8 time = 1840
.meas tran vdout2_2ck91 FIND v(dout2_2) AT=1840.1n

* CHECK dout2_3 Vdout2_3ck91 = 0 time = 1840
.meas tran vdout2_3ck91 FIND v(dout2_3) AT=1840.1n

* CHECK dout2_4 Vdout2_4ck91 = 1.8 time = 1840
.meas tran vdout2_4ck91 FIND v(dout2_4) AT=1840.1n

* CHECK dout2_5 Vdout2_5ck91 = 1.8 time = 1840
.meas tran vdout2_5ck91 FIND v(dout2_5) AT=1840.1n

* CHECK dout2_6 Vdout2_6ck91 = 1.8 time = 1840
.meas tran vdout2_6ck91 FIND v(dout2_6) AT=1840.1n

* CHECK dout2_7 Vdout2_7ck91 = 0 time = 1840
.meas tran vdout2_7ck91 FIND v(dout2_7) AT=1840.1n

* CHECK dout2_8 Vdout2_8ck91 = 0 time = 1840
.meas tran vdout2_8ck91 FIND v(dout2_8) AT=1840.1n

* CHECK dout2_9 Vdout2_9ck91 = 0 time = 1840
.meas tran vdout2_9ck91 FIND v(dout2_9) AT=1840.1n

* CHECK dout2_10 Vdout2_10ck91 = 1.8 time = 1840
.meas tran vdout2_10ck91 FIND v(dout2_10) AT=1840.1n

* CHECK dout2_11 Vdout2_11ck91 = 0 time = 1840
.meas tran vdout2_11ck91 FIND v(dout2_11) AT=1840.1n

* CHECK dout2_12 Vdout2_12ck91 = 0 time = 1840
.meas tran vdout2_12ck91 FIND v(dout2_12) AT=1840.1n

* CHECK dout2_13 Vdout2_13ck91 = 0 time = 1840
.meas tran vdout2_13ck91 FIND v(dout2_13) AT=1840.1n

* CHECK dout2_14 Vdout2_14ck91 = 0 time = 1840
.meas tran vdout2_14ck91 FIND v(dout2_14) AT=1840.1n

* CHECK dout2_15 Vdout2_15ck91 = 0 time = 1840
.meas tran vdout2_15ck91 FIND v(dout2_15) AT=1840.1n

* CHECK dout2_16 Vdout2_16ck91 = 1.8 time = 1840
.meas tran vdout2_16ck91 FIND v(dout2_16) AT=1840.1n

* CHECK dout2_17 Vdout2_17ck91 = 1.8 time = 1840
.meas tran vdout2_17ck91 FIND v(dout2_17) AT=1840.1n

* CHECK dout2_18 Vdout2_18ck91 = 1.8 time = 1840
.meas tran vdout2_18ck91 FIND v(dout2_18) AT=1840.1n

* CHECK dout2_19 Vdout2_19ck91 = 1.8 time = 1840
.meas tran vdout2_19ck91 FIND v(dout2_19) AT=1840.1n

* CHECK dout2_20 Vdout2_20ck91 = 1.8 time = 1840
.meas tran vdout2_20ck91 FIND v(dout2_20) AT=1840.1n

* CHECK dout2_21 Vdout2_21ck91 = 1.8 time = 1840
.meas tran vdout2_21ck91 FIND v(dout2_21) AT=1840.1n

* CHECK dout2_22 Vdout2_22ck91 = 0 time = 1840
.meas tran vdout2_22ck91 FIND v(dout2_22) AT=1840.1n

* CHECK dout2_23 Vdout2_23ck91 = 0 time = 1840
.meas tran vdout2_23ck91 FIND v(dout2_23) AT=1840.1n

* CHECK dout2_24 Vdout2_24ck91 = 0 time = 1840
.meas tran vdout2_24ck91 FIND v(dout2_24) AT=1840.1n

* CHECK dout2_25 Vdout2_25ck91 = 0 time = 1840
.meas tran vdout2_25ck91 FIND v(dout2_25) AT=1840.1n

* CHECK dout2_26 Vdout2_26ck91 = 1.8 time = 1840
.meas tran vdout2_26ck91 FIND v(dout2_26) AT=1840.1n

* CHECK dout2_27 Vdout2_27ck91 = 0 time = 1840
.meas tran vdout2_27ck91 FIND v(dout2_27) AT=1840.1n

* CHECK dout2_28 Vdout2_28ck91 = 0 time = 1840
.meas tran vdout2_28ck91 FIND v(dout2_28) AT=1840.1n

* CHECK dout2_29 Vdout2_29ck91 = 0 time = 1840
.meas tran vdout2_29ck91 FIND v(dout2_29) AT=1840.1n

* CHECK dout2_30 Vdout2_30ck91 = 0 time = 1840
.meas tran vdout2_30ck91 FIND v(dout2_30) AT=1840.1n

* CHECK dout2_31 Vdout2_31ck91 = 1.8 time = 1840
.meas tran vdout2_31ck91 FIND v(dout2_31) AT=1840.1n

* CHECK dout1_0 Vdout1_0ck92 = 0 time = 1860
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=1860.1n

* CHECK dout1_1 Vdout1_1ck92 = 1.8 time = 1860
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=1860.1n

* CHECK dout1_2 Vdout1_2ck92 = 1.8 time = 1860
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=1860.1n

* CHECK dout1_3 Vdout1_3ck92 = 0 time = 1860
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=1860.1n

* CHECK dout1_4 Vdout1_4ck92 = 1.8 time = 1860
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=1860.1n

* CHECK dout1_5 Vdout1_5ck92 = 1.8 time = 1860
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=1860.1n

* CHECK dout1_6 Vdout1_6ck92 = 1.8 time = 1860
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=1860.1n

* CHECK dout1_7 Vdout1_7ck92 = 0 time = 1860
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=1860.1n

* CHECK dout1_8 Vdout1_8ck92 = 0 time = 1860
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=1860.1n

* CHECK dout1_9 Vdout1_9ck92 = 0 time = 1860
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=1860.1n

* CHECK dout1_10 Vdout1_10ck92 = 1.8 time = 1860
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=1860.1n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 1860
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=1860.1n

* CHECK dout1_12 Vdout1_12ck92 = 0 time = 1860
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=1860.1n

* CHECK dout1_13 Vdout1_13ck92 = 0 time = 1860
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=1860.1n

* CHECK dout1_14 Vdout1_14ck92 = 0 time = 1860
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=1860.1n

* CHECK dout1_15 Vdout1_15ck92 = 0 time = 1860
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=1860.1n

* CHECK dout1_16 Vdout1_16ck92 = 1.8 time = 1860
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=1860.1n

* CHECK dout1_17 Vdout1_17ck92 = 1.8 time = 1860
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=1860.1n

* CHECK dout1_18 Vdout1_18ck92 = 1.8 time = 1860
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=1860.1n

* CHECK dout1_19 Vdout1_19ck92 = 1.8 time = 1860
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=1860.1n

* CHECK dout1_20 Vdout1_20ck92 = 1.8 time = 1860
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=1860.1n

* CHECK dout1_21 Vdout1_21ck92 = 1.8 time = 1860
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=1860.1n

* CHECK dout1_22 Vdout1_22ck92 = 0 time = 1860
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=1860.1n

* CHECK dout1_23 Vdout1_23ck92 = 0 time = 1860
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=1860.1n

* CHECK dout1_24 Vdout1_24ck92 = 0 time = 1860
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=1860.1n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 1860
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=1860.1n

* CHECK dout1_26 Vdout1_26ck92 = 1.8 time = 1860
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=1860.1n

* CHECK dout1_27 Vdout1_27ck92 = 0 time = 1860
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=1860.1n

* CHECK dout1_28 Vdout1_28ck92 = 0 time = 1860
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=1860.1n

* CHECK dout1_29 Vdout1_29ck92 = 0 time = 1860
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=1860.1n

* CHECK dout1_30 Vdout1_30ck92 = 0 time = 1860
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=1860.1n

* CHECK dout1_31 Vdout1_31ck92 = 1.8 time = 1860
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=1860.1n

* CHECK dout2_0 Vdout2_0ck92 = 0 time = 1860
.meas tran vdout2_0ck92 FIND v(dout2_0) AT=1860.1n

* CHECK dout2_1 Vdout2_1ck92 = 1.8 time = 1860
.meas tran vdout2_1ck92 FIND v(dout2_1) AT=1860.1n

* CHECK dout2_2 Vdout2_2ck92 = 1.8 time = 1860
.meas tran vdout2_2ck92 FIND v(dout2_2) AT=1860.1n

* CHECK dout2_3 Vdout2_3ck92 = 0 time = 1860
.meas tran vdout2_3ck92 FIND v(dout2_3) AT=1860.1n

* CHECK dout2_4 Vdout2_4ck92 = 1.8 time = 1860
.meas tran vdout2_4ck92 FIND v(dout2_4) AT=1860.1n

* CHECK dout2_5 Vdout2_5ck92 = 1.8 time = 1860
.meas tran vdout2_5ck92 FIND v(dout2_5) AT=1860.1n

* CHECK dout2_6 Vdout2_6ck92 = 1.8 time = 1860
.meas tran vdout2_6ck92 FIND v(dout2_6) AT=1860.1n

* CHECK dout2_7 Vdout2_7ck92 = 0 time = 1860
.meas tran vdout2_7ck92 FIND v(dout2_7) AT=1860.1n

* CHECK dout2_8 Vdout2_8ck92 = 0 time = 1860
.meas tran vdout2_8ck92 FIND v(dout2_8) AT=1860.1n

* CHECK dout2_9 Vdout2_9ck92 = 0 time = 1860
.meas tran vdout2_9ck92 FIND v(dout2_9) AT=1860.1n

* CHECK dout2_10 Vdout2_10ck92 = 1.8 time = 1860
.meas tran vdout2_10ck92 FIND v(dout2_10) AT=1860.1n

* CHECK dout2_11 Vdout2_11ck92 = 0 time = 1860
.meas tran vdout2_11ck92 FIND v(dout2_11) AT=1860.1n

* CHECK dout2_12 Vdout2_12ck92 = 0 time = 1860
.meas tran vdout2_12ck92 FIND v(dout2_12) AT=1860.1n

* CHECK dout2_13 Vdout2_13ck92 = 0 time = 1860
.meas tran vdout2_13ck92 FIND v(dout2_13) AT=1860.1n

* CHECK dout2_14 Vdout2_14ck92 = 0 time = 1860
.meas tran vdout2_14ck92 FIND v(dout2_14) AT=1860.1n

* CHECK dout2_15 Vdout2_15ck92 = 0 time = 1860
.meas tran vdout2_15ck92 FIND v(dout2_15) AT=1860.1n

* CHECK dout2_16 Vdout2_16ck92 = 1.8 time = 1860
.meas tran vdout2_16ck92 FIND v(dout2_16) AT=1860.1n

* CHECK dout2_17 Vdout2_17ck92 = 1.8 time = 1860
.meas tran vdout2_17ck92 FIND v(dout2_17) AT=1860.1n

* CHECK dout2_18 Vdout2_18ck92 = 1.8 time = 1860
.meas tran vdout2_18ck92 FIND v(dout2_18) AT=1860.1n

* CHECK dout2_19 Vdout2_19ck92 = 1.8 time = 1860
.meas tran vdout2_19ck92 FIND v(dout2_19) AT=1860.1n

* CHECK dout2_20 Vdout2_20ck92 = 1.8 time = 1860
.meas tran vdout2_20ck92 FIND v(dout2_20) AT=1860.1n

* CHECK dout2_21 Vdout2_21ck92 = 1.8 time = 1860
.meas tran vdout2_21ck92 FIND v(dout2_21) AT=1860.1n

* CHECK dout2_22 Vdout2_22ck92 = 0 time = 1860
.meas tran vdout2_22ck92 FIND v(dout2_22) AT=1860.1n

* CHECK dout2_23 Vdout2_23ck92 = 0 time = 1860
.meas tran vdout2_23ck92 FIND v(dout2_23) AT=1860.1n

* CHECK dout2_24 Vdout2_24ck92 = 0 time = 1860
.meas tran vdout2_24ck92 FIND v(dout2_24) AT=1860.1n

* CHECK dout2_25 Vdout2_25ck92 = 0 time = 1860
.meas tran vdout2_25ck92 FIND v(dout2_25) AT=1860.1n

* CHECK dout2_26 Vdout2_26ck92 = 1.8 time = 1860
.meas tran vdout2_26ck92 FIND v(dout2_26) AT=1860.1n

* CHECK dout2_27 Vdout2_27ck92 = 0 time = 1860
.meas tran vdout2_27ck92 FIND v(dout2_27) AT=1860.1n

* CHECK dout2_28 Vdout2_28ck92 = 0 time = 1860
.meas tran vdout2_28ck92 FIND v(dout2_28) AT=1860.1n

* CHECK dout2_29 Vdout2_29ck92 = 0 time = 1860
.meas tran vdout2_29ck92 FIND v(dout2_29) AT=1860.1n

* CHECK dout2_30 Vdout2_30ck92 = 0 time = 1860
.meas tran vdout2_30ck92 FIND v(dout2_30) AT=1860.1n

* CHECK dout2_31 Vdout2_31ck92 = 1.8 time = 1860
.meas tran vdout2_31ck92 FIND v(dout2_31) AT=1860.1n

* CHECK dout1_0 Vdout1_0ck93 = 0 time = 1880
.meas tran vdout1_0ck93 FIND v(dout1_0) AT=1880.1n

* CHECK dout1_1 Vdout1_1ck93 = 0 time = 1880
.meas tran vdout1_1ck93 FIND v(dout1_1) AT=1880.1n

* CHECK dout1_2 Vdout1_2ck93 = 0 time = 1880
.meas tran vdout1_2ck93 FIND v(dout1_2) AT=1880.1n

* CHECK dout1_3 Vdout1_3ck93 = 0 time = 1880
.meas tran vdout1_3ck93 FIND v(dout1_3) AT=1880.1n

* CHECK dout1_4 Vdout1_4ck93 = 0 time = 1880
.meas tran vdout1_4ck93 FIND v(dout1_4) AT=1880.1n

* CHECK dout1_5 Vdout1_5ck93 = 1.8 time = 1880
.meas tran vdout1_5ck93 FIND v(dout1_5) AT=1880.1n

* CHECK dout1_6 Vdout1_6ck93 = 0 time = 1880
.meas tran vdout1_6ck93 FIND v(dout1_6) AT=1880.1n

* CHECK dout1_7 Vdout1_7ck93 = 1.8 time = 1880
.meas tran vdout1_7ck93 FIND v(dout1_7) AT=1880.1n

* CHECK dout1_8 Vdout1_8ck93 = 0 time = 1880
.meas tran vdout1_8ck93 FIND v(dout1_8) AT=1880.1n

* CHECK dout1_9 Vdout1_9ck93 = 0 time = 1880
.meas tran vdout1_9ck93 FIND v(dout1_9) AT=1880.1n

* CHECK dout1_10 Vdout1_10ck93 = 1.8 time = 1880
.meas tran vdout1_10ck93 FIND v(dout1_10) AT=1880.1n

* CHECK dout1_11 Vdout1_11ck93 = 1.8 time = 1880
.meas tran vdout1_11ck93 FIND v(dout1_11) AT=1880.1n

* CHECK dout1_12 Vdout1_12ck93 = 0 time = 1880
.meas tran vdout1_12ck93 FIND v(dout1_12) AT=1880.1n

* CHECK dout1_13 Vdout1_13ck93 = 1.8 time = 1880
.meas tran vdout1_13ck93 FIND v(dout1_13) AT=1880.1n

* CHECK dout1_14 Vdout1_14ck93 = 0 time = 1880
.meas tran vdout1_14ck93 FIND v(dout1_14) AT=1880.1n

* CHECK dout1_15 Vdout1_15ck93 = 0 time = 1880
.meas tran vdout1_15ck93 FIND v(dout1_15) AT=1880.1n

* CHECK dout1_16 Vdout1_16ck93 = 0 time = 1880
.meas tran vdout1_16ck93 FIND v(dout1_16) AT=1880.1n

* CHECK dout1_17 Vdout1_17ck93 = 0 time = 1880
.meas tran vdout1_17ck93 FIND v(dout1_17) AT=1880.1n

* CHECK dout1_18 Vdout1_18ck93 = 0 time = 1880
.meas tran vdout1_18ck93 FIND v(dout1_18) AT=1880.1n

* CHECK dout1_19 Vdout1_19ck93 = 0 time = 1880
.meas tran vdout1_19ck93 FIND v(dout1_19) AT=1880.1n

* CHECK dout1_20 Vdout1_20ck93 = 1.8 time = 1880
.meas tran vdout1_20ck93 FIND v(dout1_20) AT=1880.1n

* CHECK dout1_21 Vdout1_21ck93 = 1.8 time = 1880
.meas tran vdout1_21ck93 FIND v(dout1_21) AT=1880.1n

* CHECK dout1_22 Vdout1_22ck93 = 0 time = 1880
.meas tran vdout1_22ck93 FIND v(dout1_22) AT=1880.1n

* CHECK dout1_23 Vdout1_23ck93 = 1.8 time = 1880
.meas tran vdout1_23ck93 FIND v(dout1_23) AT=1880.1n

* CHECK dout1_24 Vdout1_24ck93 = 0 time = 1880
.meas tran vdout1_24ck93 FIND v(dout1_24) AT=1880.1n

* CHECK dout1_25 Vdout1_25ck93 = 0 time = 1880
.meas tran vdout1_25ck93 FIND v(dout1_25) AT=1880.1n

* CHECK dout1_26 Vdout1_26ck93 = 1.8 time = 1880
.meas tran vdout1_26ck93 FIND v(dout1_26) AT=1880.1n

* CHECK dout1_27 Vdout1_27ck93 = 0 time = 1880
.meas tran vdout1_27ck93 FIND v(dout1_27) AT=1880.1n

* CHECK dout1_28 Vdout1_28ck93 = 0 time = 1880
.meas tran vdout1_28ck93 FIND v(dout1_28) AT=1880.1n

* CHECK dout1_29 Vdout1_29ck93 = 1.8 time = 1880
.meas tran vdout1_29ck93 FIND v(dout1_29) AT=1880.1n

* CHECK dout1_30 Vdout1_30ck93 = 1.8 time = 1880
.meas tran vdout1_30ck93 FIND v(dout1_30) AT=1880.1n

* CHECK dout1_31 Vdout1_31ck93 = 1.8 time = 1880
.meas tran vdout1_31ck93 FIND v(dout1_31) AT=1880.1n

* CHECK dout2_0 Vdout2_0ck93 = 1.8 time = 1880
.meas tran vdout2_0ck93 FIND v(dout2_0) AT=1880.1n

* CHECK dout2_1 Vdout2_1ck93 = 1.8 time = 1880
.meas tran vdout2_1ck93 FIND v(dout2_1) AT=1880.1n

* CHECK dout2_2 Vdout2_2ck93 = 1.8 time = 1880
.meas tran vdout2_2ck93 FIND v(dout2_2) AT=1880.1n

* CHECK dout2_3 Vdout2_3ck93 = 1.8 time = 1880
.meas tran vdout2_3ck93 FIND v(dout2_3) AT=1880.1n

* CHECK dout2_4 Vdout2_4ck93 = 1.8 time = 1880
.meas tran vdout2_4ck93 FIND v(dout2_4) AT=1880.1n

* CHECK dout2_5 Vdout2_5ck93 = 1.8 time = 1880
.meas tran vdout2_5ck93 FIND v(dout2_5) AT=1880.1n

* CHECK dout2_6 Vdout2_6ck93 = 1.8 time = 1880
.meas tran vdout2_6ck93 FIND v(dout2_6) AT=1880.1n

* CHECK dout2_7 Vdout2_7ck93 = 0 time = 1880
.meas tran vdout2_7ck93 FIND v(dout2_7) AT=1880.1n

* CHECK dout2_8 Vdout2_8ck93 = 1.8 time = 1880
.meas tran vdout2_8ck93 FIND v(dout2_8) AT=1880.1n

* CHECK dout2_9 Vdout2_9ck93 = 1.8 time = 1880
.meas tran vdout2_9ck93 FIND v(dout2_9) AT=1880.1n

* CHECK dout2_10 Vdout2_10ck93 = 1.8 time = 1880
.meas tran vdout2_10ck93 FIND v(dout2_10) AT=1880.1n

* CHECK dout2_11 Vdout2_11ck93 = 0 time = 1880
.meas tran vdout2_11ck93 FIND v(dout2_11) AT=1880.1n

* CHECK dout2_12 Vdout2_12ck93 = 0 time = 1880
.meas tran vdout2_12ck93 FIND v(dout2_12) AT=1880.1n

* CHECK dout2_13 Vdout2_13ck93 = 1.8 time = 1880
.meas tran vdout2_13ck93 FIND v(dout2_13) AT=1880.1n

* CHECK dout2_14 Vdout2_14ck93 = 0 time = 1880
.meas tran vdout2_14ck93 FIND v(dout2_14) AT=1880.1n

* CHECK dout2_15 Vdout2_15ck93 = 1.8 time = 1880
.meas tran vdout2_15ck93 FIND v(dout2_15) AT=1880.1n

* CHECK dout2_16 Vdout2_16ck93 = 0 time = 1880
.meas tran vdout2_16ck93 FIND v(dout2_16) AT=1880.1n

* CHECK dout2_17 Vdout2_17ck93 = 0 time = 1880
.meas tran vdout2_17ck93 FIND v(dout2_17) AT=1880.1n

* CHECK dout2_18 Vdout2_18ck93 = 0 time = 1880
.meas tran vdout2_18ck93 FIND v(dout2_18) AT=1880.1n

* CHECK dout2_19 Vdout2_19ck93 = 0 time = 1880
.meas tran vdout2_19ck93 FIND v(dout2_19) AT=1880.1n

* CHECK dout2_20 Vdout2_20ck93 = 0 time = 1880
.meas tran vdout2_20ck93 FIND v(dout2_20) AT=1880.1n

* CHECK dout2_21 Vdout2_21ck93 = 0 time = 1880
.meas tran vdout2_21ck93 FIND v(dout2_21) AT=1880.1n

* CHECK dout2_22 Vdout2_22ck93 = 1.8 time = 1880
.meas tran vdout2_22ck93 FIND v(dout2_22) AT=1880.1n

* CHECK dout2_23 Vdout2_23ck93 = 1.8 time = 1880
.meas tran vdout2_23ck93 FIND v(dout2_23) AT=1880.1n

* CHECK dout2_24 Vdout2_24ck93 = 1.8 time = 1880
.meas tran vdout2_24ck93 FIND v(dout2_24) AT=1880.1n

* CHECK dout2_25 Vdout2_25ck93 = 1.8 time = 1880
.meas tran vdout2_25ck93 FIND v(dout2_25) AT=1880.1n

* CHECK dout2_26 Vdout2_26ck93 = 0 time = 1880
.meas tran vdout2_26ck93 FIND v(dout2_26) AT=1880.1n

* CHECK dout2_27 Vdout2_27ck93 = 0 time = 1880
.meas tran vdout2_27ck93 FIND v(dout2_27) AT=1880.1n

* CHECK dout2_28 Vdout2_28ck93 = 1.8 time = 1880
.meas tran vdout2_28ck93 FIND v(dout2_28) AT=1880.1n

* CHECK dout2_29 Vdout2_29ck93 = 0 time = 1880
.meas tran vdout2_29ck93 FIND v(dout2_29) AT=1880.1n

* CHECK dout2_30 Vdout2_30ck93 = 0 time = 1880
.meas tran vdout2_30ck93 FIND v(dout2_30) AT=1880.1n

* CHECK dout2_31 Vdout2_31ck93 = 1.8 time = 1880
.meas tran vdout2_31ck93 FIND v(dout2_31) AT=1880.1n

* CHECK dout1_0 Vdout1_0ck94 = 0 time = 1900
.meas tran vdout1_0ck94 FIND v(dout1_0) AT=1900.1n

* CHECK dout1_1 Vdout1_1ck94 = 0 time = 1900
.meas tran vdout1_1ck94 FIND v(dout1_1) AT=1900.1n

* CHECK dout1_2 Vdout1_2ck94 = 0 time = 1900
.meas tran vdout1_2ck94 FIND v(dout1_2) AT=1900.1n

* CHECK dout1_3 Vdout1_3ck94 = 0 time = 1900
.meas tran vdout1_3ck94 FIND v(dout1_3) AT=1900.1n

* CHECK dout1_4 Vdout1_4ck94 = 0 time = 1900
.meas tran vdout1_4ck94 FIND v(dout1_4) AT=1900.1n

* CHECK dout1_5 Vdout1_5ck94 = 1.8 time = 1900
.meas tran vdout1_5ck94 FIND v(dout1_5) AT=1900.1n

* CHECK dout1_6 Vdout1_6ck94 = 0 time = 1900
.meas tran vdout1_6ck94 FIND v(dout1_6) AT=1900.1n

* CHECK dout1_7 Vdout1_7ck94 = 1.8 time = 1900
.meas tran vdout1_7ck94 FIND v(dout1_7) AT=1900.1n

* CHECK dout1_8 Vdout1_8ck94 = 0 time = 1900
.meas tran vdout1_8ck94 FIND v(dout1_8) AT=1900.1n

* CHECK dout1_9 Vdout1_9ck94 = 0 time = 1900
.meas tran vdout1_9ck94 FIND v(dout1_9) AT=1900.1n

* CHECK dout1_10 Vdout1_10ck94 = 1.8 time = 1900
.meas tran vdout1_10ck94 FIND v(dout1_10) AT=1900.1n

* CHECK dout1_11 Vdout1_11ck94 = 1.8 time = 1900
.meas tran vdout1_11ck94 FIND v(dout1_11) AT=1900.1n

* CHECK dout1_12 Vdout1_12ck94 = 0 time = 1900
.meas tran vdout1_12ck94 FIND v(dout1_12) AT=1900.1n

* CHECK dout1_13 Vdout1_13ck94 = 1.8 time = 1900
.meas tran vdout1_13ck94 FIND v(dout1_13) AT=1900.1n

* CHECK dout1_14 Vdout1_14ck94 = 0 time = 1900
.meas tran vdout1_14ck94 FIND v(dout1_14) AT=1900.1n

* CHECK dout1_15 Vdout1_15ck94 = 0 time = 1900
.meas tran vdout1_15ck94 FIND v(dout1_15) AT=1900.1n

* CHECK dout1_16 Vdout1_16ck94 = 0 time = 1900
.meas tran vdout1_16ck94 FIND v(dout1_16) AT=1900.1n

* CHECK dout1_17 Vdout1_17ck94 = 0 time = 1900
.meas tran vdout1_17ck94 FIND v(dout1_17) AT=1900.1n

* CHECK dout1_18 Vdout1_18ck94 = 0 time = 1900
.meas tran vdout1_18ck94 FIND v(dout1_18) AT=1900.1n

* CHECK dout1_19 Vdout1_19ck94 = 0 time = 1900
.meas tran vdout1_19ck94 FIND v(dout1_19) AT=1900.1n

* CHECK dout1_20 Vdout1_20ck94 = 1.8 time = 1900
.meas tran vdout1_20ck94 FIND v(dout1_20) AT=1900.1n

* CHECK dout1_21 Vdout1_21ck94 = 1.8 time = 1900
.meas tran vdout1_21ck94 FIND v(dout1_21) AT=1900.1n

* CHECK dout1_22 Vdout1_22ck94 = 0 time = 1900
.meas tran vdout1_22ck94 FIND v(dout1_22) AT=1900.1n

* CHECK dout1_23 Vdout1_23ck94 = 1.8 time = 1900
.meas tran vdout1_23ck94 FIND v(dout1_23) AT=1900.1n

* CHECK dout1_24 Vdout1_24ck94 = 0 time = 1900
.meas tran vdout1_24ck94 FIND v(dout1_24) AT=1900.1n

* CHECK dout1_25 Vdout1_25ck94 = 0 time = 1900
.meas tran vdout1_25ck94 FIND v(dout1_25) AT=1900.1n

* CHECK dout1_26 Vdout1_26ck94 = 1.8 time = 1900
.meas tran vdout1_26ck94 FIND v(dout1_26) AT=1900.1n

* CHECK dout1_27 Vdout1_27ck94 = 0 time = 1900
.meas tran vdout1_27ck94 FIND v(dout1_27) AT=1900.1n

* CHECK dout1_28 Vdout1_28ck94 = 0 time = 1900
.meas tran vdout1_28ck94 FIND v(dout1_28) AT=1900.1n

* CHECK dout1_29 Vdout1_29ck94 = 1.8 time = 1900
.meas tran vdout1_29ck94 FIND v(dout1_29) AT=1900.1n

* CHECK dout1_30 Vdout1_30ck94 = 1.8 time = 1900
.meas tran vdout1_30ck94 FIND v(dout1_30) AT=1900.1n

* CHECK dout1_31 Vdout1_31ck94 = 1.8 time = 1900
.meas tran vdout1_31ck94 FIND v(dout1_31) AT=1900.1n

* CHECK dout2_0 Vdout2_0ck94 = 0 time = 1900
.meas tran vdout2_0ck94 FIND v(dout2_0) AT=1900.1n

* CHECK dout2_1 Vdout2_1ck94 = 1.8 time = 1900
.meas tran vdout2_1ck94 FIND v(dout2_1) AT=1900.1n

* CHECK dout2_2 Vdout2_2ck94 = 1.8 time = 1900
.meas tran vdout2_2ck94 FIND v(dout2_2) AT=1900.1n

* CHECK dout2_3 Vdout2_3ck94 = 0 time = 1900
.meas tran vdout2_3ck94 FIND v(dout2_3) AT=1900.1n

* CHECK dout2_4 Vdout2_4ck94 = 1.8 time = 1900
.meas tran vdout2_4ck94 FIND v(dout2_4) AT=1900.1n

* CHECK dout2_5 Vdout2_5ck94 = 1.8 time = 1900
.meas tran vdout2_5ck94 FIND v(dout2_5) AT=1900.1n

* CHECK dout2_6 Vdout2_6ck94 = 1.8 time = 1900
.meas tran vdout2_6ck94 FIND v(dout2_6) AT=1900.1n

* CHECK dout2_7 Vdout2_7ck94 = 0 time = 1900
.meas tran vdout2_7ck94 FIND v(dout2_7) AT=1900.1n

* CHECK dout2_8 Vdout2_8ck94 = 0 time = 1900
.meas tran vdout2_8ck94 FIND v(dout2_8) AT=1900.1n

* CHECK dout2_9 Vdout2_9ck94 = 0 time = 1900
.meas tran vdout2_9ck94 FIND v(dout2_9) AT=1900.1n

* CHECK dout2_10 Vdout2_10ck94 = 1.8 time = 1900
.meas tran vdout2_10ck94 FIND v(dout2_10) AT=1900.1n

* CHECK dout2_11 Vdout2_11ck94 = 0 time = 1900
.meas tran vdout2_11ck94 FIND v(dout2_11) AT=1900.1n

* CHECK dout2_12 Vdout2_12ck94 = 0 time = 1900
.meas tran vdout2_12ck94 FIND v(dout2_12) AT=1900.1n

* CHECK dout2_13 Vdout2_13ck94 = 0 time = 1900
.meas tran vdout2_13ck94 FIND v(dout2_13) AT=1900.1n

* CHECK dout2_14 Vdout2_14ck94 = 0 time = 1900
.meas tran vdout2_14ck94 FIND v(dout2_14) AT=1900.1n

* CHECK dout2_15 Vdout2_15ck94 = 0 time = 1900
.meas tran vdout2_15ck94 FIND v(dout2_15) AT=1900.1n

* CHECK dout2_16 Vdout2_16ck94 = 1.8 time = 1900
.meas tran vdout2_16ck94 FIND v(dout2_16) AT=1900.1n

* CHECK dout2_17 Vdout2_17ck94 = 1.8 time = 1900
.meas tran vdout2_17ck94 FIND v(dout2_17) AT=1900.1n

* CHECK dout2_18 Vdout2_18ck94 = 1.8 time = 1900
.meas tran vdout2_18ck94 FIND v(dout2_18) AT=1900.1n

* CHECK dout2_19 Vdout2_19ck94 = 1.8 time = 1900
.meas tran vdout2_19ck94 FIND v(dout2_19) AT=1900.1n

* CHECK dout2_20 Vdout2_20ck94 = 1.8 time = 1900
.meas tran vdout2_20ck94 FIND v(dout2_20) AT=1900.1n

* CHECK dout2_21 Vdout2_21ck94 = 1.8 time = 1900
.meas tran vdout2_21ck94 FIND v(dout2_21) AT=1900.1n

* CHECK dout2_22 Vdout2_22ck94 = 0 time = 1900
.meas tran vdout2_22ck94 FIND v(dout2_22) AT=1900.1n

* CHECK dout2_23 Vdout2_23ck94 = 0 time = 1900
.meas tran vdout2_23ck94 FIND v(dout2_23) AT=1900.1n

* CHECK dout2_24 Vdout2_24ck94 = 0 time = 1900
.meas tran vdout2_24ck94 FIND v(dout2_24) AT=1900.1n

* CHECK dout2_25 Vdout2_25ck94 = 0 time = 1900
.meas tran vdout2_25ck94 FIND v(dout2_25) AT=1900.1n

* CHECK dout2_26 Vdout2_26ck94 = 1.8 time = 1900
.meas tran vdout2_26ck94 FIND v(dout2_26) AT=1900.1n

* CHECK dout2_27 Vdout2_27ck94 = 0 time = 1900
.meas tran vdout2_27ck94 FIND v(dout2_27) AT=1900.1n

* CHECK dout2_28 Vdout2_28ck94 = 0 time = 1900
.meas tran vdout2_28ck94 FIND v(dout2_28) AT=1900.1n

* CHECK dout2_29 Vdout2_29ck94 = 0 time = 1900
.meas tran vdout2_29ck94 FIND v(dout2_29) AT=1900.1n

* CHECK dout2_30 Vdout2_30ck94 = 0 time = 1900
.meas tran vdout2_30ck94 FIND v(dout2_30) AT=1900.1n

* CHECK dout2_31 Vdout2_31ck94 = 1.8 time = 1900
.meas tran vdout2_31ck94 FIND v(dout2_31) AT=1900.1n

* CHECK dout1_0 Vdout1_0ck95 = 0 time = 1920
.meas tran vdout1_0ck95 FIND v(dout1_0) AT=1920.1n

* CHECK dout1_1 Vdout1_1ck95 = 0 time = 1920
.meas tran vdout1_1ck95 FIND v(dout1_1) AT=1920.1n

* CHECK dout1_2 Vdout1_2ck95 = 0 time = 1920
.meas tran vdout1_2ck95 FIND v(dout1_2) AT=1920.1n

* CHECK dout1_3 Vdout1_3ck95 = 0 time = 1920
.meas tran vdout1_3ck95 FIND v(dout1_3) AT=1920.1n

* CHECK dout1_4 Vdout1_4ck95 = 0 time = 1920
.meas tran vdout1_4ck95 FIND v(dout1_4) AT=1920.1n

* CHECK dout1_5 Vdout1_5ck95 = 1.8 time = 1920
.meas tran vdout1_5ck95 FIND v(dout1_5) AT=1920.1n

* CHECK dout1_6 Vdout1_6ck95 = 0 time = 1920
.meas tran vdout1_6ck95 FIND v(dout1_6) AT=1920.1n

* CHECK dout1_7 Vdout1_7ck95 = 1.8 time = 1920
.meas tran vdout1_7ck95 FIND v(dout1_7) AT=1920.1n

* CHECK dout1_8 Vdout1_8ck95 = 0 time = 1920
.meas tran vdout1_8ck95 FIND v(dout1_8) AT=1920.1n

* CHECK dout1_9 Vdout1_9ck95 = 0 time = 1920
.meas tran vdout1_9ck95 FIND v(dout1_9) AT=1920.1n

* CHECK dout1_10 Vdout1_10ck95 = 1.8 time = 1920
.meas tran vdout1_10ck95 FIND v(dout1_10) AT=1920.1n

* CHECK dout1_11 Vdout1_11ck95 = 1.8 time = 1920
.meas tran vdout1_11ck95 FIND v(dout1_11) AT=1920.1n

* CHECK dout1_12 Vdout1_12ck95 = 0 time = 1920
.meas tran vdout1_12ck95 FIND v(dout1_12) AT=1920.1n

* CHECK dout1_13 Vdout1_13ck95 = 1.8 time = 1920
.meas tran vdout1_13ck95 FIND v(dout1_13) AT=1920.1n

* CHECK dout1_14 Vdout1_14ck95 = 0 time = 1920
.meas tran vdout1_14ck95 FIND v(dout1_14) AT=1920.1n

* CHECK dout1_15 Vdout1_15ck95 = 0 time = 1920
.meas tran vdout1_15ck95 FIND v(dout1_15) AT=1920.1n

* CHECK dout1_16 Vdout1_16ck95 = 0 time = 1920
.meas tran vdout1_16ck95 FIND v(dout1_16) AT=1920.1n

* CHECK dout1_17 Vdout1_17ck95 = 0 time = 1920
.meas tran vdout1_17ck95 FIND v(dout1_17) AT=1920.1n

* CHECK dout1_18 Vdout1_18ck95 = 0 time = 1920
.meas tran vdout1_18ck95 FIND v(dout1_18) AT=1920.1n

* CHECK dout1_19 Vdout1_19ck95 = 0 time = 1920
.meas tran vdout1_19ck95 FIND v(dout1_19) AT=1920.1n

* CHECK dout1_20 Vdout1_20ck95 = 1.8 time = 1920
.meas tran vdout1_20ck95 FIND v(dout1_20) AT=1920.1n

* CHECK dout1_21 Vdout1_21ck95 = 1.8 time = 1920
.meas tran vdout1_21ck95 FIND v(dout1_21) AT=1920.1n

* CHECK dout1_22 Vdout1_22ck95 = 0 time = 1920
.meas tran vdout1_22ck95 FIND v(dout1_22) AT=1920.1n

* CHECK dout1_23 Vdout1_23ck95 = 1.8 time = 1920
.meas tran vdout1_23ck95 FIND v(dout1_23) AT=1920.1n

* CHECK dout1_24 Vdout1_24ck95 = 0 time = 1920
.meas tran vdout1_24ck95 FIND v(dout1_24) AT=1920.1n

* CHECK dout1_25 Vdout1_25ck95 = 0 time = 1920
.meas tran vdout1_25ck95 FIND v(dout1_25) AT=1920.1n

* CHECK dout1_26 Vdout1_26ck95 = 1.8 time = 1920
.meas tran vdout1_26ck95 FIND v(dout1_26) AT=1920.1n

* CHECK dout1_27 Vdout1_27ck95 = 0 time = 1920
.meas tran vdout1_27ck95 FIND v(dout1_27) AT=1920.1n

* CHECK dout1_28 Vdout1_28ck95 = 0 time = 1920
.meas tran vdout1_28ck95 FIND v(dout1_28) AT=1920.1n

* CHECK dout1_29 Vdout1_29ck95 = 1.8 time = 1920
.meas tran vdout1_29ck95 FIND v(dout1_29) AT=1920.1n

* CHECK dout1_30 Vdout1_30ck95 = 1.8 time = 1920
.meas tran vdout1_30ck95 FIND v(dout1_30) AT=1920.1n

* CHECK dout1_31 Vdout1_31ck95 = 1.8 time = 1920
.meas tran vdout1_31ck95 FIND v(dout1_31) AT=1920.1n

* CHECK dout2_0 Vdout2_0ck95 = 0 time = 1920
.meas tran vdout2_0ck95 FIND v(dout2_0) AT=1920.1n

* CHECK dout2_1 Vdout2_1ck95 = 0 time = 1920
.meas tran vdout2_1ck95 FIND v(dout2_1) AT=1920.1n

* CHECK dout2_2 Vdout2_2ck95 = 0 time = 1920
.meas tran vdout2_2ck95 FIND v(dout2_2) AT=1920.1n

* CHECK dout2_3 Vdout2_3ck95 = 0 time = 1920
.meas tran vdout2_3ck95 FIND v(dout2_3) AT=1920.1n

* CHECK dout2_4 Vdout2_4ck95 = 0 time = 1920
.meas tran vdout2_4ck95 FIND v(dout2_4) AT=1920.1n

* CHECK dout2_5 Vdout2_5ck95 = 1.8 time = 1920
.meas tran vdout2_5ck95 FIND v(dout2_5) AT=1920.1n

* CHECK dout2_6 Vdout2_6ck95 = 0 time = 1920
.meas tran vdout2_6ck95 FIND v(dout2_6) AT=1920.1n

* CHECK dout2_7 Vdout2_7ck95 = 1.8 time = 1920
.meas tran vdout2_7ck95 FIND v(dout2_7) AT=1920.1n

* CHECK dout2_8 Vdout2_8ck95 = 0 time = 1920
.meas tran vdout2_8ck95 FIND v(dout2_8) AT=1920.1n

* CHECK dout2_9 Vdout2_9ck95 = 0 time = 1920
.meas tran vdout2_9ck95 FIND v(dout2_9) AT=1920.1n

* CHECK dout2_10 Vdout2_10ck95 = 1.8 time = 1920
.meas tran vdout2_10ck95 FIND v(dout2_10) AT=1920.1n

* CHECK dout2_11 Vdout2_11ck95 = 1.8 time = 1920
.meas tran vdout2_11ck95 FIND v(dout2_11) AT=1920.1n

* CHECK dout2_12 Vdout2_12ck95 = 0 time = 1920
.meas tran vdout2_12ck95 FIND v(dout2_12) AT=1920.1n

* CHECK dout2_13 Vdout2_13ck95 = 1.8 time = 1920
.meas tran vdout2_13ck95 FIND v(dout2_13) AT=1920.1n

* CHECK dout2_14 Vdout2_14ck95 = 0 time = 1920
.meas tran vdout2_14ck95 FIND v(dout2_14) AT=1920.1n

* CHECK dout2_15 Vdout2_15ck95 = 0 time = 1920
.meas tran vdout2_15ck95 FIND v(dout2_15) AT=1920.1n

* CHECK dout2_16 Vdout2_16ck95 = 0 time = 1920
.meas tran vdout2_16ck95 FIND v(dout2_16) AT=1920.1n

* CHECK dout2_17 Vdout2_17ck95 = 0 time = 1920
.meas tran vdout2_17ck95 FIND v(dout2_17) AT=1920.1n

* CHECK dout2_18 Vdout2_18ck95 = 0 time = 1920
.meas tran vdout2_18ck95 FIND v(dout2_18) AT=1920.1n

* CHECK dout2_19 Vdout2_19ck95 = 0 time = 1920
.meas tran vdout2_19ck95 FIND v(dout2_19) AT=1920.1n

* CHECK dout2_20 Vdout2_20ck95 = 1.8 time = 1920
.meas tran vdout2_20ck95 FIND v(dout2_20) AT=1920.1n

* CHECK dout2_21 Vdout2_21ck95 = 1.8 time = 1920
.meas tran vdout2_21ck95 FIND v(dout2_21) AT=1920.1n

* CHECK dout2_22 Vdout2_22ck95 = 0 time = 1920
.meas tran vdout2_22ck95 FIND v(dout2_22) AT=1920.1n

* CHECK dout2_23 Vdout2_23ck95 = 1.8 time = 1920
.meas tran vdout2_23ck95 FIND v(dout2_23) AT=1920.1n

* CHECK dout2_24 Vdout2_24ck95 = 0 time = 1920
.meas tran vdout2_24ck95 FIND v(dout2_24) AT=1920.1n

* CHECK dout2_25 Vdout2_25ck95 = 0 time = 1920
.meas tran vdout2_25ck95 FIND v(dout2_25) AT=1920.1n

* CHECK dout2_26 Vdout2_26ck95 = 1.8 time = 1920
.meas tran vdout2_26ck95 FIND v(dout2_26) AT=1920.1n

* CHECK dout2_27 Vdout2_27ck95 = 0 time = 1920
.meas tran vdout2_27ck95 FIND v(dout2_27) AT=1920.1n

* CHECK dout2_28 Vdout2_28ck95 = 0 time = 1920
.meas tran vdout2_28ck95 FIND v(dout2_28) AT=1920.1n

* CHECK dout2_29 Vdout2_29ck95 = 1.8 time = 1920
.meas tran vdout2_29ck95 FIND v(dout2_29) AT=1920.1n

* CHECK dout2_30 Vdout2_30ck95 = 1.8 time = 1920
.meas tran vdout2_30ck95 FIND v(dout2_30) AT=1920.1n

* CHECK dout2_31 Vdout2_31ck95 = 1.8 time = 1920
.meas tran vdout2_31ck95 FIND v(dout2_31) AT=1920.1n

* CHECK dout1_0 Vdout1_0ck96 = 1.8 time = 1940
.meas tran vdout1_0ck96 FIND v(dout1_0) AT=1940.1n

* CHECK dout1_1 Vdout1_1ck96 = 1.8 time = 1940
.meas tran vdout1_1ck96 FIND v(dout1_1) AT=1940.1n

* CHECK dout1_2 Vdout1_2ck96 = 1.8 time = 1940
.meas tran vdout1_2ck96 FIND v(dout1_2) AT=1940.1n

* CHECK dout1_3 Vdout1_3ck96 = 1.8 time = 1940
.meas tran vdout1_3ck96 FIND v(dout1_3) AT=1940.1n

* CHECK dout1_4 Vdout1_4ck96 = 0 time = 1940
.meas tran vdout1_4ck96 FIND v(dout1_4) AT=1940.1n

* CHECK dout1_5 Vdout1_5ck96 = 1.8 time = 1940
.meas tran vdout1_5ck96 FIND v(dout1_5) AT=1940.1n

* CHECK dout1_6 Vdout1_6ck96 = 1.8 time = 1940
.meas tran vdout1_6ck96 FIND v(dout1_6) AT=1940.1n

* CHECK dout1_7 Vdout1_7ck96 = 1.8 time = 1940
.meas tran vdout1_7ck96 FIND v(dout1_7) AT=1940.1n

* CHECK dout1_8 Vdout1_8ck96 = 1.8 time = 1940
.meas tran vdout1_8ck96 FIND v(dout1_8) AT=1940.1n

* CHECK dout1_9 Vdout1_9ck96 = 1.8 time = 1940
.meas tran vdout1_9ck96 FIND v(dout1_9) AT=1940.1n

* CHECK dout1_10 Vdout1_10ck96 = 0 time = 1940
.meas tran vdout1_10ck96 FIND v(dout1_10) AT=1940.1n

* CHECK dout1_11 Vdout1_11ck96 = 0 time = 1940
.meas tran vdout1_11ck96 FIND v(dout1_11) AT=1940.1n

* CHECK dout1_12 Vdout1_12ck96 = 1.8 time = 1940
.meas tran vdout1_12ck96 FIND v(dout1_12) AT=1940.1n

* CHECK dout1_13 Vdout1_13ck96 = 1.8 time = 1940
.meas tran vdout1_13ck96 FIND v(dout1_13) AT=1940.1n

* CHECK dout1_14 Vdout1_14ck96 = 1.8 time = 1940
.meas tran vdout1_14ck96 FIND v(dout1_14) AT=1940.1n

* CHECK dout1_15 Vdout1_15ck96 = 1.8 time = 1940
.meas tran vdout1_15ck96 FIND v(dout1_15) AT=1940.1n

* CHECK dout1_16 Vdout1_16ck96 = 1.8 time = 1940
.meas tran vdout1_16ck96 FIND v(dout1_16) AT=1940.1n

* CHECK dout1_17 Vdout1_17ck96 = 1.8 time = 1940
.meas tran vdout1_17ck96 FIND v(dout1_17) AT=1940.1n

* CHECK dout1_18 Vdout1_18ck96 = 1.8 time = 1940
.meas tran vdout1_18ck96 FIND v(dout1_18) AT=1940.1n

* CHECK dout1_19 Vdout1_19ck96 = 0 time = 1940
.meas tran vdout1_19ck96 FIND v(dout1_19) AT=1940.1n

* CHECK dout1_20 Vdout1_20ck96 = 0 time = 1940
.meas tran vdout1_20ck96 FIND v(dout1_20) AT=1940.1n

* CHECK dout1_21 Vdout1_21ck96 = 0 time = 1940
.meas tran vdout1_21ck96 FIND v(dout1_21) AT=1940.1n

* CHECK dout1_22 Vdout1_22ck96 = 0 time = 1940
.meas tran vdout1_22ck96 FIND v(dout1_22) AT=1940.1n

* CHECK dout1_23 Vdout1_23ck96 = 1.8 time = 1940
.meas tran vdout1_23ck96 FIND v(dout1_23) AT=1940.1n

* CHECK dout1_24 Vdout1_24ck96 = 0 time = 1940
.meas tran vdout1_24ck96 FIND v(dout1_24) AT=1940.1n

* CHECK dout1_25 Vdout1_25ck96 = 0 time = 1940
.meas tran vdout1_25ck96 FIND v(dout1_25) AT=1940.1n

* CHECK dout1_26 Vdout1_26ck96 = 0 time = 1940
.meas tran vdout1_26ck96 FIND v(dout1_26) AT=1940.1n

* CHECK dout1_27 Vdout1_27ck96 = 0 time = 1940
.meas tran vdout1_27ck96 FIND v(dout1_27) AT=1940.1n

* CHECK dout1_28 Vdout1_28ck96 = 1.8 time = 1940
.meas tran vdout1_28ck96 FIND v(dout1_28) AT=1940.1n

* CHECK dout1_29 Vdout1_29ck96 = 1.8 time = 1940
.meas tran vdout1_29ck96 FIND v(dout1_29) AT=1940.1n

* CHECK dout1_30 Vdout1_30ck96 = 0 time = 1940
.meas tran vdout1_30ck96 FIND v(dout1_30) AT=1940.1n

* CHECK dout1_31 Vdout1_31ck96 = 1.8 time = 1940
.meas tran vdout1_31ck96 FIND v(dout1_31) AT=1940.1n

* CHECK dout2_0 Vdout2_0ck96 = 1.8 time = 1940
.meas tran vdout2_0ck96 FIND v(dout2_0) AT=1940.1n

* CHECK dout2_1 Vdout2_1ck96 = 1.8 time = 1940
.meas tran vdout2_1ck96 FIND v(dout2_1) AT=1940.1n

* CHECK dout2_2 Vdout2_2ck96 = 1.8 time = 1940
.meas tran vdout2_2ck96 FIND v(dout2_2) AT=1940.1n

* CHECK dout2_3 Vdout2_3ck96 = 1.8 time = 1940
.meas tran vdout2_3ck96 FIND v(dout2_3) AT=1940.1n

* CHECK dout2_4 Vdout2_4ck96 = 1.8 time = 1940
.meas tran vdout2_4ck96 FIND v(dout2_4) AT=1940.1n

* CHECK dout2_5 Vdout2_5ck96 = 1.8 time = 1940
.meas tran vdout2_5ck96 FIND v(dout2_5) AT=1940.1n

* CHECK dout2_6 Vdout2_6ck96 = 1.8 time = 1940
.meas tran vdout2_6ck96 FIND v(dout2_6) AT=1940.1n

* CHECK dout2_7 Vdout2_7ck96 = 0 time = 1940
.meas tran vdout2_7ck96 FIND v(dout2_7) AT=1940.1n

* CHECK dout2_8 Vdout2_8ck96 = 1.8 time = 1940
.meas tran vdout2_8ck96 FIND v(dout2_8) AT=1940.1n

* CHECK dout2_9 Vdout2_9ck96 = 1.8 time = 1940
.meas tran vdout2_9ck96 FIND v(dout2_9) AT=1940.1n

* CHECK dout2_10 Vdout2_10ck96 = 1.8 time = 1940
.meas tran vdout2_10ck96 FIND v(dout2_10) AT=1940.1n

* CHECK dout2_11 Vdout2_11ck96 = 0 time = 1940
.meas tran vdout2_11ck96 FIND v(dout2_11) AT=1940.1n

* CHECK dout2_12 Vdout2_12ck96 = 0 time = 1940
.meas tran vdout2_12ck96 FIND v(dout2_12) AT=1940.1n

* CHECK dout2_13 Vdout2_13ck96 = 1.8 time = 1940
.meas tran vdout2_13ck96 FIND v(dout2_13) AT=1940.1n

* CHECK dout2_14 Vdout2_14ck96 = 0 time = 1940
.meas tran vdout2_14ck96 FIND v(dout2_14) AT=1940.1n

* CHECK dout2_15 Vdout2_15ck96 = 1.8 time = 1940
.meas tran vdout2_15ck96 FIND v(dout2_15) AT=1940.1n

* CHECK dout2_16 Vdout2_16ck96 = 0 time = 1940
.meas tran vdout2_16ck96 FIND v(dout2_16) AT=1940.1n

* CHECK dout2_17 Vdout2_17ck96 = 0 time = 1940
.meas tran vdout2_17ck96 FIND v(dout2_17) AT=1940.1n

* CHECK dout2_18 Vdout2_18ck96 = 0 time = 1940
.meas tran vdout2_18ck96 FIND v(dout2_18) AT=1940.1n

* CHECK dout2_19 Vdout2_19ck96 = 0 time = 1940
.meas tran vdout2_19ck96 FIND v(dout2_19) AT=1940.1n

* CHECK dout2_20 Vdout2_20ck96 = 0 time = 1940
.meas tran vdout2_20ck96 FIND v(dout2_20) AT=1940.1n

* CHECK dout2_21 Vdout2_21ck96 = 0 time = 1940
.meas tran vdout2_21ck96 FIND v(dout2_21) AT=1940.1n

* CHECK dout2_22 Vdout2_22ck96 = 1.8 time = 1940
.meas tran vdout2_22ck96 FIND v(dout2_22) AT=1940.1n

* CHECK dout2_23 Vdout2_23ck96 = 1.8 time = 1940
.meas tran vdout2_23ck96 FIND v(dout2_23) AT=1940.1n

* CHECK dout2_24 Vdout2_24ck96 = 1.8 time = 1940
.meas tran vdout2_24ck96 FIND v(dout2_24) AT=1940.1n

* CHECK dout2_25 Vdout2_25ck96 = 1.8 time = 1940
.meas tran vdout2_25ck96 FIND v(dout2_25) AT=1940.1n

* CHECK dout2_26 Vdout2_26ck96 = 0 time = 1940
.meas tran vdout2_26ck96 FIND v(dout2_26) AT=1940.1n

* CHECK dout2_27 Vdout2_27ck96 = 0 time = 1940
.meas tran vdout2_27ck96 FIND v(dout2_27) AT=1940.1n

* CHECK dout2_28 Vdout2_28ck96 = 1.8 time = 1940
.meas tran vdout2_28ck96 FIND v(dout2_28) AT=1940.1n

* CHECK dout2_29 Vdout2_29ck96 = 0 time = 1940
.meas tran vdout2_29ck96 FIND v(dout2_29) AT=1940.1n

* CHECK dout2_30 Vdout2_30ck96 = 0 time = 1940
.meas tran vdout2_30ck96 FIND v(dout2_30) AT=1940.1n

* CHECK dout2_31 Vdout2_31ck96 = 1.8 time = 1940
.meas tran vdout2_31ck96 FIND v(dout2_31) AT=1940.1n

* CHECK dout1_0 Vdout1_0ck97 = 1.8 time = 1960
.meas tran vdout1_0ck97 FIND v(dout1_0) AT=1960.1n

* CHECK dout1_1 Vdout1_1ck97 = 1.8 time = 1960
.meas tran vdout1_1ck97 FIND v(dout1_1) AT=1960.1n

* CHECK dout1_2 Vdout1_2ck97 = 1.8 time = 1960
.meas tran vdout1_2ck97 FIND v(dout1_2) AT=1960.1n

* CHECK dout1_3 Vdout1_3ck97 = 1.8 time = 1960
.meas tran vdout1_3ck97 FIND v(dout1_3) AT=1960.1n

* CHECK dout1_4 Vdout1_4ck97 = 0 time = 1960
.meas tran vdout1_4ck97 FIND v(dout1_4) AT=1960.1n

* CHECK dout1_5 Vdout1_5ck97 = 1.8 time = 1960
.meas tran vdout1_5ck97 FIND v(dout1_5) AT=1960.1n

* CHECK dout1_6 Vdout1_6ck97 = 1.8 time = 1960
.meas tran vdout1_6ck97 FIND v(dout1_6) AT=1960.1n

* CHECK dout1_7 Vdout1_7ck97 = 1.8 time = 1960
.meas tran vdout1_7ck97 FIND v(dout1_7) AT=1960.1n

* CHECK dout1_8 Vdout1_8ck97 = 1.8 time = 1960
.meas tran vdout1_8ck97 FIND v(dout1_8) AT=1960.1n

* CHECK dout1_9 Vdout1_9ck97 = 1.8 time = 1960
.meas tran vdout1_9ck97 FIND v(dout1_9) AT=1960.1n

* CHECK dout1_10 Vdout1_10ck97 = 0 time = 1960
.meas tran vdout1_10ck97 FIND v(dout1_10) AT=1960.1n

* CHECK dout1_11 Vdout1_11ck97 = 0 time = 1960
.meas tran vdout1_11ck97 FIND v(dout1_11) AT=1960.1n

* CHECK dout1_12 Vdout1_12ck97 = 1.8 time = 1960
.meas tran vdout1_12ck97 FIND v(dout1_12) AT=1960.1n

* CHECK dout1_13 Vdout1_13ck97 = 1.8 time = 1960
.meas tran vdout1_13ck97 FIND v(dout1_13) AT=1960.1n

* CHECK dout1_14 Vdout1_14ck97 = 1.8 time = 1960
.meas tran vdout1_14ck97 FIND v(dout1_14) AT=1960.1n

* CHECK dout1_15 Vdout1_15ck97 = 1.8 time = 1960
.meas tran vdout1_15ck97 FIND v(dout1_15) AT=1960.1n

* CHECK dout1_16 Vdout1_16ck97 = 1.8 time = 1960
.meas tran vdout1_16ck97 FIND v(dout1_16) AT=1960.1n

* CHECK dout1_17 Vdout1_17ck97 = 1.8 time = 1960
.meas tran vdout1_17ck97 FIND v(dout1_17) AT=1960.1n

* CHECK dout1_18 Vdout1_18ck97 = 1.8 time = 1960
.meas tran vdout1_18ck97 FIND v(dout1_18) AT=1960.1n

* CHECK dout1_19 Vdout1_19ck97 = 0 time = 1960
.meas tran vdout1_19ck97 FIND v(dout1_19) AT=1960.1n

* CHECK dout1_20 Vdout1_20ck97 = 0 time = 1960
.meas tran vdout1_20ck97 FIND v(dout1_20) AT=1960.1n

* CHECK dout1_21 Vdout1_21ck97 = 0 time = 1960
.meas tran vdout1_21ck97 FIND v(dout1_21) AT=1960.1n

* CHECK dout1_22 Vdout1_22ck97 = 0 time = 1960
.meas tran vdout1_22ck97 FIND v(dout1_22) AT=1960.1n

* CHECK dout1_23 Vdout1_23ck97 = 1.8 time = 1960
.meas tran vdout1_23ck97 FIND v(dout1_23) AT=1960.1n

* CHECK dout1_24 Vdout1_24ck97 = 0 time = 1960
.meas tran vdout1_24ck97 FIND v(dout1_24) AT=1960.1n

* CHECK dout1_25 Vdout1_25ck97 = 0 time = 1960
.meas tran vdout1_25ck97 FIND v(dout1_25) AT=1960.1n

* CHECK dout1_26 Vdout1_26ck97 = 0 time = 1960
.meas tran vdout1_26ck97 FIND v(dout1_26) AT=1960.1n

* CHECK dout1_27 Vdout1_27ck97 = 0 time = 1960
.meas tran vdout1_27ck97 FIND v(dout1_27) AT=1960.1n

* CHECK dout1_28 Vdout1_28ck97 = 1.8 time = 1960
.meas tran vdout1_28ck97 FIND v(dout1_28) AT=1960.1n

* CHECK dout1_29 Vdout1_29ck97 = 1.8 time = 1960
.meas tran vdout1_29ck97 FIND v(dout1_29) AT=1960.1n

* CHECK dout1_30 Vdout1_30ck97 = 0 time = 1960
.meas tran vdout1_30ck97 FIND v(dout1_30) AT=1960.1n

* CHECK dout1_31 Vdout1_31ck97 = 1.8 time = 1960
.meas tran vdout1_31ck97 FIND v(dout1_31) AT=1960.1n

* CHECK dout2_0 Vdout2_0ck97 = 1.8 time = 1960
.meas tran vdout2_0ck97 FIND v(dout2_0) AT=1960.1n

* CHECK dout2_1 Vdout2_1ck97 = 1.8 time = 1960
.meas tran vdout2_1ck97 FIND v(dout2_1) AT=1960.1n

* CHECK dout2_2 Vdout2_2ck97 = 1.8 time = 1960
.meas tran vdout2_2ck97 FIND v(dout2_2) AT=1960.1n

* CHECK dout2_3 Vdout2_3ck97 = 1.8 time = 1960
.meas tran vdout2_3ck97 FIND v(dout2_3) AT=1960.1n

* CHECK dout2_4 Vdout2_4ck97 = 1.8 time = 1960
.meas tran vdout2_4ck97 FIND v(dout2_4) AT=1960.1n

* CHECK dout2_5 Vdout2_5ck97 = 1.8 time = 1960
.meas tran vdout2_5ck97 FIND v(dout2_5) AT=1960.1n

* CHECK dout2_6 Vdout2_6ck97 = 1.8 time = 1960
.meas tran vdout2_6ck97 FIND v(dout2_6) AT=1960.1n

* CHECK dout2_7 Vdout2_7ck97 = 0 time = 1960
.meas tran vdout2_7ck97 FIND v(dout2_7) AT=1960.1n

* CHECK dout2_8 Vdout2_8ck97 = 1.8 time = 1960
.meas tran vdout2_8ck97 FIND v(dout2_8) AT=1960.1n

* CHECK dout2_9 Vdout2_9ck97 = 1.8 time = 1960
.meas tran vdout2_9ck97 FIND v(dout2_9) AT=1960.1n

* CHECK dout2_10 Vdout2_10ck97 = 1.8 time = 1960
.meas tran vdout2_10ck97 FIND v(dout2_10) AT=1960.1n

* CHECK dout2_11 Vdout2_11ck97 = 0 time = 1960
.meas tran vdout2_11ck97 FIND v(dout2_11) AT=1960.1n

* CHECK dout2_12 Vdout2_12ck97 = 0 time = 1960
.meas tran vdout2_12ck97 FIND v(dout2_12) AT=1960.1n

* CHECK dout2_13 Vdout2_13ck97 = 1.8 time = 1960
.meas tran vdout2_13ck97 FIND v(dout2_13) AT=1960.1n

* CHECK dout2_14 Vdout2_14ck97 = 0 time = 1960
.meas tran vdout2_14ck97 FIND v(dout2_14) AT=1960.1n

* CHECK dout2_15 Vdout2_15ck97 = 1.8 time = 1960
.meas tran vdout2_15ck97 FIND v(dout2_15) AT=1960.1n

* CHECK dout2_16 Vdout2_16ck97 = 0 time = 1960
.meas tran vdout2_16ck97 FIND v(dout2_16) AT=1960.1n

* CHECK dout2_17 Vdout2_17ck97 = 0 time = 1960
.meas tran vdout2_17ck97 FIND v(dout2_17) AT=1960.1n

* CHECK dout2_18 Vdout2_18ck97 = 0 time = 1960
.meas tran vdout2_18ck97 FIND v(dout2_18) AT=1960.1n

* CHECK dout2_19 Vdout2_19ck97 = 0 time = 1960
.meas tran vdout2_19ck97 FIND v(dout2_19) AT=1960.1n

* CHECK dout2_20 Vdout2_20ck97 = 0 time = 1960
.meas tran vdout2_20ck97 FIND v(dout2_20) AT=1960.1n

* CHECK dout2_21 Vdout2_21ck97 = 0 time = 1960
.meas tran vdout2_21ck97 FIND v(dout2_21) AT=1960.1n

* CHECK dout2_22 Vdout2_22ck97 = 1.8 time = 1960
.meas tran vdout2_22ck97 FIND v(dout2_22) AT=1960.1n

* CHECK dout2_23 Vdout2_23ck97 = 1.8 time = 1960
.meas tran vdout2_23ck97 FIND v(dout2_23) AT=1960.1n

* CHECK dout2_24 Vdout2_24ck97 = 1.8 time = 1960
.meas tran vdout2_24ck97 FIND v(dout2_24) AT=1960.1n

* CHECK dout2_25 Vdout2_25ck97 = 1.8 time = 1960
.meas tran vdout2_25ck97 FIND v(dout2_25) AT=1960.1n

* CHECK dout2_26 Vdout2_26ck97 = 0 time = 1960
.meas tran vdout2_26ck97 FIND v(dout2_26) AT=1960.1n

* CHECK dout2_27 Vdout2_27ck97 = 0 time = 1960
.meas tran vdout2_27ck97 FIND v(dout2_27) AT=1960.1n

* CHECK dout2_28 Vdout2_28ck97 = 1.8 time = 1960
.meas tran vdout2_28ck97 FIND v(dout2_28) AT=1960.1n

* CHECK dout2_29 Vdout2_29ck97 = 0 time = 1960
.meas tran vdout2_29ck97 FIND v(dout2_29) AT=1960.1n

* CHECK dout2_30 Vdout2_30ck97 = 0 time = 1960
.meas tran vdout2_30ck97 FIND v(dout2_30) AT=1960.1n

* CHECK dout2_31 Vdout2_31ck97 = 1.8 time = 1960
.meas tran vdout2_31ck97 FIND v(dout2_31) AT=1960.1n

* CHECK dout1_0 Vdout1_0ck98 = 1.8 time = 1980
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=1980.1n

* CHECK dout1_1 Vdout1_1ck98 = 0 time = 1980
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=1980.1n

* CHECK dout1_2 Vdout1_2ck98 = 0 time = 1980
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=1980.1n

* CHECK dout1_3 Vdout1_3ck98 = 1.8 time = 1980
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=1980.1n

* CHECK dout1_4 Vdout1_4ck98 = 1.8 time = 1980
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=1980.1n

* CHECK dout1_5 Vdout1_5ck98 = 1.8 time = 1980
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=1980.1n

* CHECK dout1_6 Vdout1_6ck98 = 1.8 time = 1980
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=1980.1n

* CHECK dout1_7 Vdout1_7ck98 = 1.8 time = 1980
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=1980.1n

* CHECK dout1_8 Vdout1_8ck98 = 0 time = 1980
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=1980.1n

* CHECK dout1_9 Vdout1_9ck98 = 1.8 time = 1980
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=1980.1n

* CHECK dout1_10 Vdout1_10ck98 = 0 time = 1980
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=1980.1n

* CHECK dout1_11 Vdout1_11ck98 = 1.8 time = 1980
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=1980.1n

* CHECK dout1_12 Vdout1_12ck98 = 0 time = 1980
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=1980.1n

* CHECK dout1_13 Vdout1_13ck98 = 0 time = 1980
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=1980.1n

* CHECK dout1_14 Vdout1_14ck98 = 0 time = 1980
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=1980.1n

* CHECK dout1_15 Vdout1_15ck98 = 0 time = 1980
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=1980.1n

* CHECK dout1_16 Vdout1_16ck98 = 0 time = 1980
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=1980.1n

* CHECK dout1_17 Vdout1_17ck98 = 1.8 time = 1980
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=1980.1n

* CHECK dout1_18 Vdout1_18ck98 = 1.8 time = 1980
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=1980.1n

* CHECK dout1_19 Vdout1_19ck98 = 0 time = 1980
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=1980.1n

* CHECK dout1_20 Vdout1_20ck98 = 1.8 time = 1980
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=1980.1n

* CHECK dout1_21 Vdout1_21ck98 = 0 time = 1980
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=1980.1n

* CHECK dout1_22 Vdout1_22ck98 = 0 time = 1980
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=1980.1n

* CHECK dout1_23 Vdout1_23ck98 = 0 time = 1980
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=1980.1n

* CHECK dout1_24 Vdout1_24ck98 = 1.8 time = 1980
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=1980.1n

* CHECK dout1_25 Vdout1_25ck98 = 1.8 time = 1980
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=1980.1n

* CHECK dout1_26 Vdout1_26ck98 = 0 time = 1980
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=1980.1n

* CHECK dout1_27 Vdout1_27ck98 = 1.8 time = 1980
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=1980.1n

* CHECK dout1_28 Vdout1_28ck98 = 0 time = 1980
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=1980.1n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 1980
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=1980.1n

* CHECK dout1_30 Vdout1_30ck98 = 0 time = 1980
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=1980.1n

* CHECK dout1_31 Vdout1_31ck98 = 1.8 time = 1980
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=1980.1n

* CHECK dout1_0 Vdout1_0ck99 = 0 time = 2000
.meas tran vdout1_0ck99 FIND v(dout1_0) AT=2000.1n

* CHECK dout1_1 Vdout1_1ck99 = 0 time = 2000
.meas tran vdout1_1ck99 FIND v(dout1_1) AT=2000.1n

* CHECK dout1_2 Vdout1_2ck99 = 1.8 time = 2000
.meas tran vdout1_2ck99 FIND v(dout1_2) AT=2000.1n

* CHECK dout1_3 Vdout1_3ck99 = 0 time = 2000
.meas tran vdout1_3ck99 FIND v(dout1_3) AT=2000.1n

* CHECK dout1_4 Vdout1_4ck99 = 0 time = 2000
.meas tran vdout1_4ck99 FIND v(dout1_4) AT=2000.1n

* CHECK dout1_5 Vdout1_5ck99 = 0 time = 2000
.meas tran vdout1_5ck99 FIND v(dout1_5) AT=2000.1n

* CHECK dout1_6 Vdout1_6ck99 = 1.8 time = 2000
.meas tran vdout1_6ck99 FIND v(dout1_6) AT=2000.1n

* CHECK dout1_7 Vdout1_7ck99 = 1.8 time = 2000
.meas tran vdout1_7ck99 FIND v(dout1_7) AT=2000.1n

* CHECK dout1_8 Vdout1_8ck99 = 1.8 time = 2000
.meas tran vdout1_8ck99 FIND v(dout1_8) AT=2000.1n

* CHECK dout1_9 Vdout1_9ck99 = 0 time = 2000
.meas tran vdout1_9ck99 FIND v(dout1_9) AT=2000.1n

* CHECK dout1_10 Vdout1_10ck99 = 1.8 time = 2000
.meas tran vdout1_10ck99 FIND v(dout1_10) AT=2000.1n

* CHECK dout1_11 Vdout1_11ck99 = 0 time = 2000
.meas tran vdout1_11ck99 FIND v(dout1_11) AT=2000.1n

* CHECK dout1_12 Vdout1_12ck99 = 0 time = 2000
.meas tran vdout1_12ck99 FIND v(dout1_12) AT=2000.1n

* CHECK dout1_13 Vdout1_13ck99 = 0 time = 2000
.meas tran vdout1_13ck99 FIND v(dout1_13) AT=2000.1n

* CHECK dout1_14 Vdout1_14ck99 = 0 time = 2000
.meas tran vdout1_14ck99 FIND v(dout1_14) AT=2000.1n

* CHECK dout1_15 Vdout1_15ck99 = 1.8 time = 2000
.meas tran vdout1_15ck99 FIND v(dout1_15) AT=2000.1n

* CHECK dout1_16 Vdout1_16ck99 = 0 time = 2000
.meas tran vdout1_16ck99 FIND v(dout1_16) AT=2000.1n

* CHECK dout1_17 Vdout1_17ck99 = 0 time = 2000
.meas tran vdout1_17ck99 FIND v(dout1_17) AT=2000.1n

* CHECK dout1_18 Vdout1_18ck99 = 1.8 time = 2000
.meas tran vdout1_18ck99 FIND v(dout1_18) AT=2000.1n

* CHECK dout1_19 Vdout1_19ck99 = 1.8 time = 2000
.meas tran vdout1_19ck99 FIND v(dout1_19) AT=2000.1n

* CHECK dout1_20 Vdout1_20ck99 = 1.8 time = 2000
.meas tran vdout1_20ck99 FIND v(dout1_20) AT=2000.1n

* CHECK dout1_21 Vdout1_21ck99 = 1.8 time = 2000
.meas tran vdout1_21ck99 FIND v(dout1_21) AT=2000.1n

* CHECK dout1_22 Vdout1_22ck99 = 0 time = 2000
.meas tran vdout1_22ck99 FIND v(dout1_22) AT=2000.1n

* CHECK dout1_23 Vdout1_23ck99 = 1.8 time = 2000
.meas tran vdout1_23ck99 FIND v(dout1_23) AT=2000.1n

* CHECK dout1_24 Vdout1_24ck99 = 0 time = 2000
.meas tran vdout1_24ck99 FIND v(dout1_24) AT=2000.1n

* CHECK dout1_25 Vdout1_25ck99 = 0 time = 2000
.meas tran vdout1_25ck99 FIND v(dout1_25) AT=2000.1n

* CHECK dout1_26 Vdout1_26ck99 = 0 time = 2000
.meas tran vdout1_26ck99 FIND v(dout1_26) AT=2000.1n

* CHECK dout1_27 Vdout1_27ck99 = 1.8 time = 2000
.meas tran vdout1_27ck99 FIND v(dout1_27) AT=2000.1n

* CHECK dout1_28 Vdout1_28ck99 = 1.8 time = 2000
.meas tran vdout1_28ck99 FIND v(dout1_28) AT=2000.1n

* CHECK dout1_29 Vdout1_29ck99 = 0 time = 2000
.meas tran vdout1_29ck99 FIND v(dout1_29) AT=2000.1n

* CHECK dout1_30 Vdout1_30ck99 = 1.8 time = 2000
.meas tran vdout1_30ck99 FIND v(dout1_30) AT=2000.1n

* CHECK dout1_31 Vdout1_31ck99 = 1.8 time = 2000
.meas tran vdout1_31ck99 FIND v(dout1_31) AT=2000.1n

* CHECK dout2_0 Vdout2_0ck99 = 1.8 time = 2000
.meas tran vdout2_0ck99 FIND v(dout2_0) AT=2000.1n

* CHECK dout2_1 Vdout2_1ck99 = 0 time = 2000
.meas tran vdout2_1ck99 FIND v(dout2_1) AT=2000.1n

* CHECK dout2_2 Vdout2_2ck99 = 0 time = 2000
.meas tran vdout2_2ck99 FIND v(dout2_2) AT=2000.1n

* CHECK dout2_3 Vdout2_3ck99 = 1.8 time = 2000
.meas tran vdout2_3ck99 FIND v(dout2_3) AT=2000.1n

* CHECK dout2_4 Vdout2_4ck99 = 1.8 time = 2000
.meas tran vdout2_4ck99 FIND v(dout2_4) AT=2000.1n

* CHECK dout2_5 Vdout2_5ck99 = 1.8 time = 2000
.meas tran vdout2_5ck99 FIND v(dout2_5) AT=2000.1n

* CHECK dout2_6 Vdout2_6ck99 = 1.8 time = 2000
.meas tran vdout2_6ck99 FIND v(dout2_6) AT=2000.1n

* CHECK dout2_7 Vdout2_7ck99 = 1.8 time = 2000
.meas tran vdout2_7ck99 FIND v(dout2_7) AT=2000.1n

* CHECK dout2_8 Vdout2_8ck99 = 0 time = 2000
.meas tran vdout2_8ck99 FIND v(dout2_8) AT=2000.1n

* CHECK dout2_9 Vdout2_9ck99 = 1.8 time = 2000
.meas tran vdout2_9ck99 FIND v(dout2_9) AT=2000.1n

* CHECK dout2_10 Vdout2_10ck99 = 0 time = 2000
.meas tran vdout2_10ck99 FIND v(dout2_10) AT=2000.1n

* CHECK dout2_11 Vdout2_11ck99 = 1.8 time = 2000
.meas tran vdout2_11ck99 FIND v(dout2_11) AT=2000.1n

* CHECK dout2_12 Vdout2_12ck99 = 0 time = 2000
.meas tran vdout2_12ck99 FIND v(dout2_12) AT=2000.1n

* CHECK dout2_13 Vdout2_13ck99 = 0 time = 2000
.meas tran vdout2_13ck99 FIND v(dout2_13) AT=2000.1n

* CHECK dout2_14 Vdout2_14ck99 = 0 time = 2000
.meas tran vdout2_14ck99 FIND v(dout2_14) AT=2000.1n

* CHECK dout2_15 Vdout2_15ck99 = 0 time = 2000
.meas tran vdout2_15ck99 FIND v(dout2_15) AT=2000.1n

* CHECK dout2_16 Vdout2_16ck99 = 0 time = 2000
.meas tran vdout2_16ck99 FIND v(dout2_16) AT=2000.1n

* CHECK dout2_17 Vdout2_17ck99 = 1.8 time = 2000
.meas tran vdout2_17ck99 FIND v(dout2_17) AT=2000.1n

* CHECK dout2_18 Vdout2_18ck99 = 1.8 time = 2000
.meas tran vdout2_18ck99 FIND v(dout2_18) AT=2000.1n

* CHECK dout2_19 Vdout2_19ck99 = 0 time = 2000
.meas tran vdout2_19ck99 FIND v(dout2_19) AT=2000.1n

* CHECK dout2_20 Vdout2_20ck99 = 1.8 time = 2000
.meas tran vdout2_20ck99 FIND v(dout2_20) AT=2000.1n

* CHECK dout2_21 Vdout2_21ck99 = 0 time = 2000
.meas tran vdout2_21ck99 FIND v(dout2_21) AT=2000.1n

* CHECK dout2_22 Vdout2_22ck99 = 0 time = 2000
.meas tran vdout2_22ck99 FIND v(dout2_22) AT=2000.1n

* CHECK dout2_23 Vdout2_23ck99 = 0 time = 2000
.meas tran vdout2_23ck99 FIND v(dout2_23) AT=2000.1n

* CHECK dout2_24 Vdout2_24ck99 = 1.8 time = 2000
.meas tran vdout2_24ck99 FIND v(dout2_24) AT=2000.1n

* CHECK dout2_25 Vdout2_25ck99 = 1.8 time = 2000
.meas tran vdout2_25ck99 FIND v(dout2_25) AT=2000.1n

* CHECK dout2_26 Vdout2_26ck99 = 0 time = 2000
.meas tran vdout2_26ck99 FIND v(dout2_26) AT=2000.1n

* CHECK dout2_27 Vdout2_27ck99 = 1.8 time = 2000
.meas tran vdout2_27ck99 FIND v(dout2_27) AT=2000.1n

* CHECK dout2_28 Vdout2_28ck99 = 0 time = 2000
.meas tran vdout2_28ck99 FIND v(dout2_28) AT=2000.1n

* CHECK dout2_29 Vdout2_29ck99 = 0 time = 2000
.meas tran vdout2_29ck99 FIND v(dout2_29) AT=2000.1n

* CHECK dout2_30 Vdout2_30ck99 = 0 time = 2000
.meas tran vdout2_30ck99 FIND v(dout2_30) AT=2000.1n

* CHECK dout2_31 Vdout2_31ck99 = 1.8 time = 2000
.meas tran vdout2_31ck99 FIND v(dout2_31) AT=2000.1n

* CHECK dout1_0 Vdout1_0ck100 = 0 time = 2020
.meas tran vdout1_0ck100 FIND v(dout1_0) AT=2020.1n

* CHECK dout1_1 Vdout1_1ck100 = 0 time = 2020
.meas tran vdout1_1ck100 FIND v(dout1_1) AT=2020.1n

* CHECK dout1_2 Vdout1_2ck100 = 0 time = 2020
.meas tran vdout1_2ck100 FIND v(dout1_2) AT=2020.1n

* CHECK dout1_3 Vdout1_3ck100 = 0 time = 2020
.meas tran vdout1_3ck100 FIND v(dout1_3) AT=2020.1n

* CHECK dout1_4 Vdout1_4ck100 = 1.8 time = 2020
.meas tran vdout1_4ck100 FIND v(dout1_4) AT=2020.1n

* CHECK dout1_5 Vdout1_5ck100 = 1.8 time = 2020
.meas tran vdout1_5ck100 FIND v(dout1_5) AT=2020.1n

* CHECK dout1_6 Vdout1_6ck100 = 0 time = 2020
.meas tran vdout1_6ck100 FIND v(dout1_6) AT=2020.1n

* CHECK dout1_7 Vdout1_7ck100 = 0 time = 2020
.meas tran vdout1_7ck100 FIND v(dout1_7) AT=2020.1n

* CHECK dout1_8 Vdout1_8ck100 = 1.8 time = 2020
.meas tran vdout1_8ck100 FIND v(dout1_8) AT=2020.1n

* CHECK dout1_9 Vdout1_9ck100 = 1.8 time = 2020
.meas tran vdout1_9ck100 FIND v(dout1_9) AT=2020.1n

* CHECK dout1_10 Vdout1_10ck100 = 0 time = 2020
.meas tran vdout1_10ck100 FIND v(dout1_10) AT=2020.1n

* CHECK dout1_11 Vdout1_11ck100 = 1.8 time = 2020
.meas tran vdout1_11ck100 FIND v(dout1_11) AT=2020.1n

* CHECK dout1_12 Vdout1_12ck100 = 0 time = 2020
.meas tran vdout1_12ck100 FIND v(dout1_12) AT=2020.1n

* CHECK dout1_13 Vdout1_13ck100 = 0 time = 2020
.meas tran vdout1_13ck100 FIND v(dout1_13) AT=2020.1n

* CHECK dout1_14 Vdout1_14ck100 = 1.8 time = 2020
.meas tran vdout1_14ck100 FIND v(dout1_14) AT=2020.1n

* CHECK dout1_15 Vdout1_15ck100 = 0 time = 2020
.meas tran vdout1_15ck100 FIND v(dout1_15) AT=2020.1n

* CHECK dout1_16 Vdout1_16ck100 = 0 time = 2020
.meas tran vdout1_16ck100 FIND v(dout1_16) AT=2020.1n

* CHECK dout1_17 Vdout1_17ck100 = 0 time = 2020
.meas tran vdout1_17ck100 FIND v(dout1_17) AT=2020.1n

* CHECK dout1_18 Vdout1_18ck100 = 1.8 time = 2020
.meas tran vdout1_18ck100 FIND v(dout1_18) AT=2020.1n

* CHECK dout1_19 Vdout1_19ck100 = 0 time = 2020
.meas tran vdout1_19ck100 FIND v(dout1_19) AT=2020.1n

* CHECK dout1_20 Vdout1_20ck100 = 1.8 time = 2020
.meas tran vdout1_20ck100 FIND v(dout1_20) AT=2020.1n

* CHECK dout1_21 Vdout1_21ck100 = 0 time = 2020
.meas tran vdout1_21ck100 FIND v(dout1_21) AT=2020.1n

* CHECK dout1_22 Vdout1_22ck100 = 0 time = 2020
.meas tran vdout1_22ck100 FIND v(dout1_22) AT=2020.1n

* CHECK dout1_23 Vdout1_23ck100 = 1.8 time = 2020
.meas tran vdout1_23ck100 FIND v(dout1_23) AT=2020.1n

* CHECK dout1_24 Vdout1_24ck100 = 1.8 time = 2020
.meas tran vdout1_24ck100 FIND v(dout1_24) AT=2020.1n

* CHECK dout1_25 Vdout1_25ck100 = 0 time = 2020
.meas tran vdout1_25ck100 FIND v(dout1_25) AT=2020.1n

* CHECK dout1_26 Vdout1_26ck100 = 1.8 time = 2020
.meas tran vdout1_26ck100 FIND v(dout1_26) AT=2020.1n

* CHECK dout1_27 Vdout1_27ck100 = 1.8 time = 2020
.meas tran vdout1_27ck100 FIND v(dout1_27) AT=2020.1n

* CHECK dout1_28 Vdout1_28ck100 = 1.8 time = 2020
.meas tran vdout1_28ck100 FIND v(dout1_28) AT=2020.1n

* CHECK dout1_29 Vdout1_29ck100 = 1.8 time = 2020
.meas tran vdout1_29ck100 FIND v(dout1_29) AT=2020.1n

* CHECK dout1_30 Vdout1_30ck100 = 0 time = 2020
.meas tran vdout1_30ck100 FIND v(dout1_30) AT=2020.1n

* CHECK dout1_31 Vdout1_31ck100 = 1.8 time = 2020
.meas tran vdout1_31ck100 FIND v(dout1_31) AT=2020.1n

* CHECK dout2_0 Vdout2_0ck100 = 0 time = 2020
.meas tran vdout2_0ck100 FIND v(dout2_0) AT=2020.1n

* CHECK dout2_1 Vdout2_1ck100 = 0 time = 2020
.meas tran vdout2_1ck100 FIND v(dout2_1) AT=2020.1n

* CHECK dout2_2 Vdout2_2ck100 = 1.8 time = 2020
.meas tran vdout2_2ck100 FIND v(dout2_2) AT=2020.1n

* CHECK dout2_3 Vdout2_3ck100 = 0 time = 2020
.meas tran vdout2_3ck100 FIND v(dout2_3) AT=2020.1n

* CHECK dout2_4 Vdout2_4ck100 = 0 time = 2020
.meas tran vdout2_4ck100 FIND v(dout2_4) AT=2020.1n

* CHECK dout2_5 Vdout2_5ck100 = 0 time = 2020
.meas tran vdout2_5ck100 FIND v(dout2_5) AT=2020.1n

* CHECK dout2_6 Vdout2_6ck100 = 1.8 time = 2020
.meas tran vdout2_6ck100 FIND v(dout2_6) AT=2020.1n

* CHECK dout2_7 Vdout2_7ck100 = 1.8 time = 2020
.meas tran vdout2_7ck100 FIND v(dout2_7) AT=2020.1n

* CHECK dout2_8 Vdout2_8ck100 = 1.8 time = 2020
.meas tran vdout2_8ck100 FIND v(dout2_8) AT=2020.1n

* CHECK dout2_9 Vdout2_9ck100 = 0 time = 2020
.meas tran vdout2_9ck100 FIND v(dout2_9) AT=2020.1n

* CHECK dout2_10 Vdout2_10ck100 = 1.8 time = 2020
.meas tran vdout2_10ck100 FIND v(dout2_10) AT=2020.1n

* CHECK dout2_11 Vdout2_11ck100 = 0 time = 2020
.meas tran vdout2_11ck100 FIND v(dout2_11) AT=2020.1n

* CHECK dout2_12 Vdout2_12ck100 = 0 time = 2020
.meas tran vdout2_12ck100 FIND v(dout2_12) AT=2020.1n

* CHECK dout2_13 Vdout2_13ck100 = 0 time = 2020
.meas tran vdout2_13ck100 FIND v(dout2_13) AT=2020.1n

* CHECK dout2_14 Vdout2_14ck100 = 0 time = 2020
.meas tran vdout2_14ck100 FIND v(dout2_14) AT=2020.1n

* CHECK dout2_15 Vdout2_15ck100 = 1.8 time = 2020
.meas tran vdout2_15ck100 FIND v(dout2_15) AT=2020.1n

* CHECK dout2_16 Vdout2_16ck100 = 0 time = 2020
.meas tran vdout2_16ck100 FIND v(dout2_16) AT=2020.1n

* CHECK dout2_17 Vdout2_17ck100 = 0 time = 2020
.meas tran vdout2_17ck100 FIND v(dout2_17) AT=2020.1n

* CHECK dout2_18 Vdout2_18ck100 = 1.8 time = 2020
.meas tran vdout2_18ck100 FIND v(dout2_18) AT=2020.1n

* CHECK dout2_19 Vdout2_19ck100 = 1.8 time = 2020
.meas tran vdout2_19ck100 FIND v(dout2_19) AT=2020.1n

* CHECK dout2_20 Vdout2_20ck100 = 1.8 time = 2020
.meas tran vdout2_20ck100 FIND v(dout2_20) AT=2020.1n

* CHECK dout2_21 Vdout2_21ck100 = 1.8 time = 2020
.meas tran vdout2_21ck100 FIND v(dout2_21) AT=2020.1n

* CHECK dout2_22 Vdout2_22ck100 = 0 time = 2020
.meas tran vdout2_22ck100 FIND v(dout2_22) AT=2020.1n

* CHECK dout2_23 Vdout2_23ck100 = 1.8 time = 2020
.meas tran vdout2_23ck100 FIND v(dout2_23) AT=2020.1n

* CHECK dout2_24 Vdout2_24ck100 = 0 time = 2020
.meas tran vdout2_24ck100 FIND v(dout2_24) AT=2020.1n

* CHECK dout2_25 Vdout2_25ck100 = 0 time = 2020
.meas tran vdout2_25ck100 FIND v(dout2_25) AT=2020.1n

* CHECK dout2_26 Vdout2_26ck100 = 0 time = 2020
.meas tran vdout2_26ck100 FIND v(dout2_26) AT=2020.1n

* CHECK dout2_27 Vdout2_27ck100 = 1.8 time = 2020
.meas tran vdout2_27ck100 FIND v(dout2_27) AT=2020.1n

* CHECK dout2_28 Vdout2_28ck100 = 1.8 time = 2020
.meas tran vdout2_28ck100 FIND v(dout2_28) AT=2020.1n

* CHECK dout2_29 Vdout2_29ck100 = 0 time = 2020
.meas tran vdout2_29ck100 FIND v(dout2_29) AT=2020.1n

* CHECK dout2_30 Vdout2_30ck100 = 1.8 time = 2020
.meas tran vdout2_30ck100 FIND v(dout2_30) AT=2020.1n

* CHECK dout2_31 Vdout2_31ck100 = 1.8 time = 2020
.meas tran vdout2_31ck100 FIND v(dout2_31) AT=2020.1n

* CHECK dout1_0 Vdout1_0ck101 = 1.8 time = 2040
.meas tran vdout1_0ck101 FIND v(dout1_0) AT=2040.1n

* CHECK dout1_1 Vdout1_1ck101 = 0 time = 2040
.meas tran vdout1_1ck101 FIND v(dout1_1) AT=2040.1n

* CHECK dout1_2 Vdout1_2ck101 = 0 time = 2040
.meas tran vdout1_2ck101 FIND v(dout1_2) AT=2040.1n

* CHECK dout1_3 Vdout1_3ck101 = 1.8 time = 2040
.meas tran vdout1_3ck101 FIND v(dout1_3) AT=2040.1n

* CHECK dout1_4 Vdout1_4ck101 = 1.8 time = 2040
.meas tran vdout1_4ck101 FIND v(dout1_4) AT=2040.1n

* CHECK dout1_5 Vdout1_5ck101 = 1.8 time = 2040
.meas tran vdout1_5ck101 FIND v(dout1_5) AT=2040.1n

* CHECK dout1_6 Vdout1_6ck101 = 1.8 time = 2040
.meas tran vdout1_6ck101 FIND v(dout1_6) AT=2040.1n

* CHECK dout1_7 Vdout1_7ck101 = 1.8 time = 2040
.meas tran vdout1_7ck101 FIND v(dout1_7) AT=2040.1n

* CHECK dout1_8 Vdout1_8ck101 = 0 time = 2040
.meas tran vdout1_8ck101 FIND v(dout1_8) AT=2040.1n

* CHECK dout1_9 Vdout1_9ck101 = 1.8 time = 2040
.meas tran vdout1_9ck101 FIND v(dout1_9) AT=2040.1n

* CHECK dout1_10 Vdout1_10ck101 = 0 time = 2040
.meas tran vdout1_10ck101 FIND v(dout1_10) AT=2040.1n

* CHECK dout1_11 Vdout1_11ck101 = 1.8 time = 2040
.meas tran vdout1_11ck101 FIND v(dout1_11) AT=2040.1n

* CHECK dout1_12 Vdout1_12ck101 = 0 time = 2040
.meas tran vdout1_12ck101 FIND v(dout1_12) AT=2040.1n

* CHECK dout1_13 Vdout1_13ck101 = 0 time = 2040
.meas tran vdout1_13ck101 FIND v(dout1_13) AT=2040.1n

* CHECK dout1_14 Vdout1_14ck101 = 0 time = 2040
.meas tran vdout1_14ck101 FIND v(dout1_14) AT=2040.1n

* CHECK dout1_15 Vdout1_15ck101 = 0 time = 2040
.meas tran vdout1_15ck101 FIND v(dout1_15) AT=2040.1n

* CHECK dout1_16 Vdout1_16ck101 = 0 time = 2040
.meas tran vdout1_16ck101 FIND v(dout1_16) AT=2040.1n

* CHECK dout1_17 Vdout1_17ck101 = 1.8 time = 2040
.meas tran vdout1_17ck101 FIND v(dout1_17) AT=2040.1n

* CHECK dout1_18 Vdout1_18ck101 = 1.8 time = 2040
.meas tran vdout1_18ck101 FIND v(dout1_18) AT=2040.1n

* CHECK dout1_19 Vdout1_19ck101 = 0 time = 2040
.meas tran vdout1_19ck101 FIND v(dout1_19) AT=2040.1n

* CHECK dout1_20 Vdout1_20ck101 = 1.8 time = 2040
.meas tran vdout1_20ck101 FIND v(dout1_20) AT=2040.1n

* CHECK dout1_21 Vdout1_21ck101 = 0 time = 2040
.meas tran vdout1_21ck101 FIND v(dout1_21) AT=2040.1n

* CHECK dout1_22 Vdout1_22ck101 = 0 time = 2040
.meas tran vdout1_22ck101 FIND v(dout1_22) AT=2040.1n

* CHECK dout1_23 Vdout1_23ck101 = 0 time = 2040
.meas tran vdout1_23ck101 FIND v(dout1_23) AT=2040.1n

* CHECK dout1_24 Vdout1_24ck101 = 1.8 time = 2040
.meas tran vdout1_24ck101 FIND v(dout1_24) AT=2040.1n

* CHECK dout1_25 Vdout1_25ck101 = 1.8 time = 2040
.meas tran vdout1_25ck101 FIND v(dout1_25) AT=2040.1n

* CHECK dout1_26 Vdout1_26ck101 = 0 time = 2040
.meas tran vdout1_26ck101 FIND v(dout1_26) AT=2040.1n

* CHECK dout1_27 Vdout1_27ck101 = 1.8 time = 2040
.meas tran vdout1_27ck101 FIND v(dout1_27) AT=2040.1n

* CHECK dout1_28 Vdout1_28ck101 = 0 time = 2040
.meas tran vdout1_28ck101 FIND v(dout1_28) AT=2040.1n

* CHECK dout1_29 Vdout1_29ck101 = 0 time = 2040
.meas tran vdout1_29ck101 FIND v(dout1_29) AT=2040.1n

* CHECK dout1_30 Vdout1_30ck101 = 0 time = 2040
.meas tran vdout1_30ck101 FIND v(dout1_30) AT=2040.1n

* CHECK dout1_31 Vdout1_31ck101 = 1.8 time = 2040
.meas tran vdout1_31ck101 FIND v(dout1_31) AT=2040.1n

* CHECK dout2_0 Vdout2_0ck101 = 1.8 time = 2040
.meas tran vdout2_0ck101 FIND v(dout2_0) AT=2040.1n

* CHECK dout2_1 Vdout2_1ck101 = 0 time = 2040
.meas tran vdout2_1ck101 FIND v(dout2_1) AT=2040.1n

* CHECK dout2_2 Vdout2_2ck101 = 0 time = 2040
.meas tran vdout2_2ck101 FIND v(dout2_2) AT=2040.1n

* CHECK dout2_3 Vdout2_3ck101 = 1.8 time = 2040
.meas tran vdout2_3ck101 FIND v(dout2_3) AT=2040.1n

* CHECK dout2_4 Vdout2_4ck101 = 1.8 time = 2040
.meas tran vdout2_4ck101 FIND v(dout2_4) AT=2040.1n

* CHECK dout2_5 Vdout2_5ck101 = 1.8 time = 2040
.meas tran vdout2_5ck101 FIND v(dout2_5) AT=2040.1n

* CHECK dout2_6 Vdout2_6ck101 = 1.8 time = 2040
.meas tran vdout2_6ck101 FIND v(dout2_6) AT=2040.1n

* CHECK dout2_7 Vdout2_7ck101 = 1.8 time = 2040
.meas tran vdout2_7ck101 FIND v(dout2_7) AT=2040.1n

* CHECK dout2_8 Vdout2_8ck101 = 0 time = 2040
.meas tran vdout2_8ck101 FIND v(dout2_8) AT=2040.1n

* CHECK dout2_9 Vdout2_9ck101 = 1.8 time = 2040
.meas tran vdout2_9ck101 FIND v(dout2_9) AT=2040.1n

* CHECK dout2_10 Vdout2_10ck101 = 0 time = 2040
.meas tran vdout2_10ck101 FIND v(dout2_10) AT=2040.1n

* CHECK dout2_11 Vdout2_11ck101 = 1.8 time = 2040
.meas tran vdout2_11ck101 FIND v(dout2_11) AT=2040.1n

* CHECK dout2_12 Vdout2_12ck101 = 0 time = 2040
.meas tran vdout2_12ck101 FIND v(dout2_12) AT=2040.1n

* CHECK dout2_13 Vdout2_13ck101 = 0 time = 2040
.meas tran vdout2_13ck101 FIND v(dout2_13) AT=2040.1n

* CHECK dout2_14 Vdout2_14ck101 = 0 time = 2040
.meas tran vdout2_14ck101 FIND v(dout2_14) AT=2040.1n

* CHECK dout2_15 Vdout2_15ck101 = 0 time = 2040
.meas tran vdout2_15ck101 FIND v(dout2_15) AT=2040.1n

* CHECK dout2_16 Vdout2_16ck101 = 0 time = 2040
.meas tran vdout2_16ck101 FIND v(dout2_16) AT=2040.1n

* CHECK dout2_17 Vdout2_17ck101 = 1.8 time = 2040
.meas tran vdout2_17ck101 FIND v(dout2_17) AT=2040.1n

* CHECK dout2_18 Vdout2_18ck101 = 1.8 time = 2040
.meas tran vdout2_18ck101 FIND v(dout2_18) AT=2040.1n

* CHECK dout2_19 Vdout2_19ck101 = 0 time = 2040
.meas tran vdout2_19ck101 FIND v(dout2_19) AT=2040.1n

* CHECK dout2_20 Vdout2_20ck101 = 1.8 time = 2040
.meas tran vdout2_20ck101 FIND v(dout2_20) AT=2040.1n

* CHECK dout2_21 Vdout2_21ck101 = 0 time = 2040
.meas tran vdout2_21ck101 FIND v(dout2_21) AT=2040.1n

* CHECK dout2_22 Vdout2_22ck101 = 0 time = 2040
.meas tran vdout2_22ck101 FIND v(dout2_22) AT=2040.1n

* CHECK dout2_23 Vdout2_23ck101 = 0 time = 2040
.meas tran vdout2_23ck101 FIND v(dout2_23) AT=2040.1n

* CHECK dout2_24 Vdout2_24ck101 = 1.8 time = 2040
.meas tran vdout2_24ck101 FIND v(dout2_24) AT=2040.1n

* CHECK dout2_25 Vdout2_25ck101 = 1.8 time = 2040
.meas tran vdout2_25ck101 FIND v(dout2_25) AT=2040.1n

* CHECK dout2_26 Vdout2_26ck101 = 0 time = 2040
.meas tran vdout2_26ck101 FIND v(dout2_26) AT=2040.1n

* CHECK dout2_27 Vdout2_27ck101 = 1.8 time = 2040
.meas tran vdout2_27ck101 FIND v(dout2_27) AT=2040.1n

* CHECK dout2_28 Vdout2_28ck101 = 0 time = 2040
.meas tran vdout2_28ck101 FIND v(dout2_28) AT=2040.1n

* CHECK dout2_29 Vdout2_29ck101 = 0 time = 2040
.meas tran vdout2_29ck101 FIND v(dout2_29) AT=2040.1n

* CHECK dout2_30 Vdout2_30ck101 = 0 time = 2040
.meas tran vdout2_30ck101 FIND v(dout2_30) AT=2040.1n

* CHECK dout2_31 Vdout2_31ck101 = 1.8 time = 2040
.meas tran vdout2_31ck101 FIND v(dout2_31) AT=2040.1n

* CHECK dout1_0 Vdout1_0ck102 = 0 time = 2060
.meas tran vdout1_0ck102 FIND v(dout1_0) AT=2060.1n

* CHECK dout1_1 Vdout1_1ck102 = 1.8 time = 2060
.meas tran vdout1_1ck102 FIND v(dout1_1) AT=2060.1n

* CHECK dout1_2 Vdout1_2ck102 = 0 time = 2060
.meas tran vdout1_2ck102 FIND v(dout1_2) AT=2060.1n

* CHECK dout1_3 Vdout1_3ck102 = 0 time = 2060
.meas tran vdout1_3ck102 FIND v(dout1_3) AT=2060.1n

* CHECK dout1_4 Vdout1_4ck102 = 0 time = 2060
.meas tran vdout1_4ck102 FIND v(dout1_4) AT=2060.1n

* CHECK dout1_5 Vdout1_5ck102 = 1.8 time = 2060
.meas tran vdout1_5ck102 FIND v(dout1_5) AT=2060.1n

* CHECK dout1_6 Vdout1_6ck102 = 0 time = 2060
.meas tran vdout1_6ck102 FIND v(dout1_6) AT=2060.1n

* CHECK dout1_7 Vdout1_7ck102 = 0 time = 2060
.meas tran vdout1_7ck102 FIND v(dout1_7) AT=2060.1n

* CHECK dout1_8 Vdout1_8ck102 = 0 time = 2060
.meas tran vdout1_8ck102 FIND v(dout1_8) AT=2060.1n

* CHECK dout1_9 Vdout1_9ck102 = 1.8 time = 2060
.meas tran vdout1_9ck102 FIND v(dout1_9) AT=2060.1n

* CHECK dout1_10 Vdout1_10ck102 = 0 time = 2060
.meas tran vdout1_10ck102 FIND v(dout1_10) AT=2060.1n

* CHECK dout1_11 Vdout1_11ck102 = 1.8 time = 2060
.meas tran vdout1_11ck102 FIND v(dout1_11) AT=2060.1n

* CHECK dout1_12 Vdout1_12ck102 = 1.8 time = 2060
.meas tran vdout1_12ck102 FIND v(dout1_12) AT=2060.1n

* CHECK dout1_13 Vdout1_13ck102 = 1.8 time = 2060
.meas tran vdout1_13ck102 FIND v(dout1_13) AT=2060.1n

* CHECK dout1_14 Vdout1_14ck102 = 0 time = 2060
.meas tran vdout1_14ck102 FIND v(dout1_14) AT=2060.1n

* CHECK dout1_15 Vdout1_15ck102 = 1.8 time = 2060
.meas tran vdout1_15ck102 FIND v(dout1_15) AT=2060.1n

* CHECK dout1_16 Vdout1_16ck102 = 0 time = 2060
.meas tran vdout1_16ck102 FIND v(dout1_16) AT=2060.1n

* CHECK dout1_17 Vdout1_17ck102 = 0 time = 2060
.meas tran vdout1_17ck102 FIND v(dout1_17) AT=2060.1n

* CHECK dout1_18 Vdout1_18ck102 = 1.8 time = 2060
.meas tran vdout1_18ck102 FIND v(dout1_18) AT=2060.1n

* CHECK dout1_19 Vdout1_19ck102 = 0 time = 2060
.meas tran vdout1_19ck102 FIND v(dout1_19) AT=2060.1n

* CHECK dout1_20 Vdout1_20ck102 = 1.8 time = 2060
.meas tran vdout1_20ck102 FIND v(dout1_20) AT=2060.1n

* CHECK dout1_21 Vdout1_21ck102 = 0 time = 2060
.meas tran vdout1_21ck102 FIND v(dout1_21) AT=2060.1n

* CHECK dout1_22 Vdout1_22ck102 = 0 time = 2060
.meas tran vdout1_22ck102 FIND v(dout1_22) AT=2060.1n

* CHECK dout1_23 Vdout1_23ck102 = 1.8 time = 2060
.meas tran vdout1_23ck102 FIND v(dout1_23) AT=2060.1n

* CHECK dout1_24 Vdout1_24ck102 = 0 time = 2060
.meas tran vdout1_24ck102 FIND v(dout1_24) AT=2060.1n

* CHECK dout1_25 Vdout1_25ck102 = 1.8 time = 2060
.meas tran vdout1_25ck102 FIND v(dout1_25) AT=2060.1n

* CHECK dout1_26 Vdout1_26ck102 = 1.8 time = 2060
.meas tran vdout1_26ck102 FIND v(dout1_26) AT=2060.1n

* CHECK dout1_27 Vdout1_27ck102 = 0 time = 2060
.meas tran vdout1_27ck102 FIND v(dout1_27) AT=2060.1n

* CHECK dout1_28 Vdout1_28ck102 = 0 time = 2060
.meas tran vdout1_28ck102 FIND v(dout1_28) AT=2060.1n

* CHECK dout1_29 Vdout1_29ck102 = 0 time = 2060
.meas tran vdout1_29ck102 FIND v(dout1_29) AT=2060.1n

* CHECK dout1_30 Vdout1_30ck102 = 1.8 time = 2060
.meas tran vdout1_30ck102 FIND v(dout1_30) AT=2060.1n

* CHECK dout1_31 Vdout1_31ck102 = 1.8 time = 2060
.meas tran vdout1_31ck102 FIND v(dout1_31) AT=2060.1n

* CHECK dout2_0 Vdout2_0ck102 = 0 time = 2060
.meas tran vdout2_0ck102 FIND v(dout2_0) AT=2060.1n

* CHECK dout2_1 Vdout2_1ck102 = 1.8 time = 2060
.meas tran vdout2_1ck102 FIND v(dout2_1) AT=2060.1n

* CHECK dout2_2 Vdout2_2ck102 = 0 time = 2060
.meas tran vdout2_2ck102 FIND v(dout2_2) AT=2060.1n

* CHECK dout2_3 Vdout2_3ck102 = 0 time = 2060
.meas tran vdout2_3ck102 FIND v(dout2_3) AT=2060.1n

* CHECK dout2_4 Vdout2_4ck102 = 0 time = 2060
.meas tran vdout2_4ck102 FIND v(dout2_4) AT=2060.1n

* CHECK dout2_5 Vdout2_5ck102 = 1.8 time = 2060
.meas tran vdout2_5ck102 FIND v(dout2_5) AT=2060.1n

* CHECK dout2_6 Vdout2_6ck102 = 0 time = 2060
.meas tran vdout2_6ck102 FIND v(dout2_6) AT=2060.1n

* CHECK dout2_7 Vdout2_7ck102 = 0 time = 2060
.meas tran vdout2_7ck102 FIND v(dout2_7) AT=2060.1n

* CHECK dout2_8 Vdout2_8ck102 = 0 time = 2060
.meas tran vdout2_8ck102 FIND v(dout2_8) AT=2060.1n

* CHECK dout2_9 Vdout2_9ck102 = 1.8 time = 2060
.meas tran vdout2_9ck102 FIND v(dout2_9) AT=2060.1n

* CHECK dout2_10 Vdout2_10ck102 = 0 time = 2060
.meas tran vdout2_10ck102 FIND v(dout2_10) AT=2060.1n

* CHECK dout2_11 Vdout2_11ck102 = 1.8 time = 2060
.meas tran vdout2_11ck102 FIND v(dout2_11) AT=2060.1n

* CHECK dout2_12 Vdout2_12ck102 = 1.8 time = 2060
.meas tran vdout2_12ck102 FIND v(dout2_12) AT=2060.1n

* CHECK dout2_13 Vdout2_13ck102 = 1.8 time = 2060
.meas tran vdout2_13ck102 FIND v(dout2_13) AT=2060.1n

* CHECK dout2_14 Vdout2_14ck102 = 0 time = 2060
.meas tran vdout2_14ck102 FIND v(dout2_14) AT=2060.1n

* CHECK dout2_15 Vdout2_15ck102 = 1.8 time = 2060
.meas tran vdout2_15ck102 FIND v(dout2_15) AT=2060.1n

* CHECK dout2_16 Vdout2_16ck102 = 0 time = 2060
.meas tran vdout2_16ck102 FIND v(dout2_16) AT=2060.1n

* CHECK dout2_17 Vdout2_17ck102 = 0 time = 2060
.meas tran vdout2_17ck102 FIND v(dout2_17) AT=2060.1n

* CHECK dout2_18 Vdout2_18ck102 = 1.8 time = 2060
.meas tran vdout2_18ck102 FIND v(dout2_18) AT=2060.1n

* CHECK dout2_19 Vdout2_19ck102 = 0 time = 2060
.meas tran vdout2_19ck102 FIND v(dout2_19) AT=2060.1n

* CHECK dout2_20 Vdout2_20ck102 = 1.8 time = 2060
.meas tran vdout2_20ck102 FIND v(dout2_20) AT=2060.1n

* CHECK dout2_21 Vdout2_21ck102 = 0 time = 2060
.meas tran vdout2_21ck102 FIND v(dout2_21) AT=2060.1n

* CHECK dout2_22 Vdout2_22ck102 = 0 time = 2060
.meas tran vdout2_22ck102 FIND v(dout2_22) AT=2060.1n

* CHECK dout2_23 Vdout2_23ck102 = 1.8 time = 2060
.meas tran vdout2_23ck102 FIND v(dout2_23) AT=2060.1n

* CHECK dout2_24 Vdout2_24ck102 = 0 time = 2060
.meas tran vdout2_24ck102 FIND v(dout2_24) AT=2060.1n

* CHECK dout2_25 Vdout2_25ck102 = 1.8 time = 2060
.meas tran vdout2_25ck102 FIND v(dout2_25) AT=2060.1n

* CHECK dout2_26 Vdout2_26ck102 = 1.8 time = 2060
.meas tran vdout2_26ck102 FIND v(dout2_26) AT=2060.1n

* CHECK dout2_27 Vdout2_27ck102 = 0 time = 2060
.meas tran vdout2_27ck102 FIND v(dout2_27) AT=2060.1n

* CHECK dout2_28 Vdout2_28ck102 = 0 time = 2060
.meas tran vdout2_28ck102 FIND v(dout2_28) AT=2060.1n

* CHECK dout2_29 Vdout2_29ck102 = 0 time = 2060
.meas tran vdout2_29ck102 FIND v(dout2_29) AT=2060.1n

* CHECK dout2_30 Vdout2_30ck102 = 1.8 time = 2060
.meas tran vdout2_30ck102 FIND v(dout2_30) AT=2060.1n

* CHECK dout2_31 Vdout2_31ck102 = 1.8 time = 2060
.meas tran vdout2_31ck102 FIND v(dout2_31) AT=2060.1n

* CHECK dout1_0 Vdout1_0ck103 = 1.8 time = 2080
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=2080.1n

* CHECK dout1_1 Vdout1_1ck103 = 0 time = 2080
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=2080.1n

* CHECK dout1_2 Vdout1_2ck103 = 0 time = 2080
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=2080.1n

* CHECK dout1_3 Vdout1_3ck103 = 1.8 time = 2080
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=2080.1n

* CHECK dout1_4 Vdout1_4ck103 = 1.8 time = 2080
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=2080.1n

* CHECK dout1_5 Vdout1_5ck103 = 1.8 time = 2080
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=2080.1n

* CHECK dout1_6 Vdout1_6ck103 = 1.8 time = 2080
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=2080.1n

* CHECK dout1_7 Vdout1_7ck103 = 1.8 time = 2080
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=2080.1n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 2080
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=2080.1n

* CHECK dout1_9 Vdout1_9ck103 = 1.8 time = 2080
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=2080.1n

* CHECK dout1_10 Vdout1_10ck103 = 0 time = 2080
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=2080.1n

* CHECK dout1_11 Vdout1_11ck103 = 1.8 time = 2080
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=2080.1n

* CHECK dout1_12 Vdout1_12ck103 = 0 time = 2080
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=2080.1n

* CHECK dout1_13 Vdout1_13ck103 = 0 time = 2080
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=2080.1n

* CHECK dout1_14 Vdout1_14ck103 = 0 time = 2080
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=2080.1n

* CHECK dout1_15 Vdout1_15ck103 = 0 time = 2080
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=2080.1n

* CHECK dout1_16 Vdout1_16ck103 = 0 time = 2080
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=2080.1n

* CHECK dout1_17 Vdout1_17ck103 = 1.8 time = 2080
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=2080.1n

* CHECK dout1_18 Vdout1_18ck103 = 1.8 time = 2080
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=2080.1n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 2080
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=2080.1n

* CHECK dout1_20 Vdout1_20ck103 = 1.8 time = 2080
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=2080.1n

* CHECK dout1_21 Vdout1_21ck103 = 0 time = 2080
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=2080.1n

* CHECK dout1_22 Vdout1_22ck103 = 0 time = 2080
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=2080.1n

* CHECK dout1_23 Vdout1_23ck103 = 0 time = 2080
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=2080.1n

* CHECK dout1_24 Vdout1_24ck103 = 1.8 time = 2080
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=2080.1n

* CHECK dout1_25 Vdout1_25ck103 = 1.8 time = 2080
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=2080.1n

* CHECK dout1_26 Vdout1_26ck103 = 0 time = 2080
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=2080.1n

* CHECK dout1_27 Vdout1_27ck103 = 1.8 time = 2080
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=2080.1n

* CHECK dout1_28 Vdout1_28ck103 = 0 time = 2080
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=2080.1n

* CHECK dout1_29 Vdout1_29ck103 = 0 time = 2080
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=2080.1n

* CHECK dout1_30 Vdout1_30ck103 = 0 time = 2080
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=2080.1n

* CHECK dout1_31 Vdout1_31ck103 = 1.8 time = 2080
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=2080.1n

* CHECK dout2_0 Vdout2_0ck103 = 0 time = 2080
.meas tran vdout2_0ck103 FIND v(dout2_0) AT=2080.1n

* CHECK dout2_1 Vdout2_1ck103 = 1.8 time = 2080
.meas tran vdout2_1ck103 FIND v(dout2_1) AT=2080.1n

* CHECK dout2_2 Vdout2_2ck103 = 1.8 time = 2080
.meas tran vdout2_2ck103 FIND v(dout2_2) AT=2080.1n

* CHECK dout2_3 Vdout2_3ck103 = 1.8 time = 2080
.meas tran vdout2_3ck103 FIND v(dout2_3) AT=2080.1n

* CHECK dout2_4 Vdout2_4ck103 = 0 time = 2080
.meas tran vdout2_4ck103 FIND v(dout2_4) AT=2080.1n

* CHECK dout2_5 Vdout2_5ck103 = 1.8 time = 2080
.meas tran vdout2_5ck103 FIND v(dout2_5) AT=2080.1n

* CHECK dout2_6 Vdout2_6ck103 = 1.8 time = 2080
.meas tran vdout2_6ck103 FIND v(dout2_6) AT=2080.1n

* CHECK dout2_7 Vdout2_7ck103 = 0 time = 2080
.meas tran vdout2_7ck103 FIND v(dout2_7) AT=2080.1n

* CHECK dout2_8 Vdout2_8ck103 = 1.8 time = 2080
.meas tran vdout2_8ck103 FIND v(dout2_8) AT=2080.1n

* CHECK dout2_9 Vdout2_9ck103 = 0 time = 2080
.meas tran vdout2_9ck103 FIND v(dout2_9) AT=2080.1n

* CHECK dout2_10 Vdout2_10ck103 = 1.8 time = 2080
.meas tran vdout2_10ck103 FIND v(dout2_10) AT=2080.1n

* CHECK dout2_11 Vdout2_11ck103 = 0 time = 2080
.meas tran vdout2_11ck103 FIND v(dout2_11) AT=2080.1n

* CHECK dout2_12 Vdout2_12ck103 = 0 time = 2080
.meas tran vdout2_12ck103 FIND v(dout2_12) AT=2080.1n

* CHECK dout2_13 Vdout2_13ck103 = 0 time = 2080
.meas tran vdout2_13ck103 FIND v(dout2_13) AT=2080.1n

* CHECK dout2_14 Vdout2_14ck103 = 1.8 time = 2080
.meas tran vdout2_14ck103 FIND v(dout2_14) AT=2080.1n

* CHECK dout2_15 Vdout2_15ck103 = 0 time = 2080
.meas tran vdout2_15ck103 FIND v(dout2_15) AT=2080.1n

* CHECK dout2_16 Vdout2_16ck103 = 1.8 time = 2080
.meas tran vdout2_16ck103 FIND v(dout2_16) AT=2080.1n

* CHECK dout2_17 Vdout2_17ck103 = 0 time = 2080
.meas tran vdout2_17ck103 FIND v(dout2_17) AT=2080.1n

* CHECK dout2_18 Vdout2_18ck103 = 0 time = 2080
.meas tran vdout2_18ck103 FIND v(dout2_18) AT=2080.1n

* CHECK dout2_19 Vdout2_19ck103 = 0 time = 2080
.meas tran vdout2_19ck103 FIND v(dout2_19) AT=2080.1n

* CHECK dout2_20 Vdout2_20ck103 = 1.8 time = 2080
.meas tran vdout2_20ck103 FIND v(dout2_20) AT=2080.1n

* CHECK dout2_21 Vdout2_21ck103 = 1.8 time = 2080
.meas tran vdout2_21ck103 FIND v(dout2_21) AT=2080.1n

* CHECK dout2_22 Vdout2_22ck103 = 1.8 time = 2080
.meas tran vdout2_22ck103 FIND v(dout2_22) AT=2080.1n

* CHECK dout2_23 Vdout2_23ck103 = 1.8 time = 2080
.meas tran vdout2_23ck103 FIND v(dout2_23) AT=2080.1n

* CHECK dout2_24 Vdout2_24ck103 = 0 time = 2080
.meas tran vdout2_24ck103 FIND v(dout2_24) AT=2080.1n

* CHECK dout2_25 Vdout2_25ck103 = 0 time = 2080
.meas tran vdout2_25ck103 FIND v(dout2_25) AT=2080.1n

* CHECK dout2_26 Vdout2_26ck103 = 1.8 time = 2080
.meas tran vdout2_26ck103 FIND v(dout2_26) AT=2080.1n

* CHECK dout2_27 Vdout2_27ck103 = 0 time = 2080
.meas tran vdout2_27ck103 FIND v(dout2_27) AT=2080.1n

* CHECK dout2_28 Vdout2_28ck103 = 1.8 time = 2080
.meas tran vdout2_28ck103 FIND v(dout2_28) AT=2080.1n

* CHECK dout2_29 Vdout2_29ck103 = 0 time = 2080
.meas tran vdout2_29ck103 FIND v(dout2_29) AT=2080.1n

* CHECK dout2_30 Vdout2_30ck103 = 0 time = 2080
.meas tran vdout2_30ck103 FIND v(dout2_30) AT=2080.1n

* CHECK dout2_31 Vdout2_31ck103 = 1.8 time = 2080
.meas tran vdout2_31ck103 FIND v(dout2_31) AT=2080.1n

* CHECK dout1_0 Vdout1_0ck104 = 1.8 time = 2100
.meas tran vdout1_0ck104 FIND v(dout1_0) AT=2100.1n

* CHECK dout1_1 Vdout1_1ck104 = 0 time = 2100
.meas tran vdout1_1ck104 FIND v(dout1_1) AT=2100.1n

* CHECK dout1_2 Vdout1_2ck104 = 0 time = 2100
.meas tran vdout1_2ck104 FIND v(dout1_2) AT=2100.1n

* CHECK dout1_3 Vdout1_3ck104 = 0 time = 2100
.meas tran vdout1_3ck104 FIND v(dout1_3) AT=2100.1n

* CHECK dout1_4 Vdout1_4ck104 = 1.8 time = 2100
.meas tran vdout1_4ck104 FIND v(dout1_4) AT=2100.1n

* CHECK dout1_5 Vdout1_5ck104 = 1.8 time = 2100
.meas tran vdout1_5ck104 FIND v(dout1_5) AT=2100.1n

* CHECK dout1_6 Vdout1_6ck104 = 1.8 time = 2100
.meas tran vdout1_6ck104 FIND v(dout1_6) AT=2100.1n

* CHECK dout1_7 Vdout1_7ck104 = 0 time = 2100
.meas tran vdout1_7ck104 FIND v(dout1_7) AT=2100.1n

* CHECK dout1_8 Vdout1_8ck104 = 1.8 time = 2100
.meas tran vdout1_8ck104 FIND v(dout1_8) AT=2100.1n

* CHECK dout1_9 Vdout1_9ck104 = 1.8 time = 2100
.meas tran vdout1_9ck104 FIND v(dout1_9) AT=2100.1n

* CHECK dout1_10 Vdout1_10ck104 = 1.8 time = 2100
.meas tran vdout1_10ck104 FIND v(dout1_10) AT=2100.1n

* CHECK dout1_11 Vdout1_11ck104 = 0 time = 2100
.meas tran vdout1_11ck104 FIND v(dout1_11) AT=2100.1n

* CHECK dout1_12 Vdout1_12ck104 = 0 time = 2100
.meas tran vdout1_12ck104 FIND v(dout1_12) AT=2100.1n

* CHECK dout1_13 Vdout1_13ck104 = 1.8 time = 2100
.meas tran vdout1_13ck104 FIND v(dout1_13) AT=2100.1n

* CHECK dout1_14 Vdout1_14ck104 = 1.8 time = 2100
.meas tran vdout1_14ck104 FIND v(dout1_14) AT=2100.1n

* CHECK dout1_15 Vdout1_15ck104 = 1.8 time = 2100
.meas tran vdout1_15ck104 FIND v(dout1_15) AT=2100.1n

* CHECK dout1_16 Vdout1_16ck104 = 0 time = 2100
.meas tran vdout1_16ck104 FIND v(dout1_16) AT=2100.1n

* CHECK dout1_17 Vdout1_17ck104 = 0 time = 2100
.meas tran vdout1_17ck104 FIND v(dout1_17) AT=2100.1n

* CHECK dout1_18 Vdout1_18ck104 = 1.8 time = 2100
.meas tran vdout1_18ck104 FIND v(dout1_18) AT=2100.1n

* CHECK dout1_19 Vdout1_19ck104 = 1.8 time = 2100
.meas tran vdout1_19ck104 FIND v(dout1_19) AT=2100.1n

* CHECK dout1_20 Vdout1_20ck104 = 0 time = 2100
.meas tran vdout1_20ck104 FIND v(dout1_20) AT=2100.1n

* CHECK dout1_21 Vdout1_21ck104 = 1.8 time = 2100
.meas tran vdout1_21ck104 FIND v(dout1_21) AT=2100.1n

* CHECK dout1_22 Vdout1_22ck104 = 1.8 time = 2100
.meas tran vdout1_22ck104 FIND v(dout1_22) AT=2100.1n

* CHECK dout1_23 Vdout1_23ck104 = 0 time = 2100
.meas tran vdout1_23ck104 FIND v(dout1_23) AT=2100.1n

* CHECK dout1_24 Vdout1_24ck104 = 1.8 time = 2100
.meas tran vdout1_24ck104 FIND v(dout1_24) AT=2100.1n

* CHECK dout1_25 Vdout1_25ck104 = 1.8 time = 2100
.meas tran vdout1_25ck104 FIND v(dout1_25) AT=2100.1n

* CHECK dout1_26 Vdout1_26ck104 = 0 time = 2100
.meas tran vdout1_26ck104 FIND v(dout1_26) AT=2100.1n

* CHECK dout1_27 Vdout1_27ck104 = 0 time = 2100
.meas tran vdout1_27ck104 FIND v(dout1_27) AT=2100.1n

* CHECK dout1_28 Vdout1_28ck104 = 0 time = 2100
.meas tran vdout1_28ck104 FIND v(dout1_28) AT=2100.1n

* CHECK dout1_29 Vdout1_29ck104 = 1.8 time = 2100
.meas tran vdout1_29ck104 FIND v(dout1_29) AT=2100.1n

* CHECK dout1_30 Vdout1_30ck104 = 0 time = 2100
.meas tran vdout1_30ck104 FIND v(dout1_30) AT=2100.1n

* CHECK dout1_31 Vdout1_31ck104 = 0 time = 2100
.meas tran vdout1_31ck104 FIND v(dout1_31) AT=2100.1n

* CHECK dout1_0 Vdout1_0ck105 = 1.8 time = 2120
.meas tran vdout1_0ck105 FIND v(dout1_0) AT=2120.1n

* CHECK dout1_1 Vdout1_1ck105 = 0 time = 2120
.meas tran vdout1_1ck105 FIND v(dout1_1) AT=2120.1n

* CHECK dout1_2 Vdout1_2ck105 = 0 time = 2120
.meas tran vdout1_2ck105 FIND v(dout1_2) AT=2120.1n

* CHECK dout1_3 Vdout1_3ck105 = 0 time = 2120
.meas tran vdout1_3ck105 FIND v(dout1_3) AT=2120.1n

* CHECK dout1_4 Vdout1_4ck105 = 1.8 time = 2120
.meas tran vdout1_4ck105 FIND v(dout1_4) AT=2120.1n

* CHECK dout1_5 Vdout1_5ck105 = 1.8 time = 2120
.meas tran vdout1_5ck105 FIND v(dout1_5) AT=2120.1n

* CHECK dout1_6 Vdout1_6ck105 = 1.8 time = 2120
.meas tran vdout1_6ck105 FIND v(dout1_6) AT=2120.1n

* CHECK dout1_7 Vdout1_7ck105 = 0 time = 2120
.meas tran vdout1_7ck105 FIND v(dout1_7) AT=2120.1n

* CHECK dout1_8 Vdout1_8ck105 = 1.8 time = 2120
.meas tran vdout1_8ck105 FIND v(dout1_8) AT=2120.1n

* CHECK dout1_9 Vdout1_9ck105 = 1.8 time = 2120
.meas tran vdout1_9ck105 FIND v(dout1_9) AT=2120.1n

* CHECK dout1_10 Vdout1_10ck105 = 1.8 time = 2120
.meas tran vdout1_10ck105 FIND v(dout1_10) AT=2120.1n

* CHECK dout1_11 Vdout1_11ck105 = 0 time = 2120
.meas tran vdout1_11ck105 FIND v(dout1_11) AT=2120.1n

* CHECK dout1_12 Vdout1_12ck105 = 0 time = 2120
.meas tran vdout1_12ck105 FIND v(dout1_12) AT=2120.1n

* CHECK dout1_13 Vdout1_13ck105 = 1.8 time = 2120
.meas tran vdout1_13ck105 FIND v(dout1_13) AT=2120.1n

* CHECK dout1_14 Vdout1_14ck105 = 1.8 time = 2120
.meas tran vdout1_14ck105 FIND v(dout1_14) AT=2120.1n

* CHECK dout1_15 Vdout1_15ck105 = 1.8 time = 2120
.meas tran vdout1_15ck105 FIND v(dout1_15) AT=2120.1n

* CHECK dout1_16 Vdout1_16ck105 = 0 time = 2120
.meas tran vdout1_16ck105 FIND v(dout1_16) AT=2120.1n

* CHECK dout1_17 Vdout1_17ck105 = 0 time = 2120
.meas tran vdout1_17ck105 FIND v(dout1_17) AT=2120.1n

* CHECK dout1_18 Vdout1_18ck105 = 1.8 time = 2120
.meas tran vdout1_18ck105 FIND v(dout1_18) AT=2120.1n

* CHECK dout1_19 Vdout1_19ck105 = 1.8 time = 2120
.meas tran vdout1_19ck105 FIND v(dout1_19) AT=2120.1n

* CHECK dout1_20 Vdout1_20ck105 = 0 time = 2120
.meas tran vdout1_20ck105 FIND v(dout1_20) AT=2120.1n

* CHECK dout1_21 Vdout1_21ck105 = 1.8 time = 2120
.meas tran vdout1_21ck105 FIND v(dout1_21) AT=2120.1n

* CHECK dout1_22 Vdout1_22ck105 = 1.8 time = 2120
.meas tran vdout1_22ck105 FIND v(dout1_22) AT=2120.1n

* CHECK dout1_23 Vdout1_23ck105 = 0 time = 2120
.meas tran vdout1_23ck105 FIND v(dout1_23) AT=2120.1n

* CHECK dout1_24 Vdout1_24ck105 = 1.8 time = 2120
.meas tran vdout1_24ck105 FIND v(dout1_24) AT=2120.1n

* CHECK dout1_25 Vdout1_25ck105 = 1.8 time = 2120
.meas tran vdout1_25ck105 FIND v(dout1_25) AT=2120.1n

* CHECK dout1_26 Vdout1_26ck105 = 0 time = 2120
.meas tran vdout1_26ck105 FIND v(dout1_26) AT=2120.1n

* CHECK dout1_27 Vdout1_27ck105 = 0 time = 2120
.meas tran vdout1_27ck105 FIND v(dout1_27) AT=2120.1n

* CHECK dout1_28 Vdout1_28ck105 = 0 time = 2120
.meas tran vdout1_28ck105 FIND v(dout1_28) AT=2120.1n

* CHECK dout1_29 Vdout1_29ck105 = 1.8 time = 2120
.meas tran vdout1_29ck105 FIND v(dout1_29) AT=2120.1n

* CHECK dout1_30 Vdout1_30ck105 = 0 time = 2120
.meas tran vdout1_30ck105 FIND v(dout1_30) AT=2120.1n

* CHECK dout1_31 Vdout1_31ck105 = 0 time = 2120
.meas tran vdout1_31ck105 FIND v(dout1_31) AT=2120.1n

* CHECK dout2_0 Vdout2_0ck105 = 1.8 time = 2120
.meas tran vdout2_0ck105 FIND v(dout2_0) AT=2120.1n

* CHECK dout2_1 Vdout2_1ck105 = 0 time = 2120
.meas tran vdout2_1ck105 FIND v(dout2_1) AT=2120.1n

* CHECK dout2_2 Vdout2_2ck105 = 0 time = 2120
.meas tran vdout2_2ck105 FIND v(dout2_2) AT=2120.1n

* CHECK dout2_3 Vdout2_3ck105 = 0 time = 2120
.meas tran vdout2_3ck105 FIND v(dout2_3) AT=2120.1n

* CHECK dout2_4 Vdout2_4ck105 = 1.8 time = 2120
.meas tran vdout2_4ck105 FIND v(dout2_4) AT=2120.1n

* CHECK dout2_5 Vdout2_5ck105 = 1.8 time = 2120
.meas tran vdout2_5ck105 FIND v(dout2_5) AT=2120.1n

* CHECK dout2_6 Vdout2_6ck105 = 1.8 time = 2120
.meas tran vdout2_6ck105 FIND v(dout2_6) AT=2120.1n

* CHECK dout2_7 Vdout2_7ck105 = 0 time = 2120
.meas tran vdout2_7ck105 FIND v(dout2_7) AT=2120.1n

* CHECK dout2_8 Vdout2_8ck105 = 1.8 time = 2120
.meas tran vdout2_8ck105 FIND v(dout2_8) AT=2120.1n

* CHECK dout2_9 Vdout2_9ck105 = 1.8 time = 2120
.meas tran vdout2_9ck105 FIND v(dout2_9) AT=2120.1n

* CHECK dout2_10 Vdout2_10ck105 = 1.8 time = 2120
.meas tran vdout2_10ck105 FIND v(dout2_10) AT=2120.1n

* CHECK dout2_11 Vdout2_11ck105 = 0 time = 2120
.meas tran vdout2_11ck105 FIND v(dout2_11) AT=2120.1n

* CHECK dout2_12 Vdout2_12ck105 = 0 time = 2120
.meas tran vdout2_12ck105 FIND v(dout2_12) AT=2120.1n

* CHECK dout2_13 Vdout2_13ck105 = 1.8 time = 2120
.meas tran vdout2_13ck105 FIND v(dout2_13) AT=2120.1n

* CHECK dout2_14 Vdout2_14ck105 = 1.8 time = 2120
.meas tran vdout2_14ck105 FIND v(dout2_14) AT=2120.1n

* CHECK dout2_15 Vdout2_15ck105 = 1.8 time = 2120
.meas tran vdout2_15ck105 FIND v(dout2_15) AT=2120.1n

* CHECK dout2_16 Vdout2_16ck105 = 0 time = 2120
.meas tran vdout2_16ck105 FIND v(dout2_16) AT=2120.1n

* CHECK dout2_17 Vdout2_17ck105 = 0 time = 2120
.meas tran vdout2_17ck105 FIND v(dout2_17) AT=2120.1n

* CHECK dout2_18 Vdout2_18ck105 = 1.8 time = 2120
.meas tran vdout2_18ck105 FIND v(dout2_18) AT=2120.1n

* CHECK dout2_19 Vdout2_19ck105 = 1.8 time = 2120
.meas tran vdout2_19ck105 FIND v(dout2_19) AT=2120.1n

* CHECK dout2_20 Vdout2_20ck105 = 0 time = 2120
.meas tran vdout2_20ck105 FIND v(dout2_20) AT=2120.1n

* CHECK dout2_21 Vdout2_21ck105 = 1.8 time = 2120
.meas tran vdout2_21ck105 FIND v(dout2_21) AT=2120.1n

* CHECK dout2_22 Vdout2_22ck105 = 1.8 time = 2120
.meas tran vdout2_22ck105 FIND v(dout2_22) AT=2120.1n

* CHECK dout2_23 Vdout2_23ck105 = 0 time = 2120
.meas tran vdout2_23ck105 FIND v(dout2_23) AT=2120.1n

* CHECK dout2_24 Vdout2_24ck105 = 1.8 time = 2120
.meas tran vdout2_24ck105 FIND v(dout2_24) AT=2120.1n

* CHECK dout2_25 Vdout2_25ck105 = 1.8 time = 2120
.meas tran vdout2_25ck105 FIND v(dout2_25) AT=2120.1n

* CHECK dout2_26 Vdout2_26ck105 = 0 time = 2120
.meas tran vdout2_26ck105 FIND v(dout2_26) AT=2120.1n

* CHECK dout2_27 Vdout2_27ck105 = 0 time = 2120
.meas tran vdout2_27ck105 FIND v(dout2_27) AT=2120.1n

* CHECK dout2_28 Vdout2_28ck105 = 0 time = 2120
.meas tran vdout2_28ck105 FIND v(dout2_28) AT=2120.1n

* CHECK dout2_29 Vdout2_29ck105 = 1.8 time = 2120
.meas tran vdout2_29ck105 FIND v(dout2_29) AT=2120.1n

* CHECK dout2_30 Vdout2_30ck105 = 0 time = 2120
.meas tran vdout2_30ck105 FIND v(dout2_30) AT=2120.1n

* CHECK dout2_31 Vdout2_31ck105 = 0 time = 2120
.meas tran vdout2_31ck105 FIND v(dout2_31) AT=2120.1n

* CHECK dout1_0 Vdout1_0ck106 = 1.8 time = 2140
.meas tran vdout1_0ck106 FIND v(dout1_0) AT=2140.1n

* CHECK dout1_1 Vdout1_1ck106 = 0 time = 2140
.meas tran vdout1_1ck106 FIND v(dout1_1) AT=2140.1n

* CHECK dout1_2 Vdout1_2ck106 = 1.8 time = 2140
.meas tran vdout1_2ck106 FIND v(dout1_2) AT=2140.1n

* CHECK dout1_3 Vdout1_3ck106 = 0 time = 2140
.meas tran vdout1_3ck106 FIND v(dout1_3) AT=2140.1n

* CHECK dout1_4 Vdout1_4ck106 = 1.8 time = 2140
.meas tran vdout1_4ck106 FIND v(dout1_4) AT=2140.1n

* CHECK dout1_5 Vdout1_5ck106 = 0 time = 2140
.meas tran vdout1_5ck106 FIND v(dout1_5) AT=2140.1n

* CHECK dout1_6 Vdout1_6ck106 = 0 time = 2140
.meas tran vdout1_6ck106 FIND v(dout1_6) AT=2140.1n

* CHECK dout1_7 Vdout1_7ck106 = 1.8 time = 2140
.meas tran vdout1_7ck106 FIND v(dout1_7) AT=2140.1n

* CHECK dout1_8 Vdout1_8ck106 = 0 time = 2140
.meas tran vdout1_8ck106 FIND v(dout1_8) AT=2140.1n

* CHECK dout1_9 Vdout1_9ck106 = 0 time = 2140
.meas tran vdout1_9ck106 FIND v(dout1_9) AT=2140.1n

* CHECK dout1_10 Vdout1_10ck106 = 1.8 time = 2140
.meas tran vdout1_10ck106 FIND v(dout1_10) AT=2140.1n

* CHECK dout1_11 Vdout1_11ck106 = 0 time = 2140
.meas tran vdout1_11ck106 FIND v(dout1_11) AT=2140.1n

* CHECK dout1_12 Vdout1_12ck106 = 0 time = 2140
.meas tran vdout1_12ck106 FIND v(dout1_12) AT=2140.1n

* CHECK dout1_13 Vdout1_13ck106 = 0 time = 2140
.meas tran vdout1_13ck106 FIND v(dout1_13) AT=2140.1n

* CHECK dout1_14 Vdout1_14ck106 = 1.8 time = 2140
.meas tran vdout1_14ck106 FIND v(dout1_14) AT=2140.1n

* CHECK dout1_15 Vdout1_15ck106 = 0 time = 2140
.meas tran vdout1_15ck106 FIND v(dout1_15) AT=2140.1n

* CHECK dout1_16 Vdout1_16ck106 = 0 time = 2140
.meas tran vdout1_16ck106 FIND v(dout1_16) AT=2140.1n

* CHECK dout1_17 Vdout1_17ck106 = 0 time = 2140
.meas tran vdout1_17ck106 FIND v(dout1_17) AT=2140.1n

* CHECK dout1_18 Vdout1_18ck106 = 0 time = 2140
.meas tran vdout1_18ck106 FIND v(dout1_18) AT=2140.1n

* CHECK dout1_19 Vdout1_19ck106 = 1.8 time = 2140
.meas tran vdout1_19ck106 FIND v(dout1_19) AT=2140.1n

* CHECK dout1_20 Vdout1_20ck106 = 1.8 time = 2140
.meas tran vdout1_20ck106 FIND v(dout1_20) AT=2140.1n

* CHECK dout1_21 Vdout1_21ck106 = 1.8 time = 2140
.meas tran vdout1_21ck106 FIND v(dout1_21) AT=2140.1n

* CHECK dout1_22 Vdout1_22ck106 = 0 time = 2140
.meas tran vdout1_22ck106 FIND v(dout1_22) AT=2140.1n

* CHECK dout1_23 Vdout1_23ck106 = 0 time = 2140
.meas tran vdout1_23ck106 FIND v(dout1_23) AT=2140.1n

* CHECK dout1_24 Vdout1_24ck106 = 1.8 time = 2140
.meas tran vdout1_24ck106 FIND v(dout1_24) AT=2140.1n

* CHECK dout1_25 Vdout1_25ck106 = 1.8 time = 2140
.meas tran vdout1_25ck106 FIND v(dout1_25) AT=2140.1n

* CHECK dout1_26 Vdout1_26ck106 = 0 time = 2140
.meas tran vdout1_26ck106 FIND v(dout1_26) AT=2140.1n

* CHECK dout1_27 Vdout1_27ck106 = 1.8 time = 2140
.meas tran vdout1_27ck106 FIND v(dout1_27) AT=2140.1n

* CHECK dout1_28 Vdout1_28ck106 = 0 time = 2140
.meas tran vdout1_28ck106 FIND v(dout1_28) AT=2140.1n

* CHECK dout1_29 Vdout1_29ck106 = 1.8 time = 2140
.meas tran vdout1_29ck106 FIND v(dout1_29) AT=2140.1n

* CHECK dout1_30 Vdout1_30ck106 = 0 time = 2140
.meas tran vdout1_30ck106 FIND v(dout1_30) AT=2140.1n

* CHECK dout1_31 Vdout1_31ck106 = 0 time = 2140
.meas tran vdout1_31ck106 FIND v(dout1_31) AT=2140.1n

* CHECK dout2_0 Vdout2_0ck106 = 1.8 time = 2140
.meas tran vdout2_0ck106 FIND v(dout2_0) AT=2140.1n

* CHECK dout2_1 Vdout2_1ck106 = 0 time = 2140
.meas tran vdout2_1ck106 FIND v(dout2_1) AT=2140.1n

* CHECK dout2_2 Vdout2_2ck106 = 0 time = 2140
.meas tran vdout2_2ck106 FIND v(dout2_2) AT=2140.1n

* CHECK dout2_3 Vdout2_3ck106 = 0 time = 2140
.meas tran vdout2_3ck106 FIND v(dout2_3) AT=2140.1n

* CHECK dout2_4 Vdout2_4ck106 = 1.8 time = 2140
.meas tran vdout2_4ck106 FIND v(dout2_4) AT=2140.1n

* CHECK dout2_5 Vdout2_5ck106 = 1.8 time = 2140
.meas tran vdout2_5ck106 FIND v(dout2_5) AT=2140.1n

* CHECK dout2_6 Vdout2_6ck106 = 1.8 time = 2140
.meas tran vdout2_6ck106 FIND v(dout2_6) AT=2140.1n

* CHECK dout2_7 Vdout2_7ck106 = 0 time = 2140
.meas tran vdout2_7ck106 FIND v(dout2_7) AT=2140.1n

* CHECK dout2_8 Vdout2_8ck106 = 1.8 time = 2140
.meas tran vdout2_8ck106 FIND v(dout2_8) AT=2140.1n

* CHECK dout2_9 Vdout2_9ck106 = 1.8 time = 2140
.meas tran vdout2_9ck106 FIND v(dout2_9) AT=2140.1n

* CHECK dout2_10 Vdout2_10ck106 = 1.8 time = 2140
.meas tran vdout2_10ck106 FIND v(dout2_10) AT=2140.1n

* CHECK dout2_11 Vdout2_11ck106 = 0 time = 2140
.meas tran vdout2_11ck106 FIND v(dout2_11) AT=2140.1n

* CHECK dout2_12 Vdout2_12ck106 = 0 time = 2140
.meas tran vdout2_12ck106 FIND v(dout2_12) AT=2140.1n

* CHECK dout2_13 Vdout2_13ck106 = 1.8 time = 2140
.meas tran vdout2_13ck106 FIND v(dout2_13) AT=2140.1n

* CHECK dout2_14 Vdout2_14ck106 = 1.8 time = 2140
.meas tran vdout2_14ck106 FIND v(dout2_14) AT=2140.1n

* CHECK dout2_15 Vdout2_15ck106 = 1.8 time = 2140
.meas tran vdout2_15ck106 FIND v(dout2_15) AT=2140.1n

* CHECK dout2_16 Vdout2_16ck106 = 0 time = 2140
.meas tran vdout2_16ck106 FIND v(dout2_16) AT=2140.1n

* CHECK dout2_17 Vdout2_17ck106 = 0 time = 2140
.meas tran vdout2_17ck106 FIND v(dout2_17) AT=2140.1n

* CHECK dout2_18 Vdout2_18ck106 = 1.8 time = 2140
.meas tran vdout2_18ck106 FIND v(dout2_18) AT=2140.1n

* CHECK dout2_19 Vdout2_19ck106 = 1.8 time = 2140
.meas tran vdout2_19ck106 FIND v(dout2_19) AT=2140.1n

* CHECK dout2_20 Vdout2_20ck106 = 0 time = 2140
.meas tran vdout2_20ck106 FIND v(dout2_20) AT=2140.1n

* CHECK dout2_21 Vdout2_21ck106 = 1.8 time = 2140
.meas tran vdout2_21ck106 FIND v(dout2_21) AT=2140.1n

* CHECK dout2_22 Vdout2_22ck106 = 1.8 time = 2140
.meas tran vdout2_22ck106 FIND v(dout2_22) AT=2140.1n

* CHECK dout2_23 Vdout2_23ck106 = 0 time = 2140
.meas tran vdout2_23ck106 FIND v(dout2_23) AT=2140.1n

* CHECK dout2_24 Vdout2_24ck106 = 1.8 time = 2140
.meas tran vdout2_24ck106 FIND v(dout2_24) AT=2140.1n

* CHECK dout2_25 Vdout2_25ck106 = 1.8 time = 2140
.meas tran vdout2_25ck106 FIND v(dout2_25) AT=2140.1n

* CHECK dout2_26 Vdout2_26ck106 = 0 time = 2140
.meas tran vdout2_26ck106 FIND v(dout2_26) AT=2140.1n

* CHECK dout2_27 Vdout2_27ck106 = 0 time = 2140
.meas tran vdout2_27ck106 FIND v(dout2_27) AT=2140.1n

* CHECK dout2_28 Vdout2_28ck106 = 0 time = 2140
.meas tran vdout2_28ck106 FIND v(dout2_28) AT=2140.1n

* CHECK dout2_29 Vdout2_29ck106 = 1.8 time = 2140
.meas tran vdout2_29ck106 FIND v(dout2_29) AT=2140.1n

* CHECK dout2_30 Vdout2_30ck106 = 0 time = 2140
.meas tran vdout2_30ck106 FIND v(dout2_30) AT=2140.1n

* CHECK dout2_31 Vdout2_31ck106 = 0 time = 2140
.meas tran vdout2_31ck106 FIND v(dout2_31) AT=2140.1n

* CHECK dout1_0 Vdout1_0ck107 = 1.8 time = 2160
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=2160.1n

* CHECK dout1_1 Vdout1_1ck107 = 0 time = 2160
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=2160.1n

* CHECK dout1_2 Vdout1_2ck107 = 1.8 time = 2160
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=2160.1n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 2160
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=2160.1n

* CHECK dout1_4 Vdout1_4ck107 = 1.8 time = 2160
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=2160.1n

* CHECK dout1_5 Vdout1_5ck107 = 0 time = 2160
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=2160.1n

* CHECK dout1_6 Vdout1_6ck107 = 0 time = 2160
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=2160.1n

* CHECK dout1_7 Vdout1_7ck107 = 1.8 time = 2160
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=2160.1n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 2160
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=2160.1n

* CHECK dout1_9 Vdout1_9ck107 = 0 time = 2160
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=2160.1n

* CHECK dout1_10 Vdout1_10ck107 = 1.8 time = 2160
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=2160.1n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 2160
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=2160.1n

* CHECK dout1_12 Vdout1_12ck107 = 0 time = 2160
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=2160.1n

* CHECK dout1_13 Vdout1_13ck107 = 0 time = 2160
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=2160.1n

* CHECK dout1_14 Vdout1_14ck107 = 1.8 time = 2160
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=2160.1n

* CHECK dout1_15 Vdout1_15ck107 = 0 time = 2160
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=2160.1n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 2160
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=2160.1n

* CHECK dout1_17 Vdout1_17ck107 = 0 time = 2160
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=2160.1n

* CHECK dout1_18 Vdout1_18ck107 = 0 time = 2160
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=2160.1n

* CHECK dout1_19 Vdout1_19ck107 = 1.8 time = 2160
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=2160.1n

* CHECK dout1_20 Vdout1_20ck107 = 1.8 time = 2160
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=2160.1n

* CHECK dout1_21 Vdout1_21ck107 = 1.8 time = 2160
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=2160.1n

* CHECK dout1_22 Vdout1_22ck107 = 0 time = 2160
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=2160.1n

* CHECK dout1_23 Vdout1_23ck107 = 0 time = 2160
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=2160.1n

* CHECK dout1_24 Vdout1_24ck107 = 1.8 time = 2160
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=2160.1n

* CHECK dout1_25 Vdout1_25ck107 = 1.8 time = 2160
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=2160.1n

* CHECK dout1_26 Vdout1_26ck107 = 0 time = 2160
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=2160.1n

* CHECK dout1_27 Vdout1_27ck107 = 1.8 time = 2160
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=2160.1n

* CHECK dout1_28 Vdout1_28ck107 = 0 time = 2160
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=2160.1n

* CHECK dout1_29 Vdout1_29ck107 = 1.8 time = 2160
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=2160.1n

* CHECK dout1_30 Vdout1_30ck107 = 0 time = 2160
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=2160.1n

* CHECK dout1_31 Vdout1_31ck107 = 0 time = 2160
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=2160.1n

* CHECK dout2_0 Vdout2_0ck107 = 1.8 time = 2160
.meas tran vdout2_0ck107 FIND v(dout2_0) AT=2160.1n

* CHECK dout2_1 Vdout2_1ck107 = 0 time = 2160
.meas tran vdout2_1ck107 FIND v(dout2_1) AT=2160.1n

* CHECK dout2_2 Vdout2_2ck107 = 1.8 time = 2160
.meas tran vdout2_2ck107 FIND v(dout2_2) AT=2160.1n

* CHECK dout2_3 Vdout2_3ck107 = 0 time = 2160
.meas tran vdout2_3ck107 FIND v(dout2_3) AT=2160.1n

* CHECK dout2_4 Vdout2_4ck107 = 1.8 time = 2160
.meas tran vdout2_4ck107 FIND v(dout2_4) AT=2160.1n

* CHECK dout2_5 Vdout2_5ck107 = 0 time = 2160
.meas tran vdout2_5ck107 FIND v(dout2_5) AT=2160.1n

* CHECK dout2_6 Vdout2_6ck107 = 0 time = 2160
.meas tran vdout2_6ck107 FIND v(dout2_6) AT=2160.1n

* CHECK dout2_7 Vdout2_7ck107 = 1.8 time = 2160
.meas tran vdout2_7ck107 FIND v(dout2_7) AT=2160.1n

* CHECK dout2_8 Vdout2_8ck107 = 0 time = 2160
.meas tran vdout2_8ck107 FIND v(dout2_8) AT=2160.1n

* CHECK dout2_9 Vdout2_9ck107 = 0 time = 2160
.meas tran vdout2_9ck107 FIND v(dout2_9) AT=2160.1n

* CHECK dout2_10 Vdout2_10ck107 = 1.8 time = 2160
.meas tran vdout2_10ck107 FIND v(dout2_10) AT=2160.1n

* CHECK dout2_11 Vdout2_11ck107 = 0 time = 2160
.meas tran vdout2_11ck107 FIND v(dout2_11) AT=2160.1n

* CHECK dout2_12 Vdout2_12ck107 = 0 time = 2160
.meas tran vdout2_12ck107 FIND v(dout2_12) AT=2160.1n

* CHECK dout2_13 Vdout2_13ck107 = 0 time = 2160
.meas tran vdout2_13ck107 FIND v(dout2_13) AT=2160.1n

* CHECK dout2_14 Vdout2_14ck107 = 1.8 time = 2160
.meas tran vdout2_14ck107 FIND v(dout2_14) AT=2160.1n

* CHECK dout2_15 Vdout2_15ck107 = 0 time = 2160
.meas tran vdout2_15ck107 FIND v(dout2_15) AT=2160.1n

* CHECK dout2_16 Vdout2_16ck107 = 0 time = 2160
.meas tran vdout2_16ck107 FIND v(dout2_16) AT=2160.1n

* CHECK dout2_17 Vdout2_17ck107 = 0 time = 2160
.meas tran vdout2_17ck107 FIND v(dout2_17) AT=2160.1n

* CHECK dout2_18 Vdout2_18ck107 = 0 time = 2160
.meas tran vdout2_18ck107 FIND v(dout2_18) AT=2160.1n

* CHECK dout2_19 Vdout2_19ck107 = 1.8 time = 2160
.meas tran vdout2_19ck107 FIND v(dout2_19) AT=2160.1n

* CHECK dout2_20 Vdout2_20ck107 = 1.8 time = 2160
.meas tran vdout2_20ck107 FIND v(dout2_20) AT=2160.1n

* CHECK dout2_21 Vdout2_21ck107 = 1.8 time = 2160
.meas tran vdout2_21ck107 FIND v(dout2_21) AT=2160.1n

* CHECK dout2_22 Vdout2_22ck107 = 0 time = 2160
.meas tran vdout2_22ck107 FIND v(dout2_22) AT=2160.1n

* CHECK dout2_23 Vdout2_23ck107 = 0 time = 2160
.meas tran vdout2_23ck107 FIND v(dout2_23) AT=2160.1n

* CHECK dout2_24 Vdout2_24ck107 = 1.8 time = 2160
.meas tran vdout2_24ck107 FIND v(dout2_24) AT=2160.1n

* CHECK dout2_25 Vdout2_25ck107 = 1.8 time = 2160
.meas tran vdout2_25ck107 FIND v(dout2_25) AT=2160.1n

* CHECK dout2_26 Vdout2_26ck107 = 0 time = 2160
.meas tran vdout2_26ck107 FIND v(dout2_26) AT=2160.1n

* CHECK dout2_27 Vdout2_27ck107 = 1.8 time = 2160
.meas tran vdout2_27ck107 FIND v(dout2_27) AT=2160.1n

* CHECK dout2_28 Vdout2_28ck107 = 0 time = 2160
.meas tran vdout2_28ck107 FIND v(dout2_28) AT=2160.1n

* CHECK dout2_29 Vdout2_29ck107 = 1.8 time = 2160
.meas tran vdout2_29ck107 FIND v(dout2_29) AT=2160.1n

* CHECK dout2_30 Vdout2_30ck107 = 0 time = 2160
.meas tran vdout2_30ck107 FIND v(dout2_30) AT=2160.1n

* CHECK dout2_31 Vdout2_31ck107 = 0 time = 2160
.meas tran vdout2_31ck107 FIND v(dout2_31) AT=2160.1n

* CHECK dout1_0 Vdout1_0ck108 = 1.8 time = 2180
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=2180.1n

* CHECK dout1_1 Vdout1_1ck108 = 0 time = 2180
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=2180.1n

* CHECK dout1_2 Vdout1_2ck108 = 0 time = 2180
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=2180.1n

* CHECK dout1_3 Vdout1_3ck108 = 0 time = 2180
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=2180.1n

* CHECK dout1_4 Vdout1_4ck108 = 1.8 time = 2180
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=2180.1n

* CHECK dout1_5 Vdout1_5ck108 = 1.8 time = 2180
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=2180.1n

* CHECK dout1_6 Vdout1_6ck108 = 1.8 time = 2180
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=2180.1n

* CHECK dout1_7 Vdout1_7ck108 = 0 time = 2180
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=2180.1n

* CHECK dout1_8 Vdout1_8ck108 = 1.8 time = 2180
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=2180.1n

* CHECK dout1_9 Vdout1_9ck108 = 1.8 time = 2180
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=2180.1n

* CHECK dout1_10 Vdout1_10ck108 = 1.8 time = 2180
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=2180.1n

* CHECK dout1_11 Vdout1_11ck108 = 0 time = 2180
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=2180.1n

* CHECK dout1_12 Vdout1_12ck108 = 0 time = 2180
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=2180.1n

* CHECK dout1_13 Vdout1_13ck108 = 1.8 time = 2180
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=2180.1n

* CHECK dout1_14 Vdout1_14ck108 = 1.8 time = 2180
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=2180.1n

* CHECK dout1_15 Vdout1_15ck108 = 1.8 time = 2180
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=2180.1n

* CHECK dout1_16 Vdout1_16ck108 = 0 time = 2180
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=2180.1n

* CHECK dout1_17 Vdout1_17ck108 = 0 time = 2180
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=2180.1n

* CHECK dout1_18 Vdout1_18ck108 = 1.8 time = 2180
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=2180.1n

* CHECK dout1_19 Vdout1_19ck108 = 1.8 time = 2180
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=2180.1n

* CHECK dout1_20 Vdout1_20ck108 = 0 time = 2180
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=2180.1n

* CHECK dout1_21 Vdout1_21ck108 = 1.8 time = 2180
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=2180.1n

* CHECK dout1_22 Vdout1_22ck108 = 1.8 time = 2180
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=2180.1n

* CHECK dout1_23 Vdout1_23ck108 = 0 time = 2180
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=2180.1n

* CHECK dout1_24 Vdout1_24ck108 = 1.8 time = 2180
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=2180.1n

* CHECK dout1_25 Vdout1_25ck108 = 1.8 time = 2180
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=2180.1n

* CHECK dout1_26 Vdout1_26ck108 = 0 time = 2180
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=2180.1n

* CHECK dout1_27 Vdout1_27ck108 = 0 time = 2180
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=2180.1n

* CHECK dout1_28 Vdout1_28ck108 = 0 time = 2180
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=2180.1n

* CHECK dout1_29 Vdout1_29ck108 = 1.8 time = 2180
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=2180.1n

* CHECK dout1_30 Vdout1_30ck108 = 0 time = 2180
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=2180.1n

* CHECK dout1_31 Vdout1_31ck108 = 0 time = 2180
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=2180.1n

* CHECK dout2_0 Vdout2_0ck108 = 1.8 time = 2180
.meas tran vdout2_0ck108 FIND v(dout2_0) AT=2180.1n

* CHECK dout2_1 Vdout2_1ck108 = 0 time = 2180
.meas tran vdout2_1ck108 FIND v(dout2_1) AT=2180.1n

* CHECK dout2_2 Vdout2_2ck108 = 0 time = 2180
.meas tran vdout2_2ck108 FIND v(dout2_2) AT=2180.1n

* CHECK dout2_3 Vdout2_3ck108 = 0 time = 2180
.meas tran vdout2_3ck108 FIND v(dout2_3) AT=2180.1n

* CHECK dout2_4 Vdout2_4ck108 = 1.8 time = 2180
.meas tran vdout2_4ck108 FIND v(dout2_4) AT=2180.1n

* CHECK dout2_5 Vdout2_5ck108 = 1.8 time = 2180
.meas tran vdout2_5ck108 FIND v(dout2_5) AT=2180.1n

* CHECK dout2_6 Vdout2_6ck108 = 1.8 time = 2180
.meas tran vdout2_6ck108 FIND v(dout2_6) AT=2180.1n

* CHECK dout2_7 Vdout2_7ck108 = 0 time = 2180
.meas tran vdout2_7ck108 FIND v(dout2_7) AT=2180.1n

* CHECK dout2_8 Vdout2_8ck108 = 1.8 time = 2180
.meas tran vdout2_8ck108 FIND v(dout2_8) AT=2180.1n

* CHECK dout2_9 Vdout2_9ck108 = 1.8 time = 2180
.meas tran vdout2_9ck108 FIND v(dout2_9) AT=2180.1n

* CHECK dout2_10 Vdout2_10ck108 = 1.8 time = 2180
.meas tran vdout2_10ck108 FIND v(dout2_10) AT=2180.1n

* CHECK dout2_11 Vdout2_11ck108 = 0 time = 2180
.meas tran vdout2_11ck108 FIND v(dout2_11) AT=2180.1n

* CHECK dout2_12 Vdout2_12ck108 = 0 time = 2180
.meas tran vdout2_12ck108 FIND v(dout2_12) AT=2180.1n

* CHECK dout2_13 Vdout2_13ck108 = 1.8 time = 2180
.meas tran vdout2_13ck108 FIND v(dout2_13) AT=2180.1n

* CHECK dout2_14 Vdout2_14ck108 = 1.8 time = 2180
.meas tran vdout2_14ck108 FIND v(dout2_14) AT=2180.1n

* CHECK dout2_15 Vdout2_15ck108 = 1.8 time = 2180
.meas tran vdout2_15ck108 FIND v(dout2_15) AT=2180.1n

* CHECK dout2_16 Vdout2_16ck108 = 0 time = 2180
.meas tran vdout2_16ck108 FIND v(dout2_16) AT=2180.1n

* CHECK dout2_17 Vdout2_17ck108 = 0 time = 2180
.meas tran vdout2_17ck108 FIND v(dout2_17) AT=2180.1n

* CHECK dout2_18 Vdout2_18ck108 = 1.8 time = 2180
.meas tran vdout2_18ck108 FIND v(dout2_18) AT=2180.1n

* CHECK dout2_19 Vdout2_19ck108 = 1.8 time = 2180
.meas tran vdout2_19ck108 FIND v(dout2_19) AT=2180.1n

* CHECK dout2_20 Vdout2_20ck108 = 0 time = 2180
.meas tran vdout2_20ck108 FIND v(dout2_20) AT=2180.1n

* CHECK dout2_21 Vdout2_21ck108 = 1.8 time = 2180
.meas tran vdout2_21ck108 FIND v(dout2_21) AT=2180.1n

* CHECK dout2_22 Vdout2_22ck108 = 1.8 time = 2180
.meas tran vdout2_22ck108 FIND v(dout2_22) AT=2180.1n

* CHECK dout2_23 Vdout2_23ck108 = 0 time = 2180
.meas tran vdout2_23ck108 FIND v(dout2_23) AT=2180.1n

* CHECK dout2_24 Vdout2_24ck108 = 1.8 time = 2180
.meas tran vdout2_24ck108 FIND v(dout2_24) AT=2180.1n

* CHECK dout2_25 Vdout2_25ck108 = 1.8 time = 2180
.meas tran vdout2_25ck108 FIND v(dout2_25) AT=2180.1n

* CHECK dout2_26 Vdout2_26ck108 = 0 time = 2180
.meas tran vdout2_26ck108 FIND v(dout2_26) AT=2180.1n

* CHECK dout2_27 Vdout2_27ck108 = 0 time = 2180
.meas tran vdout2_27ck108 FIND v(dout2_27) AT=2180.1n

* CHECK dout2_28 Vdout2_28ck108 = 0 time = 2180
.meas tran vdout2_28ck108 FIND v(dout2_28) AT=2180.1n

* CHECK dout2_29 Vdout2_29ck108 = 1.8 time = 2180
.meas tran vdout2_29ck108 FIND v(dout2_29) AT=2180.1n

* CHECK dout2_30 Vdout2_30ck108 = 0 time = 2180
.meas tran vdout2_30ck108 FIND v(dout2_30) AT=2180.1n

* CHECK dout2_31 Vdout2_31ck108 = 0 time = 2180
.meas tran vdout2_31ck108 FIND v(dout2_31) AT=2180.1n

* CHECK dout2_0 Vdout2_0ck109 = 0 time = 2200
.meas tran vdout2_0ck109 FIND v(dout2_0) AT=2200.1n

* CHECK dout2_1 Vdout2_1ck109 = 1.8 time = 2200
.meas tran vdout2_1ck109 FIND v(dout2_1) AT=2200.1n

* CHECK dout2_2 Vdout2_2ck109 = 0 time = 2200
.meas tran vdout2_2ck109 FIND v(dout2_2) AT=2200.1n

* CHECK dout2_3 Vdout2_3ck109 = 1.8 time = 2200
.meas tran vdout2_3ck109 FIND v(dout2_3) AT=2200.1n

* CHECK dout2_4 Vdout2_4ck109 = 1.8 time = 2200
.meas tran vdout2_4ck109 FIND v(dout2_4) AT=2200.1n

* CHECK dout2_5 Vdout2_5ck109 = 0 time = 2200
.meas tran vdout2_5ck109 FIND v(dout2_5) AT=2200.1n

* CHECK dout2_6 Vdout2_6ck109 = 0 time = 2200
.meas tran vdout2_6ck109 FIND v(dout2_6) AT=2200.1n

* CHECK dout2_7 Vdout2_7ck109 = 1.8 time = 2200
.meas tran vdout2_7ck109 FIND v(dout2_7) AT=2200.1n

* CHECK dout2_8 Vdout2_8ck109 = 0 time = 2200
.meas tran vdout2_8ck109 FIND v(dout2_8) AT=2200.1n

* CHECK dout2_9 Vdout2_9ck109 = 0 time = 2200
.meas tran vdout2_9ck109 FIND v(dout2_9) AT=2200.1n

* CHECK dout2_10 Vdout2_10ck109 = 1.8 time = 2200
.meas tran vdout2_10ck109 FIND v(dout2_10) AT=2200.1n

* CHECK dout2_11 Vdout2_11ck109 = 1.8 time = 2200
.meas tran vdout2_11ck109 FIND v(dout2_11) AT=2200.1n

* CHECK dout2_12 Vdout2_12ck109 = 0 time = 2200
.meas tran vdout2_12ck109 FIND v(dout2_12) AT=2200.1n

* CHECK dout2_13 Vdout2_13ck109 = 0 time = 2200
.meas tran vdout2_13ck109 FIND v(dout2_13) AT=2200.1n

* CHECK dout2_14 Vdout2_14ck109 = 0 time = 2200
.meas tran vdout2_14ck109 FIND v(dout2_14) AT=2200.1n

* CHECK dout2_15 Vdout2_15ck109 = 1.8 time = 2200
.meas tran vdout2_15ck109 FIND v(dout2_15) AT=2200.1n

* CHECK dout2_16 Vdout2_16ck109 = 1.8 time = 2200
.meas tran vdout2_16ck109 FIND v(dout2_16) AT=2200.1n

* CHECK dout2_17 Vdout2_17ck109 = 0 time = 2200
.meas tran vdout2_17ck109 FIND v(dout2_17) AT=2200.1n

* CHECK dout2_18 Vdout2_18ck109 = 1.8 time = 2200
.meas tran vdout2_18ck109 FIND v(dout2_18) AT=2200.1n

* CHECK dout2_19 Vdout2_19ck109 = 0 time = 2200
.meas tran vdout2_19ck109 FIND v(dout2_19) AT=2200.1n

* CHECK dout2_20 Vdout2_20ck109 = 0 time = 2200
.meas tran vdout2_20ck109 FIND v(dout2_20) AT=2200.1n

* CHECK dout2_21 Vdout2_21ck109 = 1.8 time = 2200
.meas tran vdout2_21ck109 FIND v(dout2_21) AT=2200.1n

* CHECK dout2_22 Vdout2_22ck109 = 0 time = 2200
.meas tran vdout2_22ck109 FIND v(dout2_22) AT=2200.1n

* CHECK dout2_23 Vdout2_23ck109 = 1.8 time = 2200
.meas tran vdout2_23ck109 FIND v(dout2_23) AT=2200.1n

* CHECK dout2_24 Vdout2_24ck109 = 0 time = 2200
.meas tran vdout2_24ck109 FIND v(dout2_24) AT=2200.1n

* CHECK dout2_25 Vdout2_25ck109 = 1.8 time = 2200
.meas tran vdout2_25ck109 FIND v(dout2_25) AT=2200.1n

* CHECK dout2_26 Vdout2_26ck109 = 0 time = 2200
.meas tran vdout2_26ck109 FIND v(dout2_26) AT=2200.1n

* CHECK dout2_27 Vdout2_27ck109 = 0 time = 2200
.meas tran vdout2_27ck109 FIND v(dout2_27) AT=2200.1n

* CHECK dout2_28 Vdout2_28ck109 = 0 time = 2200
.meas tran vdout2_28ck109 FIND v(dout2_28) AT=2200.1n

* CHECK dout2_29 Vdout2_29ck109 = 1.8 time = 2200
.meas tran vdout2_29ck109 FIND v(dout2_29) AT=2200.1n

* CHECK dout2_30 Vdout2_30ck109 = 1.8 time = 2200
.meas tran vdout2_30ck109 FIND v(dout2_30) AT=2200.1n

* CHECK dout2_31 Vdout2_31ck109 = 0 time = 2200
.meas tran vdout2_31ck109 FIND v(dout2_31) AT=2200.1n

* CHECK dout1_0 Vdout1_0ck110 = 1.8 time = 2220
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=2220.1n

* CHECK dout1_1 Vdout1_1ck110 = 1.8 time = 2220
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=2220.1n

* CHECK dout1_2 Vdout1_2ck110 = 0 time = 2220
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=2220.1n

* CHECK dout1_3 Vdout1_3ck110 = 0 time = 2220
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=2220.1n

* CHECK dout1_4 Vdout1_4ck110 = 1.8 time = 2220
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=2220.1n

* CHECK dout1_5 Vdout1_5ck110 = 1.8 time = 2220
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=2220.1n

* CHECK dout1_6 Vdout1_6ck110 = 1.8 time = 2220
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=2220.1n

* CHECK dout1_7 Vdout1_7ck110 = 1.8 time = 2220
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=2220.1n

* CHECK dout1_8 Vdout1_8ck110 = 0 time = 2220
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=2220.1n

* CHECK dout1_9 Vdout1_9ck110 = 1.8 time = 2220
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=2220.1n

* CHECK dout1_10 Vdout1_10ck110 = 1.8 time = 2220
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=2220.1n

* CHECK dout1_11 Vdout1_11ck110 = 0 time = 2220
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=2220.1n

* CHECK dout1_12 Vdout1_12ck110 = 1.8 time = 2220
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=2220.1n

* CHECK dout1_13 Vdout1_13ck110 = 1.8 time = 2220
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=2220.1n

* CHECK dout1_14 Vdout1_14ck110 = 1.8 time = 2220
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=2220.1n

* CHECK dout1_15 Vdout1_15ck110 = 1.8 time = 2220
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=2220.1n

* CHECK dout1_16 Vdout1_16ck110 = 1.8 time = 2220
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=2220.1n

* CHECK dout1_17 Vdout1_17ck110 = 1.8 time = 2220
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=2220.1n

* CHECK dout1_18 Vdout1_18ck110 = 1.8 time = 2220
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=2220.1n

* CHECK dout1_19 Vdout1_19ck110 = 1.8 time = 2220
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=2220.1n

* CHECK dout1_20 Vdout1_20ck110 = 1.8 time = 2220
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=2220.1n

* CHECK dout1_21 Vdout1_21ck110 = 1.8 time = 2220
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=2220.1n

* CHECK dout1_22 Vdout1_22ck110 = 1.8 time = 2220
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=2220.1n

* CHECK dout1_23 Vdout1_23ck110 = 0 time = 2220
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=2220.1n

* CHECK dout1_24 Vdout1_24ck110 = 0 time = 2220
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=2220.1n

* CHECK dout1_25 Vdout1_25ck110 = 0 time = 2220
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=2220.1n

* CHECK dout1_26 Vdout1_26ck110 = 1.8 time = 2220
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=2220.1n

* CHECK dout1_27 Vdout1_27ck110 = 0 time = 2220
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=2220.1n

* CHECK dout1_28 Vdout1_28ck110 = 1.8 time = 2220
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=2220.1n

* CHECK dout1_29 Vdout1_29ck110 = 1.8 time = 2220
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=2220.1n

* CHECK dout1_30 Vdout1_30ck110 = 0 time = 2220
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=2220.1n

* CHECK dout1_31 Vdout1_31ck110 = 1.8 time = 2220
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=2220.1n

* CHECK dout2_0 Vdout2_0ck110 = 1.8 time = 2220
.meas tran vdout2_0ck110 FIND v(dout2_0) AT=2220.1n

* CHECK dout2_1 Vdout2_1ck110 = 0 time = 2220
.meas tran vdout2_1ck110 FIND v(dout2_1) AT=2220.1n

* CHECK dout2_2 Vdout2_2ck110 = 0 time = 2220
.meas tran vdout2_2ck110 FIND v(dout2_2) AT=2220.1n

* CHECK dout2_3 Vdout2_3ck110 = 0 time = 2220
.meas tran vdout2_3ck110 FIND v(dout2_3) AT=2220.1n

* CHECK dout2_4 Vdout2_4ck110 = 1.8 time = 2220
.meas tran vdout2_4ck110 FIND v(dout2_4) AT=2220.1n

* CHECK dout2_5 Vdout2_5ck110 = 1.8 time = 2220
.meas tran vdout2_5ck110 FIND v(dout2_5) AT=2220.1n

* CHECK dout2_6 Vdout2_6ck110 = 1.8 time = 2220
.meas tran vdout2_6ck110 FIND v(dout2_6) AT=2220.1n

* CHECK dout2_7 Vdout2_7ck110 = 0 time = 2220
.meas tran vdout2_7ck110 FIND v(dout2_7) AT=2220.1n

* CHECK dout2_8 Vdout2_8ck110 = 1.8 time = 2220
.meas tran vdout2_8ck110 FIND v(dout2_8) AT=2220.1n

* CHECK dout2_9 Vdout2_9ck110 = 1.8 time = 2220
.meas tran vdout2_9ck110 FIND v(dout2_9) AT=2220.1n

* CHECK dout2_10 Vdout2_10ck110 = 1.8 time = 2220
.meas tran vdout2_10ck110 FIND v(dout2_10) AT=2220.1n

* CHECK dout2_11 Vdout2_11ck110 = 0 time = 2220
.meas tran vdout2_11ck110 FIND v(dout2_11) AT=2220.1n

* CHECK dout2_12 Vdout2_12ck110 = 0 time = 2220
.meas tran vdout2_12ck110 FIND v(dout2_12) AT=2220.1n

* CHECK dout2_13 Vdout2_13ck110 = 1.8 time = 2220
.meas tran vdout2_13ck110 FIND v(dout2_13) AT=2220.1n

* CHECK dout2_14 Vdout2_14ck110 = 1.8 time = 2220
.meas tran vdout2_14ck110 FIND v(dout2_14) AT=2220.1n

* CHECK dout2_15 Vdout2_15ck110 = 1.8 time = 2220
.meas tran vdout2_15ck110 FIND v(dout2_15) AT=2220.1n

* CHECK dout2_16 Vdout2_16ck110 = 0 time = 2220
.meas tran vdout2_16ck110 FIND v(dout2_16) AT=2220.1n

* CHECK dout2_17 Vdout2_17ck110 = 0 time = 2220
.meas tran vdout2_17ck110 FIND v(dout2_17) AT=2220.1n

* CHECK dout2_18 Vdout2_18ck110 = 1.8 time = 2220
.meas tran vdout2_18ck110 FIND v(dout2_18) AT=2220.1n

* CHECK dout2_19 Vdout2_19ck110 = 1.8 time = 2220
.meas tran vdout2_19ck110 FIND v(dout2_19) AT=2220.1n

* CHECK dout2_20 Vdout2_20ck110 = 0 time = 2220
.meas tran vdout2_20ck110 FIND v(dout2_20) AT=2220.1n

* CHECK dout2_21 Vdout2_21ck110 = 1.8 time = 2220
.meas tran vdout2_21ck110 FIND v(dout2_21) AT=2220.1n

* CHECK dout2_22 Vdout2_22ck110 = 1.8 time = 2220
.meas tran vdout2_22ck110 FIND v(dout2_22) AT=2220.1n

* CHECK dout2_23 Vdout2_23ck110 = 0 time = 2220
.meas tran vdout2_23ck110 FIND v(dout2_23) AT=2220.1n

* CHECK dout2_24 Vdout2_24ck110 = 1.8 time = 2220
.meas tran vdout2_24ck110 FIND v(dout2_24) AT=2220.1n

* CHECK dout2_25 Vdout2_25ck110 = 1.8 time = 2220
.meas tran vdout2_25ck110 FIND v(dout2_25) AT=2220.1n

* CHECK dout2_26 Vdout2_26ck110 = 0 time = 2220
.meas tran vdout2_26ck110 FIND v(dout2_26) AT=2220.1n

* CHECK dout2_27 Vdout2_27ck110 = 0 time = 2220
.meas tran vdout2_27ck110 FIND v(dout2_27) AT=2220.1n

* CHECK dout2_28 Vdout2_28ck110 = 0 time = 2220
.meas tran vdout2_28ck110 FIND v(dout2_28) AT=2220.1n

* CHECK dout2_29 Vdout2_29ck110 = 1.8 time = 2220
.meas tran vdout2_29ck110 FIND v(dout2_29) AT=2220.1n

* CHECK dout2_30 Vdout2_30ck110 = 0 time = 2220
.meas tran vdout2_30ck110 FIND v(dout2_30) AT=2220.1n

* CHECK dout2_31 Vdout2_31ck110 = 0 time = 2220
.meas tran vdout2_31ck110 FIND v(dout2_31) AT=2220.1n

* CHECK dout2_0 Vdout2_0ck111 = 1.8 time = 2240
.meas tran vdout2_0ck111 FIND v(dout2_0) AT=2240.1n

* CHECK dout2_1 Vdout2_1ck111 = 0 time = 2240
.meas tran vdout2_1ck111 FIND v(dout2_1) AT=2240.1n

* CHECK dout2_2 Vdout2_2ck111 = 0 time = 2240
.meas tran vdout2_2ck111 FIND v(dout2_2) AT=2240.1n

* CHECK dout2_3 Vdout2_3ck111 = 0 time = 2240
.meas tran vdout2_3ck111 FIND v(dout2_3) AT=2240.1n

* CHECK dout2_4 Vdout2_4ck111 = 1.8 time = 2240
.meas tran vdout2_4ck111 FIND v(dout2_4) AT=2240.1n

* CHECK dout2_5 Vdout2_5ck111 = 1.8 time = 2240
.meas tran vdout2_5ck111 FIND v(dout2_5) AT=2240.1n

* CHECK dout2_6 Vdout2_6ck111 = 1.8 time = 2240
.meas tran vdout2_6ck111 FIND v(dout2_6) AT=2240.1n

* CHECK dout2_7 Vdout2_7ck111 = 0 time = 2240
.meas tran vdout2_7ck111 FIND v(dout2_7) AT=2240.1n

* CHECK dout2_8 Vdout2_8ck111 = 1.8 time = 2240
.meas tran vdout2_8ck111 FIND v(dout2_8) AT=2240.1n

* CHECK dout2_9 Vdout2_9ck111 = 1.8 time = 2240
.meas tran vdout2_9ck111 FIND v(dout2_9) AT=2240.1n

* CHECK dout2_10 Vdout2_10ck111 = 1.8 time = 2240
.meas tran vdout2_10ck111 FIND v(dout2_10) AT=2240.1n

* CHECK dout2_11 Vdout2_11ck111 = 0 time = 2240
.meas tran vdout2_11ck111 FIND v(dout2_11) AT=2240.1n

* CHECK dout2_12 Vdout2_12ck111 = 0 time = 2240
.meas tran vdout2_12ck111 FIND v(dout2_12) AT=2240.1n

* CHECK dout2_13 Vdout2_13ck111 = 1.8 time = 2240
.meas tran vdout2_13ck111 FIND v(dout2_13) AT=2240.1n

* CHECK dout2_14 Vdout2_14ck111 = 1.8 time = 2240
.meas tran vdout2_14ck111 FIND v(dout2_14) AT=2240.1n

* CHECK dout2_15 Vdout2_15ck111 = 1.8 time = 2240
.meas tran vdout2_15ck111 FIND v(dout2_15) AT=2240.1n

* CHECK dout2_16 Vdout2_16ck111 = 0 time = 2240
.meas tran vdout2_16ck111 FIND v(dout2_16) AT=2240.1n

* CHECK dout2_17 Vdout2_17ck111 = 0 time = 2240
.meas tran vdout2_17ck111 FIND v(dout2_17) AT=2240.1n

* CHECK dout2_18 Vdout2_18ck111 = 1.8 time = 2240
.meas tran vdout2_18ck111 FIND v(dout2_18) AT=2240.1n

* CHECK dout2_19 Vdout2_19ck111 = 1.8 time = 2240
.meas tran vdout2_19ck111 FIND v(dout2_19) AT=2240.1n

* CHECK dout2_20 Vdout2_20ck111 = 0 time = 2240
.meas tran vdout2_20ck111 FIND v(dout2_20) AT=2240.1n

* CHECK dout2_21 Vdout2_21ck111 = 1.8 time = 2240
.meas tran vdout2_21ck111 FIND v(dout2_21) AT=2240.1n

* CHECK dout2_22 Vdout2_22ck111 = 1.8 time = 2240
.meas tran vdout2_22ck111 FIND v(dout2_22) AT=2240.1n

* CHECK dout2_23 Vdout2_23ck111 = 0 time = 2240
.meas tran vdout2_23ck111 FIND v(dout2_23) AT=2240.1n

* CHECK dout2_24 Vdout2_24ck111 = 1.8 time = 2240
.meas tran vdout2_24ck111 FIND v(dout2_24) AT=2240.1n

* CHECK dout2_25 Vdout2_25ck111 = 1.8 time = 2240
.meas tran vdout2_25ck111 FIND v(dout2_25) AT=2240.1n

* CHECK dout2_26 Vdout2_26ck111 = 0 time = 2240
.meas tran vdout2_26ck111 FIND v(dout2_26) AT=2240.1n

* CHECK dout2_27 Vdout2_27ck111 = 0 time = 2240
.meas tran vdout2_27ck111 FIND v(dout2_27) AT=2240.1n

* CHECK dout2_28 Vdout2_28ck111 = 0 time = 2240
.meas tran vdout2_28ck111 FIND v(dout2_28) AT=2240.1n

* CHECK dout2_29 Vdout2_29ck111 = 1.8 time = 2240
.meas tran vdout2_29ck111 FIND v(dout2_29) AT=2240.1n

* CHECK dout2_30 Vdout2_30ck111 = 0 time = 2240
.meas tran vdout2_30ck111 FIND v(dout2_30) AT=2240.1n

* CHECK dout2_31 Vdout2_31ck111 = 0 time = 2240
.meas tran vdout2_31ck111 FIND v(dout2_31) AT=2240.1n

* CHECK dout2_0 Vdout2_0ck112 = 1.8 time = 2260
.meas tran vdout2_0ck112 FIND v(dout2_0) AT=2260.1n

* CHECK dout2_1 Vdout2_1ck112 = 1.8 time = 2260
.meas tran vdout2_1ck112 FIND v(dout2_1) AT=2260.1n

* CHECK dout2_2 Vdout2_2ck112 = 0 time = 2260
.meas tran vdout2_2ck112 FIND v(dout2_2) AT=2260.1n

* CHECK dout2_3 Vdout2_3ck112 = 0 time = 2260
.meas tran vdout2_3ck112 FIND v(dout2_3) AT=2260.1n

* CHECK dout2_4 Vdout2_4ck112 = 1.8 time = 2260
.meas tran vdout2_4ck112 FIND v(dout2_4) AT=2260.1n

* CHECK dout2_5 Vdout2_5ck112 = 1.8 time = 2260
.meas tran vdout2_5ck112 FIND v(dout2_5) AT=2260.1n

* CHECK dout2_6 Vdout2_6ck112 = 1.8 time = 2260
.meas tran vdout2_6ck112 FIND v(dout2_6) AT=2260.1n

* CHECK dout2_7 Vdout2_7ck112 = 1.8 time = 2260
.meas tran vdout2_7ck112 FIND v(dout2_7) AT=2260.1n

* CHECK dout2_8 Vdout2_8ck112 = 0 time = 2260
.meas tran vdout2_8ck112 FIND v(dout2_8) AT=2260.1n

* CHECK dout2_9 Vdout2_9ck112 = 1.8 time = 2260
.meas tran vdout2_9ck112 FIND v(dout2_9) AT=2260.1n

* CHECK dout2_10 Vdout2_10ck112 = 1.8 time = 2260
.meas tran vdout2_10ck112 FIND v(dout2_10) AT=2260.1n

* CHECK dout2_11 Vdout2_11ck112 = 0 time = 2260
.meas tran vdout2_11ck112 FIND v(dout2_11) AT=2260.1n

* CHECK dout2_12 Vdout2_12ck112 = 1.8 time = 2260
.meas tran vdout2_12ck112 FIND v(dout2_12) AT=2260.1n

* CHECK dout2_13 Vdout2_13ck112 = 1.8 time = 2260
.meas tran vdout2_13ck112 FIND v(dout2_13) AT=2260.1n

* CHECK dout2_14 Vdout2_14ck112 = 1.8 time = 2260
.meas tran vdout2_14ck112 FIND v(dout2_14) AT=2260.1n

* CHECK dout2_15 Vdout2_15ck112 = 1.8 time = 2260
.meas tran vdout2_15ck112 FIND v(dout2_15) AT=2260.1n

* CHECK dout2_16 Vdout2_16ck112 = 1.8 time = 2260
.meas tran vdout2_16ck112 FIND v(dout2_16) AT=2260.1n

* CHECK dout2_17 Vdout2_17ck112 = 1.8 time = 2260
.meas tran vdout2_17ck112 FIND v(dout2_17) AT=2260.1n

* CHECK dout2_18 Vdout2_18ck112 = 1.8 time = 2260
.meas tran vdout2_18ck112 FIND v(dout2_18) AT=2260.1n

* CHECK dout2_19 Vdout2_19ck112 = 1.8 time = 2260
.meas tran vdout2_19ck112 FIND v(dout2_19) AT=2260.1n

* CHECK dout2_20 Vdout2_20ck112 = 1.8 time = 2260
.meas tran vdout2_20ck112 FIND v(dout2_20) AT=2260.1n

* CHECK dout2_21 Vdout2_21ck112 = 1.8 time = 2260
.meas tran vdout2_21ck112 FIND v(dout2_21) AT=2260.1n

* CHECK dout2_22 Vdout2_22ck112 = 1.8 time = 2260
.meas tran vdout2_22ck112 FIND v(dout2_22) AT=2260.1n

* CHECK dout2_23 Vdout2_23ck112 = 0 time = 2260
.meas tran vdout2_23ck112 FIND v(dout2_23) AT=2260.1n

* CHECK dout2_24 Vdout2_24ck112 = 0 time = 2260
.meas tran vdout2_24ck112 FIND v(dout2_24) AT=2260.1n

* CHECK dout2_25 Vdout2_25ck112 = 0 time = 2260
.meas tran vdout2_25ck112 FIND v(dout2_25) AT=2260.1n

* CHECK dout2_26 Vdout2_26ck112 = 1.8 time = 2260
.meas tran vdout2_26ck112 FIND v(dout2_26) AT=2260.1n

* CHECK dout2_27 Vdout2_27ck112 = 0 time = 2260
.meas tran vdout2_27ck112 FIND v(dout2_27) AT=2260.1n

* CHECK dout2_28 Vdout2_28ck112 = 1.8 time = 2260
.meas tran vdout2_28ck112 FIND v(dout2_28) AT=2260.1n

* CHECK dout2_29 Vdout2_29ck112 = 1.8 time = 2260
.meas tran vdout2_29ck112 FIND v(dout2_29) AT=2260.1n

* CHECK dout2_30 Vdout2_30ck112 = 0 time = 2260
.meas tran vdout2_30ck112 FIND v(dout2_30) AT=2260.1n

* CHECK dout2_31 Vdout2_31ck112 = 1.8 time = 2260
.meas tran vdout2_31ck112 FIND v(dout2_31) AT=2260.1n

* CHECK dout1_0 Vdout1_0ck113 = 1.8 time = 2280
.meas tran vdout1_0ck113 FIND v(dout1_0) AT=2280.1n

* CHECK dout1_1 Vdout1_1ck113 = 0 time = 2280
.meas tran vdout1_1ck113 FIND v(dout1_1) AT=2280.1n

* CHECK dout1_2 Vdout1_2ck113 = 0 time = 2280
.meas tran vdout1_2ck113 FIND v(dout1_2) AT=2280.1n

* CHECK dout1_3 Vdout1_3ck113 = 0 time = 2280
.meas tran vdout1_3ck113 FIND v(dout1_3) AT=2280.1n

* CHECK dout1_4 Vdout1_4ck113 = 1.8 time = 2280
.meas tran vdout1_4ck113 FIND v(dout1_4) AT=2280.1n

* CHECK dout1_5 Vdout1_5ck113 = 1.8 time = 2280
.meas tran vdout1_5ck113 FIND v(dout1_5) AT=2280.1n

* CHECK dout1_6 Vdout1_6ck113 = 1.8 time = 2280
.meas tran vdout1_6ck113 FIND v(dout1_6) AT=2280.1n

* CHECK dout1_7 Vdout1_7ck113 = 0 time = 2280
.meas tran vdout1_7ck113 FIND v(dout1_7) AT=2280.1n

* CHECK dout1_8 Vdout1_8ck113 = 1.8 time = 2280
.meas tran vdout1_8ck113 FIND v(dout1_8) AT=2280.1n

* CHECK dout1_9 Vdout1_9ck113 = 1.8 time = 2280
.meas tran vdout1_9ck113 FIND v(dout1_9) AT=2280.1n

* CHECK dout1_10 Vdout1_10ck113 = 1.8 time = 2280
.meas tran vdout1_10ck113 FIND v(dout1_10) AT=2280.1n

* CHECK dout1_11 Vdout1_11ck113 = 0 time = 2280
.meas tran vdout1_11ck113 FIND v(dout1_11) AT=2280.1n

* CHECK dout1_12 Vdout1_12ck113 = 0 time = 2280
.meas tran vdout1_12ck113 FIND v(dout1_12) AT=2280.1n

* CHECK dout1_13 Vdout1_13ck113 = 1.8 time = 2280
.meas tran vdout1_13ck113 FIND v(dout1_13) AT=2280.1n

* CHECK dout1_14 Vdout1_14ck113 = 1.8 time = 2280
.meas tran vdout1_14ck113 FIND v(dout1_14) AT=2280.1n

* CHECK dout1_15 Vdout1_15ck113 = 1.8 time = 2280
.meas tran vdout1_15ck113 FIND v(dout1_15) AT=2280.1n

* CHECK dout1_16 Vdout1_16ck113 = 0 time = 2280
.meas tran vdout1_16ck113 FIND v(dout1_16) AT=2280.1n

* CHECK dout1_17 Vdout1_17ck113 = 0 time = 2280
.meas tran vdout1_17ck113 FIND v(dout1_17) AT=2280.1n

* CHECK dout1_18 Vdout1_18ck113 = 1.8 time = 2280
.meas tran vdout1_18ck113 FIND v(dout1_18) AT=2280.1n

* CHECK dout1_19 Vdout1_19ck113 = 1.8 time = 2280
.meas tran vdout1_19ck113 FIND v(dout1_19) AT=2280.1n

* CHECK dout1_20 Vdout1_20ck113 = 0 time = 2280
.meas tran vdout1_20ck113 FIND v(dout1_20) AT=2280.1n

* CHECK dout1_21 Vdout1_21ck113 = 1.8 time = 2280
.meas tran vdout1_21ck113 FIND v(dout1_21) AT=2280.1n

* CHECK dout1_22 Vdout1_22ck113 = 1.8 time = 2280
.meas tran vdout1_22ck113 FIND v(dout1_22) AT=2280.1n

* CHECK dout1_23 Vdout1_23ck113 = 0 time = 2280
.meas tran vdout1_23ck113 FIND v(dout1_23) AT=2280.1n

* CHECK dout1_24 Vdout1_24ck113 = 1.8 time = 2280
.meas tran vdout1_24ck113 FIND v(dout1_24) AT=2280.1n

* CHECK dout1_25 Vdout1_25ck113 = 1.8 time = 2280
.meas tran vdout1_25ck113 FIND v(dout1_25) AT=2280.1n

* CHECK dout1_26 Vdout1_26ck113 = 0 time = 2280
.meas tran vdout1_26ck113 FIND v(dout1_26) AT=2280.1n

* CHECK dout1_27 Vdout1_27ck113 = 0 time = 2280
.meas tran vdout1_27ck113 FIND v(dout1_27) AT=2280.1n

* CHECK dout1_28 Vdout1_28ck113 = 0 time = 2280
.meas tran vdout1_28ck113 FIND v(dout1_28) AT=2280.1n

* CHECK dout1_29 Vdout1_29ck113 = 1.8 time = 2280
.meas tran vdout1_29ck113 FIND v(dout1_29) AT=2280.1n

* CHECK dout1_30 Vdout1_30ck113 = 0 time = 2280
.meas tran vdout1_30ck113 FIND v(dout1_30) AT=2280.1n

* CHECK dout1_31 Vdout1_31ck113 = 0 time = 2280
.meas tran vdout1_31ck113 FIND v(dout1_31) AT=2280.1n

* CHECK dout2_0 Vdout2_0ck113 = 1.8 time = 2280
.meas tran vdout2_0ck113 FIND v(dout2_0) AT=2280.1n

* CHECK dout2_1 Vdout2_1ck113 = 1.8 time = 2280
.meas tran vdout2_1ck113 FIND v(dout2_1) AT=2280.1n

* CHECK dout2_2 Vdout2_2ck113 = 0 time = 2280
.meas tran vdout2_2ck113 FIND v(dout2_2) AT=2280.1n

* CHECK dout2_3 Vdout2_3ck113 = 0 time = 2280
.meas tran vdout2_3ck113 FIND v(dout2_3) AT=2280.1n

* CHECK dout2_4 Vdout2_4ck113 = 1.8 time = 2280
.meas tran vdout2_4ck113 FIND v(dout2_4) AT=2280.1n

* CHECK dout2_5 Vdout2_5ck113 = 1.8 time = 2280
.meas tran vdout2_5ck113 FIND v(dout2_5) AT=2280.1n

* CHECK dout2_6 Vdout2_6ck113 = 1.8 time = 2280
.meas tran vdout2_6ck113 FIND v(dout2_6) AT=2280.1n

* CHECK dout2_7 Vdout2_7ck113 = 1.8 time = 2280
.meas tran vdout2_7ck113 FIND v(dout2_7) AT=2280.1n

* CHECK dout2_8 Vdout2_8ck113 = 0 time = 2280
.meas tran vdout2_8ck113 FIND v(dout2_8) AT=2280.1n

* CHECK dout2_9 Vdout2_9ck113 = 1.8 time = 2280
.meas tran vdout2_9ck113 FIND v(dout2_9) AT=2280.1n

* CHECK dout2_10 Vdout2_10ck113 = 1.8 time = 2280
.meas tran vdout2_10ck113 FIND v(dout2_10) AT=2280.1n

* CHECK dout2_11 Vdout2_11ck113 = 0 time = 2280
.meas tran vdout2_11ck113 FIND v(dout2_11) AT=2280.1n

* CHECK dout2_12 Vdout2_12ck113 = 1.8 time = 2280
.meas tran vdout2_12ck113 FIND v(dout2_12) AT=2280.1n

* CHECK dout2_13 Vdout2_13ck113 = 1.8 time = 2280
.meas tran vdout2_13ck113 FIND v(dout2_13) AT=2280.1n

* CHECK dout2_14 Vdout2_14ck113 = 1.8 time = 2280
.meas tran vdout2_14ck113 FIND v(dout2_14) AT=2280.1n

* CHECK dout2_15 Vdout2_15ck113 = 1.8 time = 2280
.meas tran vdout2_15ck113 FIND v(dout2_15) AT=2280.1n

* CHECK dout2_16 Vdout2_16ck113 = 1.8 time = 2280
.meas tran vdout2_16ck113 FIND v(dout2_16) AT=2280.1n

* CHECK dout2_17 Vdout2_17ck113 = 1.8 time = 2280
.meas tran vdout2_17ck113 FIND v(dout2_17) AT=2280.1n

* CHECK dout2_18 Vdout2_18ck113 = 1.8 time = 2280
.meas tran vdout2_18ck113 FIND v(dout2_18) AT=2280.1n

* CHECK dout2_19 Vdout2_19ck113 = 1.8 time = 2280
.meas tran vdout2_19ck113 FIND v(dout2_19) AT=2280.1n

* CHECK dout2_20 Vdout2_20ck113 = 1.8 time = 2280
.meas tran vdout2_20ck113 FIND v(dout2_20) AT=2280.1n

* CHECK dout2_21 Vdout2_21ck113 = 1.8 time = 2280
.meas tran vdout2_21ck113 FIND v(dout2_21) AT=2280.1n

* CHECK dout2_22 Vdout2_22ck113 = 1.8 time = 2280
.meas tran vdout2_22ck113 FIND v(dout2_22) AT=2280.1n

* CHECK dout2_23 Vdout2_23ck113 = 0 time = 2280
.meas tran vdout2_23ck113 FIND v(dout2_23) AT=2280.1n

* CHECK dout2_24 Vdout2_24ck113 = 0 time = 2280
.meas tran vdout2_24ck113 FIND v(dout2_24) AT=2280.1n

* CHECK dout2_25 Vdout2_25ck113 = 0 time = 2280
.meas tran vdout2_25ck113 FIND v(dout2_25) AT=2280.1n

* CHECK dout2_26 Vdout2_26ck113 = 1.8 time = 2280
.meas tran vdout2_26ck113 FIND v(dout2_26) AT=2280.1n

* CHECK dout2_27 Vdout2_27ck113 = 0 time = 2280
.meas tran vdout2_27ck113 FIND v(dout2_27) AT=2280.1n

* CHECK dout2_28 Vdout2_28ck113 = 1.8 time = 2280
.meas tran vdout2_28ck113 FIND v(dout2_28) AT=2280.1n

* CHECK dout2_29 Vdout2_29ck113 = 1.8 time = 2280
.meas tran vdout2_29ck113 FIND v(dout2_29) AT=2280.1n

* CHECK dout2_30 Vdout2_30ck113 = 0 time = 2280
.meas tran vdout2_30ck113 FIND v(dout2_30) AT=2280.1n

* CHECK dout2_31 Vdout2_31ck113 = 1.8 time = 2280
.meas tran vdout2_31ck113 FIND v(dout2_31) AT=2280.1n

* CHECK dout1_0 Vdout1_0ck114 = 1.8 time = 2300
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=2300.1n

* CHECK dout1_1 Vdout1_1ck114 = 0 time = 2300
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=2300.1n

* CHECK dout1_2 Vdout1_2ck114 = 0 time = 2300
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=2300.1n

* CHECK dout1_3 Vdout1_3ck114 = 0 time = 2300
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=2300.1n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 2300
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=2300.1n

* CHECK dout1_5 Vdout1_5ck114 = 1.8 time = 2300
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=2300.1n

* CHECK dout1_6 Vdout1_6ck114 = 1.8 time = 2300
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=2300.1n

* CHECK dout1_7 Vdout1_7ck114 = 1.8 time = 2300
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=2300.1n

* CHECK dout1_8 Vdout1_8ck114 = 1.8 time = 2300
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=2300.1n

* CHECK dout1_9 Vdout1_9ck114 = 1.8 time = 2300
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=2300.1n

* CHECK dout1_10 Vdout1_10ck114 = 1.8 time = 2300
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=2300.1n

* CHECK dout1_11 Vdout1_11ck114 = 0 time = 2300
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=2300.1n

* CHECK dout1_12 Vdout1_12ck114 = 1.8 time = 2300
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=2300.1n

* CHECK dout1_13 Vdout1_13ck114 = 1.8 time = 2300
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=2300.1n

* CHECK dout1_14 Vdout1_14ck114 = 1.8 time = 2300
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=2300.1n

* CHECK dout1_15 Vdout1_15ck114 = 1.8 time = 2300
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=2300.1n

* CHECK dout1_16 Vdout1_16ck114 = 1.8 time = 2300
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=2300.1n

* CHECK dout1_17 Vdout1_17ck114 = 0 time = 2300
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=2300.1n

* CHECK dout1_18 Vdout1_18ck114 = 0 time = 2300
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=2300.1n

* CHECK dout1_19 Vdout1_19ck114 = 0 time = 2300
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=2300.1n

* CHECK dout1_20 Vdout1_20ck114 = 1.8 time = 2300
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=2300.1n

* CHECK dout1_21 Vdout1_21ck114 = 0 time = 2300
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=2300.1n

* CHECK dout1_22 Vdout1_22ck114 = 0 time = 2300
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=2300.1n

* CHECK dout1_23 Vdout1_23ck114 = 1.8 time = 2300
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=2300.1n

* CHECK dout1_24 Vdout1_24ck114 = 1.8 time = 2300
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=2300.1n

* CHECK dout1_25 Vdout1_25ck114 = 0 time = 2300
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=2300.1n

* CHECK dout1_26 Vdout1_26ck114 = 1.8 time = 2300
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=2300.1n

* CHECK dout1_27 Vdout1_27ck114 = 0 time = 2300
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=2300.1n

* CHECK dout1_28 Vdout1_28ck114 = 1.8 time = 2300
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=2300.1n

* CHECK dout1_29 Vdout1_29ck114 = 1.8 time = 2300
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=2300.1n

* CHECK dout1_30 Vdout1_30ck114 = 1.8 time = 2300
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=2300.1n

* CHECK dout1_31 Vdout1_31ck114 = 1.8 time = 2300
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=2300.1n

* CHECK dout2_0 Vdout2_0ck114 = 1.8 time = 2300
.meas tran vdout2_0ck114 FIND v(dout2_0) AT=2300.1n

* CHECK dout2_1 Vdout2_1ck114 = 0 time = 2300
.meas tran vdout2_1ck114 FIND v(dout2_1) AT=2300.1n

* CHECK dout2_2 Vdout2_2ck114 = 0 time = 2300
.meas tran vdout2_2ck114 FIND v(dout2_2) AT=2300.1n

* CHECK dout2_3 Vdout2_3ck114 = 0 time = 2300
.meas tran vdout2_3ck114 FIND v(dout2_3) AT=2300.1n

* CHECK dout2_4 Vdout2_4ck114 = 0 time = 2300
.meas tran vdout2_4ck114 FIND v(dout2_4) AT=2300.1n

* CHECK dout2_5 Vdout2_5ck114 = 1.8 time = 2300
.meas tran vdout2_5ck114 FIND v(dout2_5) AT=2300.1n

* CHECK dout2_6 Vdout2_6ck114 = 1.8 time = 2300
.meas tran vdout2_6ck114 FIND v(dout2_6) AT=2300.1n

* CHECK dout2_7 Vdout2_7ck114 = 1.8 time = 2300
.meas tran vdout2_7ck114 FIND v(dout2_7) AT=2300.1n

* CHECK dout2_8 Vdout2_8ck114 = 1.8 time = 2300
.meas tran vdout2_8ck114 FIND v(dout2_8) AT=2300.1n

* CHECK dout2_9 Vdout2_9ck114 = 1.8 time = 2300
.meas tran vdout2_9ck114 FIND v(dout2_9) AT=2300.1n

* CHECK dout2_10 Vdout2_10ck114 = 1.8 time = 2300
.meas tran vdout2_10ck114 FIND v(dout2_10) AT=2300.1n

* CHECK dout2_11 Vdout2_11ck114 = 0 time = 2300
.meas tran vdout2_11ck114 FIND v(dout2_11) AT=2300.1n

* CHECK dout2_12 Vdout2_12ck114 = 1.8 time = 2300
.meas tran vdout2_12ck114 FIND v(dout2_12) AT=2300.1n

* CHECK dout2_13 Vdout2_13ck114 = 1.8 time = 2300
.meas tran vdout2_13ck114 FIND v(dout2_13) AT=2300.1n

* CHECK dout2_14 Vdout2_14ck114 = 1.8 time = 2300
.meas tran vdout2_14ck114 FIND v(dout2_14) AT=2300.1n

* CHECK dout2_15 Vdout2_15ck114 = 1.8 time = 2300
.meas tran vdout2_15ck114 FIND v(dout2_15) AT=2300.1n

* CHECK dout2_16 Vdout2_16ck114 = 1.8 time = 2300
.meas tran vdout2_16ck114 FIND v(dout2_16) AT=2300.1n

* CHECK dout2_17 Vdout2_17ck114 = 0 time = 2300
.meas tran vdout2_17ck114 FIND v(dout2_17) AT=2300.1n

* CHECK dout2_18 Vdout2_18ck114 = 0 time = 2300
.meas tran vdout2_18ck114 FIND v(dout2_18) AT=2300.1n

* CHECK dout2_19 Vdout2_19ck114 = 0 time = 2300
.meas tran vdout2_19ck114 FIND v(dout2_19) AT=2300.1n

* CHECK dout2_20 Vdout2_20ck114 = 1.8 time = 2300
.meas tran vdout2_20ck114 FIND v(dout2_20) AT=2300.1n

* CHECK dout2_21 Vdout2_21ck114 = 0 time = 2300
.meas tran vdout2_21ck114 FIND v(dout2_21) AT=2300.1n

* CHECK dout2_22 Vdout2_22ck114 = 0 time = 2300
.meas tran vdout2_22ck114 FIND v(dout2_22) AT=2300.1n

* CHECK dout2_23 Vdout2_23ck114 = 1.8 time = 2300
.meas tran vdout2_23ck114 FIND v(dout2_23) AT=2300.1n

* CHECK dout2_24 Vdout2_24ck114 = 1.8 time = 2300
.meas tran vdout2_24ck114 FIND v(dout2_24) AT=2300.1n

* CHECK dout2_25 Vdout2_25ck114 = 0 time = 2300
.meas tran vdout2_25ck114 FIND v(dout2_25) AT=2300.1n

* CHECK dout2_26 Vdout2_26ck114 = 1.8 time = 2300
.meas tran vdout2_26ck114 FIND v(dout2_26) AT=2300.1n

* CHECK dout2_27 Vdout2_27ck114 = 0 time = 2300
.meas tran vdout2_27ck114 FIND v(dout2_27) AT=2300.1n

* CHECK dout2_28 Vdout2_28ck114 = 1.8 time = 2300
.meas tran vdout2_28ck114 FIND v(dout2_28) AT=2300.1n

* CHECK dout2_29 Vdout2_29ck114 = 1.8 time = 2300
.meas tran vdout2_29ck114 FIND v(dout2_29) AT=2300.1n

* CHECK dout2_30 Vdout2_30ck114 = 1.8 time = 2300
.meas tran vdout2_30ck114 FIND v(dout2_30) AT=2300.1n

* CHECK dout2_31 Vdout2_31ck114 = 1.8 time = 2300
.meas tran vdout2_31ck114 FIND v(dout2_31) AT=2300.1n

* CHECK dout2_0 Vdout2_0ck115 = 1.8 time = 2320
.meas tran vdout2_0ck115 FIND v(dout2_0) AT=2320.1n

* CHECK dout2_1 Vdout2_1ck115 = 0 time = 2320
.meas tran vdout2_1ck115 FIND v(dout2_1) AT=2320.1n

* CHECK dout2_2 Vdout2_2ck115 = 1.8 time = 2320
.meas tran vdout2_2ck115 FIND v(dout2_2) AT=2320.1n

* CHECK dout2_3 Vdout2_3ck115 = 1.8 time = 2320
.meas tran vdout2_3ck115 FIND v(dout2_3) AT=2320.1n

* CHECK dout2_4 Vdout2_4ck115 = 1.8 time = 2320
.meas tran vdout2_4ck115 FIND v(dout2_4) AT=2320.1n

* CHECK dout2_5 Vdout2_5ck115 = 0 time = 2320
.meas tran vdout2_5ck115 FIND v(dout2_5) AT=2320.1n

* CHECK dout2_6 Vdout2_6ck115 = 1.8 time = 2320
.meas tran vdout2_6ck115 FIND v(dout2_6) AT=2320.1n

* CHECK dout2_7 Vdout2_7ck115 = 1.8 time = 2320
.meas tran vdout2_7ck115 FIND v(dout2_7) AT=2320.1n

* CHECK dout2_8 Vdout2_8ck115 = 0 time = 2320
.meas tran vdout2_8ck115 FIND v(dout2_8) AT=2320.1n

* CHECK dout2_9 Vdout2_9ck115 = 1.8 time = 2320
.meas tran vdout2_9ck115 FIND v(dout2_9) AT=2320.1n

* CHECK dout2_10 Vdout2_10ck115 = 0 time = 2320
.meas tran vdout2_10ck115 FIND v(dout2_10) AT=2320.1n

* CHECK dout2_11 Vdout2_11ck115 = 0 time = 2320
.meas tran vdout2_11ck115 FIND v(dout2_11) AT=2320.1n

* CHECK dout2_12 Vdout2_12ck115 = 1.8 time = 2320
.meas tran vdout2_12ck115 FIND v(dout2_12) AT=2320.1n

* CHECK dout2_13 Vdout2_13ck115 = 1.8 time = 2320
.meas tran vdout2_13ck115 FIND v(dout2_13) AT=2320.1n

* CHECK dout2_14 Vdout2_14ck115 = 0 time = 2320
.meas tran vdout2_14ck115 FIND v(dout2_14) AT=2320.1n

* CHECK dout2_15 Vdout2_15ck115 = 1.8 time = 2320
.meas tran vdout2_15ck115 FIND v(dout2_15) AT=2320.1n

* CHECK dout2_16 Vdout2_16ck115 = 1.8 time = 2320
.meas tran vdout2_16ck115 FIND v(dout2_16) AT=2320.1n

* CHECK dout2_17 Vdout2_17ck115 = 1.8 time = 2320
.meas tran vdout2_17ck115 FIND v(dout2_17) AT=2320.1n

* CHECK dout2_18 Vdout2_18ck115 = 0 time = 2320
.meas tran vdout2_18ck115 FIND v(dout2_18) AT=2320.1n

* CHECK dout2_19 Vdout2_19ck115 = 0 time = 2320
.meas tran vdout2_19ck115 FIND v(dout2_19) AT=2320.1n

* CHECK dout2_20 Vdout2_20ck115 = 1.8 time = 2320
.meas tran vdout2_20ck115 FIND v(dout2_20) AT=2320.1n

* CHECK dout2_21 Vdout2_21ck115 = 1.8 time = 2320
.meas tran vdout2_21ck115 FIND v(dout2_21) AT=2320.1n

* CHECK dout2_22 Vdout2_22ck115 = 1.8 time = 2320
.meas tran vdout2_22ck115 FIND v(dout2_22) AT=2320.1n

* CHECK dout2_23 Vdout2_23ck115 = 1.8 time = 2320
.meas tran vdout2_23ck115 FIND v(dout2_23) AT=2320.1n

* CHECK dout2_24 Vdout2_24ck115 = 1.8 time = 2320
.meas tran vdout2_24ck115 FIND v(dout2_24) AT=2320.1n

* CHECK dout2_25 Vdout2_25ck115 = 1.8 time = 2320
.meas tran vdout2_25ck115 FIND v(dout2_25) AT=2320.1n

* CHECK dout2_26 Vdout2_26ck115 = 0 time = 2320
.meas tran vdout2_26ck115 FIND v(dout2_26) AT=2320.1n

* CHECK dout2_27 Vdout2_27ck115 = 0 time = 2320
.meas tran vdout2_27ck115 FIND v(dout2_27) AT=2320.1n

* CHECK dout2_28 Vdout2_28ck115 = 1.8 time = 2320
.meas tran vdout2_28ck115 FIND v(dout2_28) AT=2320.1n

* CHECK dout2_29 Vdout2_29ck115 = 0 time = 2320
.meas tran vdout2_29ck115 FIND v(dout2_29) AT=2320.1n

* CHECK dout2_30 Vdout2_30ck115 = 1.8 time = 2320
.meas tran vdout2_30ck115 FIND v(dout2_30) AT=2320.1n

* CHECK dout2_31 Vdout2_31ck115 = 0 time = 2320
.meas tran vdout2_31ck115 FIND v(dout2_31) AT=2320.1n

* CHECK dout1_0 Vdout1_0ck116 = 0 time = 2340
.meas tran vdout1_0ck116 FIND v(dout1_0) AT=2340.1n

* CHECK dout1_1 Vdout1_1ck116 = 1.8 time = 2340
.meas tran vdout1_1ck116 FIND v(dout1_1) AT=2340.1n

* CHECK dout1_2 Vdout1_2ck116 = 1.8 time = 2340
.meas tran vdout1_2ck116 FIND v(dout1_2) AT=2340.1n

* CHECK dout1_3 Vdout1_3ck116 = 1.8 time = 2340
.meas tran vdout1_3ck116 FIND v(dout1_3) AT=2340.1n

* CHECK dout1_4 Vdout1_4ck116 = 1.8 time = 2340
.meas tran vdout1_4ck116 FIND v(dout1_4) AT=2340.1n

* CHECK dout1_5 Vdout1_5ck116 = 1.8 time = 2340
.meas tran vdout1_5ck116 FIND v(dout1_5) AT=2340.1n

* CHECK dout1_6 Vdout1_6ck116 = 0 time = 2340
.meas tran vdout1_6ck116 FIND v(dout1_6) AT=2340.1n

* CHECK dout1_7 Vdout1_7ck116 = 1.8 time = 2340
.meas tran vdout1_7ck116 FIND v(dout1_7) AT=2340.1n

* CHECK dout1_8 Vdout1_8ck116 = 1.8 time = 2340
.meas tran vdout1_8ck116 FIND v(dout1_8) AT=2340.1n

* CHECK dout1_9 Vdout1_9ck116 = 0 time = 2340
.meas tran vdout1_9ck116 FIND v(dout1_9) AT=2340.1n

* CHECK dout1_10 Vdout1_10ck116 = 0 time = 2340
.meas tran vdout1_10ck116 FIND v(dout1_10) AT=2340.1n

* CHECK dout1_11 Vdout1_11ck116 = 1.8 time = 2340
.meas tran vdout1_11ck116 FIND v(dout1_11) AT=2340.1n

* CHECK dout1_12 Vdout1_12ck116 = 0 time = 2340
.meas tran vdout1_12ck116 FIND v(dout1_12) AT=2340.1n

* CHECK dout1_13 Vdout1_13ck116 = 0 time = 2340
.meas tran vdout1_13ck116 FIND v(dout1_13) AT=2340.1n

* CHECK dout1_14 Vdout1_14ck116 = 0 time = 2340
.meas tran vdout1_14ck116 FIND v(dout1_14) AT=2340.1n

* CHECK dout1_15 Vdout1_15ck116 = 0 time = 2340
.meas tran vdout1_15ck116 FIND v(dout1_15) AT=2340.1n

* CHECK dout1_16 Vdout1_16ck116 = 0 time = 2340
.meas tran vdout1_16ck116 FIND v(dout1_16) AT=2340.1n

* CHECK dout1_17 Vdout1_17ck116 = 1.8 time = 2340
.meas tran vdout1_17ck116 FIND v(dout1_17) AT=2340.1n

* CHECK dout1_18 Vdout1_18ck116 = 1.8 time = 2340
.meas tran vdout1_18ck116 FIND v(dout1_18) AT=2340.1n

* CHECK dout1_19 Vdout1_19ck116 = 0 time = 2340
.meas tran vdout1_19ck116 FIND v(dout1_19) AT=2340.1n

* CHECK dout1_20 Vdout1_20ck116 = 1.8 time = 2340
.meas tran vdout1_20ck116 FIND v(dout1_20) AT=2340.1n

* CHECK dout1_21 Vdout1_21ck116 = 0 time = 2340
.meas tran vdout1_21ck116 FIND v(dout1_21) AT=2340.1n

* CHECK dout1_22 Vdout1_22ck116 = 1.8 time = 2340
.meas tran vdout1_22ck116 FIND v(dout1_22) AT=2340.1n

* CHECK dout1_23 Vdout1_23ck116 = 0 time = 2340
.meas tran vdout1_23ck116 FIND v(dout1_23) AT=2340.1n

* CHECK dout1_24 Vdout1_24ck116 = 1.8 time = 2340
.meas tran vdout1_24ck116 FIND v(dout1_24) AT=2340.1n

* CHECK dout1_25 Vdout1_25ck116 = 1.8 time = 2340
.meas tran vdout1_25ck116 FIND v(dout1_25) AT=2340.1n

* CHECK dout1_26 Vdout1_26ck116 = 0 time = 2340
.meas tran vdout1_26ck116 FIND v(dout1_26) AT=2340.1n

* CHECK dout1_27 Vdout1_27ck116 = 1.8 time = 2340
.meas tran vdout1_27ck116 FIND v(dout1_27) AT=2340.1n

* CHECK dout1_28 Vdout1_28ck116 = 0 time = 2340
.meas tran vdout1_28ck116 FIND v(dout1_28) AT=2340.1n

* CHECK dout1_29 Vdout1_29ck116 = 0 time = 2340
.meas tran vdout1_29ck116 FIND v(dout1_29) AT=2340.1n

* CHECK dout1_30 Vdout1_30ck116 = 1.8 time = 2340
.meas tran vdout1_30ck116 FIND v(dout1_30) AT=2340.1n

* CHECK dout1_31 Vdout1_31ck116 = 1.8 time = 2340
.meas tran vdout1_31ck116 FIND v(dout1_31) AT=2340.1n

* CHECK dout2_0 Vdout2_0ck116 = 1.8 time = 2340
.meas tran vdout2_0ck116 FIND v(dout2_0) AT=2340.1n

* CHECK dout2_1 Vdout2_1ck116 = 0 time = 2340
.meas tran vdout2_1ck116 FIND v(dout2_1) AT=2340.1n

* CHECK dout2_2 Vdout2_2ck116 = 1.8 time = 2340
.meas tran vdout2_2ck116 FIND v(dout2_2) AT=2340.1n

* CHECK dout2_3 Vdout2_3ck116 = 1.8 time = 2340
.meas tran vdout2_3ck116 FIND v(dout2_3) AT=2340.1n

* CHECK dout2_4 Vdout2_4ck116 = 1.8 time = 2340
.meas tran vdout2_4ck116 FIND v(dout2_4) AT=2340.1n

* CHECK dout2_5 Vdout2_5ck116 = 0 time = 2340
.meas tran vdout2_5ck116 FIND v(dout2_5) AT=2340.1n

* CHECK dout2_6 Vdout2_6ck116 = 1.8 time = 2340
.meas tran vdout2_6ck116 FIND v(dout2_6) AT=2340.1n

* CHECK dout2_7 Vdout2_7ck116 = 1.8 time = 2340
.meas tran vdout2_7ck116 FIND v(dout2_7) AT=2340.1n

* CHECK dout2_8 Vdout2_8ck116 = 0 time = 2340
.meas tran vdout2_8ck116 FIND v(dout2_8) AT=2340.1n

* CHECK dout2_9 Vdout2_9ck116 = 0 time = 2340
.meas tran vdout2_9ck116 FIND v(dout2_9) AT=2340.1n

* CHECK dout2_10 Vdout2_10ck116 = 0 time = 2340
.meas tran vdout2_10ck116 FIND v(dout2_10) AT=2340.1n

* CHECK dout2_11 Vdout2_11ck116 = 1.8 time = 2340
.meas tran vdout2_11ck116 FIND v(dout2_11) AT=2340.1n

* CHECK dout2_12 Vdout2_12ck116 = 1.8 time = 2340
.meas tran vdout2_12ck116 FIND v(dout2_12) AT=2340.1n

* CHECK dout2_13 Vdout2_13ck116 = 1.8 time = 2340
.meas tran vdout2_13ck116 FIND v(dout2_13) AT=2340.1n

* CHECK dout2_14 Vdout2_14ck116 = 0 time = 2340
.meas tran vdout2_14ck116 FIND v(dout2_14) AT=2340.1n

* CHECK dout2_15 Vdout2_15ck116 = 0 time = 2340
.meas tran vdout2_15ck116 FIND v(dout2_15) AT=2340.1n

* CHECK dout2_16 Vdout2_16ck116 = 0 time = 2340
.meas tran vdout2_16ck116 FIND v(dout2_16) AT=2340.1n

* CHECK dout2_17 Vdout2_17ck116 = 0 time = 2340
.meas tran vdout2_17ck116 FIND v(dout2_17) AT=2340.1n

* CHECK dout2_18 Vdout2_18ck116 = 1.8 time = 2340
.meas tran vdout2_18ck116 FIND v(dout2_18) AT=2340.1n

* CHECK dout2_19 Vdout2_19ck116 = 0 time = 2340
.meas tran vdout2_19ck116 FIND v(dout2_19) AT=2340.1n

* CHECK dout2_20 Vdout2_20ck116 = 0 time = 2340
.meas tran vdout2_20ck116 FIND v(dout2_20) AT=2340.1n

* CHECK dout2_21 Vdout2_21ck116 = 1.8 time = 2340
.meas tran vdout2_21ck116 FIND v(dout2_21) AT=2340.1n

* CHECK dout2_22 Vdout2_22ck116 = 1.8 time = 2340
.meas tran vdout2_22ck116 FIND v(dout2_22) AT=2340.1n

* CHECK dout2_23 Vdout2_23ck116 = 1.8 time = 2340
.meas tran vdout2_23ck116 FIND v(dout2_23) AT=2340.1n

* CHECK dout2_24 Vdout2_24ck116 = 1.8 time = 2340
.meas tran vdout2_24ck116 FIND v(dout2_24) AT=2340.1n

* CHECK dout2_25 Vdout2_25ck116 = 0 time = 2340
.meas tran vdout2_25ck116 FIND v(dout2_25) AT=2340.1n

* CHECK dout2_26 Vdout2_26ck116 = 1.8 time = 2340
.meas tran vdout2_26ck116 FIND v(dout2_26) AT=2340.1n

* CHECK dout2_27 Vdout2_27ck116 = 1.8 time = 2340
.meas tran vdout2_27ck116 FIND v(dout2_27) AT=2340.1n

* CHECK dout2_28 Vdout2_28ck116 = 1.8 time = 2340
.meas tran vdout2_28ck116 FIND v(dout2_28) AT=2340.1n

* CHECK dout2_29 Vdout2_29ck116 = 1.8 time = 2340
.meas tran vdout2_29ck116 FIND v(dout2_29) AT=2340.1n

* CHECK dout2_30 Vdout2_30ck116 = 1.8 time = 2340
.meas tran vdout2_30ck116 FIND v(dout2_30) AT=2340.1n

* CHECK dout2_31 Vdout2_31ck116 = 1.8 time = 2340
.meas tran vdout2_31ck116 FIND v(dout2_31) AT=2340.1n

* CHECK dout1_0 Vdout1_0ck117 = 0 time = 2360
.meas tran vdout1_0ck117 FIND v(dout1_0) AT=2360.1n

* CHECK dout1_1 Vdout1_1ck117 = 1.8 time = 2360
.meas tran vdout1_1ck117 FIND v(dout1_1) AT=2360.1n

* CHECK dout1_2 Vdout1_2ck117 = 1.8 time = 2360
.meas tran vdout1_2ck117 FIND v(dout1_2) AT=2360.1n

* CHECK dout1_3 Vdout1_3ck117 = 0 time = 2360
.meas tran vdout1_3ck117 FIND v(dout1_3) AT=2360.1n

* CHECK dout1_4 Vdout1_4ck117 = 1.8 time = 2360
.meas tran vdout1_4ck117 FIND v(dout1_4) AT=2360.1n

* CHECK dout1_5 Vdout1_5ck117 = 0 time = 2360
.meas tran vdout1_5ck117 FIND v(dout1_5) AT=2360.1n

* CHECK dout1_6 Vdout1_6ck117 = 0 time = 2360
.meas tran vdout1_6ck117 FIND v(dout1_6) AT=2360.1n

* CHECK dout1_7 Vdout1_7ck117 = 0 time = 2360
.meas tran vdout1_7ck117 FIND v(dout1_7) AT=2360.1n

* CHECK dout1_8 Vdout1_8ck117 = 1.8 time = 2360
.meas tran vdout1_8ck117 FIND v(dout1_8) AT=2360.1n

* CHECK dout1_9 Vdout1_9ck117 = 1.8 time = 2360
.meas tran vdout1_9ck117 FIND v(dout1_9) AT=2360.1n

* CHECK dout1_10 Vdout1_10ck117 = 1.8 time = 2360
.meas tran vdout1_10ck117 FIND v(dout1_10) AT=2360.1n

* CHECK dout1_11 Vdout1_11ck117 = 1.8 time = 2360
.meas tran vdout1_11ck117 FIND v(dout1_11) AT=2360.1n

* CHECK dout1_12 Vdout1_12ck117 = 1.8 time = 2360
.meas tran vdout1_12ck117 FIND v(dout1_12) AT=2360.1n

* CHECK dout1_13 Vdout1_13ck117 = 1.8 time = 2360
.meas tran vdout1_13ck117 FIND v(dout1_13) AT=2360.1n

* CHECK dout1_14 Vdout1_14ck117 = 1.8 time = 2360
.meas tran vdout1_14ck117 FIND v(dout1_14) AT=2360.1n

* CHECK dout1_15 Vdout1_15ck117 = 0 time = 2360
.meas tran vdout1_15ck117 FIND v(dout1_15) AT=2360.1n

* CHECK dout1_16 Vdout1_16ck117 = 1.8 time = 2360
.meas tran vdout1_16ck117 FIND v(dout1_16) AT=2360.1n

* CHECK dout1_17 Vdout1_17ck117 = 1.8 time = 2360
.meas tran vdout1_17ck117 FIND v(dout1_17) AT=2360.1n

* CHECK dout1_18 Vdout1_18ck117 = 1.8 time = 2360
.meas tran vdout1_18ck117 FIND v(dout1_18) AT=2360.1n

* CHECK dout1_19 Vdout1_19ck117 = 1.8 time = 2360
.meas tran vdout1_19ck117 FIND v(dout1_19) AT=2360.1n

* CHECK dout1_20 Vdout1_20ck117 = 1.8 time = 2360
.meas tran vdout1_20ck117 FIND v(dout1_20) AT=2360.1n

* CHECK dout1_21 Vdout1_21ck117 = 1.8 time = 2360
.meas tran vdout1_21ck117 FIND v(dout1_21) AT=2360.1n

* CHECK dout1_22 Vdout1_22ck117 = 0 time = 2360
.meas tran vdout1_22ck117 FIND v(dout1_22) AT=2360.1n

* CHECK dout1_23 Vdout1_23ck117 = 0 time = 2360
.meas tran vdout1_23ck117 FIND v(dout1_23) AT=2360.1n

* CHECK dout1_24 Vdout1_24ck117 = 1.8 time = 2360
.meas tran vdout1_24ck117 FIND v(dout1_24) AT=2360.1n

* CHECK dout1_25 Vdout1_25ck117 = 1.8 time = 2360
.meas tran vdout1_25ck117 FIND v(dout1_25) AT=2360.1n

* CHECK dout1_26 Vdout1_26ck117 = 0 time = 2360
.meas tran vdout1_26ck117 FIND v(dout1_26) AT=2360.1n

* CHECK dout1_27 Vdout1_27ck117 = 1.8 time = 2360
.meas tran vdout1_27ck117 FIND v(dout1_27) AT=2360.1n

* CHECK dout1_28 Vdout1_28ck117 = 1.8 time = 2360
.meas tran vdout1_28ck117 FIND v(dout1_28) AT=2360.1n

* CHECK dout1_29 Vdout1_29ck117 = 1.8 time = 2360
.meas tran vdout1_29ck117 FIND v(dout1_29) AT=2360.1n

* CHECK dout1_30 Vdout1_30ck117 = 1.8 time = 2360
.meas tran vdout1_30ck117 FIND v(dout1_30) AT=2360.1n

* CHECK dout1_31 Vdout1_31ck117 = 0 time = 2360
.meas tran vdout1_31ck117 FIND v(dout1_31) AT=2360.1n

* CHECK dout2_0 Vdout2_0ck117 = 0 time = 2360
.meas tran vdout2_0ck117 FIND v(dout2_0) AT=2360.1n

* CHECK dout2_1 Vdout2_1ck117 = 1.8 time = 2360
.meas tran vdout2_1ck117 FIND v(dout2_1) AT=2360.1n

* CHECK dout2_2 Vdout2_2ck117 = 1.8 time = 2360
.meas tran vdout2_2ck117 FIND v(dout2_2) AT=2360.1n

* CHECK dout2_3 Vdout2_3ck117 = 0 time = 2360
.meas tran vdout2_3ck117 FIND v(dout2_3) AT=2360.1n

* CHECK dout2_4 Vdout2_4ck117 = 1.8 time = 2360
.meas tran vdout2_4ck117 FIND v(dout2_4) AT=2360.1n

* CHECK dout2_5 Vdout2_5ck117 = 0 time = 2360
.meas tran vdout2_5ck117 FIND v(dout2_5) AT=2360.1n

* CHECK dout2_6 Vdout2_6ck117 = 0 time = 2360
.meas tran vdout2_6ck117 FIND v(dout2_6) AT=2360.1n

* CHECK dout2_7 Vdout2_7ck117 = 0 time = 2360
.meas tran vdout2_7ck117 FIND v(dout2_7) AT=2360.1n

* CHECK dout2_8 Vdout2_8ck117 = 1.8 time = 2360
.meas tran vdout2_8ck117 FIND v(dout2_8) AT=2360.1n

* CHECK dout2_9 Vdout2_9ck117 = 1.8 time = 2360
.meas tran vdout2_9ck117 FIND v(dout2_9) AT=2360.1n

* CHECK dout2_10 Vdout2_10ck117 = 1.8 time = 2360
.meas tran vdout2_10ck117 FIND v(dout2_10) AT=2360.1n

* CHECK dout2_11 Vdout2_11ck117 = 1.8 time = 2360
.meas tran vdout2_11ck117 FIND v(dout2_11) AT=2360.1n

* CHECK dout2_12 Vdout2_12ck117 = 1.8 time = 2360
.meas tran vdout2_12ck117 FIND v(dout2_12) AT=2360.1n

* CHECK dout2_13 Vdout2_13ck117 = 1.8 time = 2360
.meas tran vdout2_13ck117 FIND v(dout2_13) AT=2360.1n

* CHECK dout2_14 Vdout2_14ck117 = 1.8 time = 2360
.meas tran vdout2_14ck117 FIND v(dout2_14) AT=2360.1n

* CHECK dout2_15 Vdout2_15ck117 = 0 time = 2360
.meas tran vdout2_15ck117 FIND v(dout2_15) AT=2360.1n

* CHECK dout2_16 Vdout2_16ck117 = 1.8 time = 2360
.meas tran vdout2_16ck117 FIND v(dout2_16) AT=2360.1n

* CHECK dout2_17 Vdout2_17ck117 = 1.8 time = 2360
.meas tran vdout2_17ck117 FIND v(dout2_17) AT=2360.1n

* CHECK dout2_18 Vdout2_18ck117 = 1.8 time = 2360
.meas tran vdout2_18ck117 FIND v(dout2_18) AT=2360.1n

* CHECK dout2_19 Vdout2_19ck117 = 1.8 time = 2360
.meas tran vdout2_19ck117 FIND v(dout2_19) AT=2360.1n

* CHECK dout2_20 Vdout2_20ck117 = 1.8 time = 2360
.meas tran vdout2_20ck117 FIND v(dout2_20) AT=2360.1n

* CHECK dout2_21 Vdout2_21ck117 = 1.8 time = 2360
.meas tran vdout2_21ck117 FIND v(dout2_21) AT=2360.1n

* CHECK dout2_22 Vdout2_22ck117 = 0 time = 2360
.meas tran vdout2_22ck117 FIND v(dout2_22) AT=2360.1n

* CHECK dout2_23 Vdout2_23ck117 = 0 time = 2360
.meas tran vdout2_23ck117 FIND v(dout2_23) AT=2360.1n

* CHECK dout2_24 Vdout2_24ck117 = 1.8 time = 2360
.meas tran vdout2_24ck117 FIND v(dout2_24) AT=2360.1n

* CHECK dout2_25 Vdout2_25ck117 = 1.8 time = 2360
.meas tran vdout2_25ck117 FIND v(dout2_25) AT=2360.1n

* CHECK dout2_26 Vdout2_26ck117 = 0 time = 2360
.meas tran vdout2_26ck117 FIND v(dout2_26) AT=2360.1n

* CHECK dout2_27 Vdout2_27ck117 = 1.8 time = 2360
.meas tran vdout2_27ck117 FIND v(dout2_27) AT=2360.1n

* CHECK dout2_28 Vdout2_28ck117 = 1.8 time = 2360
.meas tran vdout2_28ck117 FIND v(dout2_28) AT=2360.1n

* CHECK dout2_29 Vdout2_29ck117 = 1.8 time = 2360
.meas tran vdout2_29ck117 FIND v(dout2_29) AT=2360.1n

* CHECK dout2_30 Vdout2_30ck117 = 1.8 time = 2360
.meas tran vdout2_30ck117 FIND v(dout2_30) AT=2360.1n

* CHECK dout2_31 Vdout2_31ck117 = 0 time = 2360
.meas tran vdout2_31ck117 FIND v(dout2_31) AT=2360.1n

* CHECK dout1_0 Vdout1_0ck118 = 1.8 time = 2380
.meas tran vdout1_0ck118 FIND v(dout1_0) AT=2380.1n

* CHECK dout1_1 Vdout1_1ck118 = 1.8 time = 2380
.meas tran vdout1_1ck118 FIND v(dout1_1) AT=2380.1n

* CHECK dout1_2 Vdout1_2ck118 = 0 time = 2380
.meas tran vdout1_2ck118 FIND v(dout1_2) AT=2380.1n

* CHECK dout1_3 Vdout1_3ck118 = 0 time = 2380
.meas tran vdout1_3ck118 FIND v(dout1_3) AT=2380.1n

* CHECK dout1_4 Vdout1_4ck118 = 1.8 time = 2380
.meas tran vdout1_4ck118 FIND v(dout1_4) AT=2380.1n

* CHECK dout1_5 Vdout1_5ck118 = 1.8 time = 2380
.meas tran vdout1_5ck118 FIND v(dout1_5) AT=2380.1n

* CHECK dout1_6 Vdout1_6ck118 = 1.8 time = 2380
.meas tran vdout1_6ck118 FIND v(dout1_6) AT=2380.1n

* CHECK dout1_7 Vdout1_7ck118 = 0 time = 2380
.meas tran vdout1_7ck118 FIND v(dout1_7) AT=2380.1n

* CHECK dout1_8 Vdout1_8ck118 = 0 time = 2380
.meas tran vdout1_8ck118 FIND v(dout1_8) AT=2380.1n

* CHECK dout1_9 Vdout1_9ck118 = 1.8 time = 2380
.meas tran vdout1_9ck118 FIND v(dout1_9) AT=2380.1n

* CHECK dout1_10 Vdout1_10ck118 = 1.8 time = 2380
.meas tran vdout1_10ck118 FIND v(dout1_10) AT=2380.1n

* CHECK dout1_11 Vdout1_11ck118 = 1.8 time = 2380
.meas tran vdout1_11ck118 FIND v(dout1_11) AT=2380.1n

* CHECK dout1_12 Vdout1_12ck118 = 0 time = 2380
.meas tran vdout1_12ck118 FIND v(dout1_12) AT=2380.1n

* CHECK dout1_13 Vdout1_13ck118 = 1.8 time = 2380
.meas tran vdout1_13ck118 FIND v(dout1_13) AT=2380.1n

* CHECK dout1_14 Vdout1_14ck118 = 0 time = 2380
.meas tran vdout1_14ck118 FIND v(dout1_14) AT=2380.1n

* CHECK dout1_15 Vdout1_15ck118 = 0 time = 2380
.meas tran vdout1_15ck118 FIND v(dout1_15) AT=2380.1n

* CHECK dout1_16 Vdout1_16ck118 = 1.8 time = 2380
.meas tran vdout1_16ck118 FIND v(dout1_16) AT=2380.1n

* CHECK dout1_17 Vdout1_17ck118 = 0 time = 2380
.meas tran vdout1_17ck118 FIND v(dout1_17) AT=2380.1n

* CHECK dout1_18 Vdout1_18ck118 = 1.8 time = 2380
.meas tran vdout1_18ck118 FIND v(dout1_18) AT=2380.1n

* CHECK dout1_19 Vdout1_19ck118 = 1.8 time = 2380
.meas tran vdout1_19ck118 FIND v(dout1_19) AT=2380.1n

* CHECK dout1_20 Vdout1_20ck118 = 1.8 time = 2380
.meas tran vdout1_20ck118 FIND v(dout1_20) AT=2380.1n

* CHECK dout1_21 Vdout1_21ck118 = 0 time = 2380
.meas tran vdout1_21ck118 FIND v(dout1_21) AT=2380.1n

* CHECK dout1_22 Vdout1_22ck118 = 0 time = 2380
.meas tran vdout1_22ck118 FIND v(dout1_22) AT=2380.1n

* CHECK dout1_23 Vdout1_23ck118 = 0 time = 2380
.meas tran vdout1_23ck118 FIND v(dout1_23) AT=2380.1n

* CHECK dout1_24 Vdout1_24ck118 = 1.8 time = 2380
.meas tran vdout1_24ck118 FIND v(dout1_24) AT=2380.1n

* CHECK dout1_25 Vdout1_25ck118 = 1.8 time = 2380
.meas tran vdout1_25ck118 FIND v(dout1_25) AT=2380.1n

* CHECK dout1_26 Vdout1_26ck118 = 1.8 time = 2380
.meas tran vdout1_26ck118 FIND v(dout1_26) AT=2380.1n

* CHECK dout1_27 Vdout1_27ck118 = 1.8 time = 2380
.meas tran vdout1_27ck118 FIND v(dout1_27) AT=2380.1n

* CHECK dout1_28 Vdout1_28ck118 = 1.8 time = 2380
.meas tran vdout1_28ck118 FIND v(dout1_28) AT=2380.1n

* CHECK dout1_29 Vdout1_29ck118 = 1.8 time = 2380
.meas tran vdout1_29ck118 FIND v(dout1_29) AT=2380.1n

* CHECK dout1_30 Vdout1_30ck118 = 1.8 time = 2380
.meas tran vdout1_30ck118 FIND v(dout1_30) AT=2380.1n

* CHECK dout1_31 Vdout1_31ck118 = 1.8 time = 2380
.meas tran vdout1_31ck118 FIND v(dout1_31) AT=2380.1n

* CHECK dout2_0 Vdout2_0ck118 = 0 time = 2380
.meas tran vdout2_0ck118 FIND v(dout2_0) AT=2380.1n

* CHECK dout2_1 Vdout2_1ck118 = 1.8 time = 2380
.meas tran vdout2_1ck118 FIND v(dout2_1) AT=2380.1n

* CHECK dout2_2 Vdout2_2ck118 = 1.8 time = 2380
.meas tran vdout2_2ck118 FIND v(dout2_2) AT=2380.1n

* CHECK dout2_3 Vdout2_3ck118 = 1.8 time = 2380
.meas tran vdout2_3ck118 FIND v(dout2_3) AT=2380.1n

* CHECK dout2_4 Vdout2_4ck118 = 1.8 time = 2380
.meas tran vdout2_4ck118 FIND v(dout2_4) AT=2380.1n

* CHECK dout2_5 Vdout2_5ck118 = 1.8 time = 2380
.meas tran vdout2_5ck118 FIND v(dout2_5) AT=2380.1n

* CHECK dout2_6 Vdout2_6ck118 = 0 time = 2380
.meas tran vdout2_6ck118 FIND v(dout2_6) AT=2380.1n

* CHECK dout2_7 Vdout2_7ck118 = 1.8 time = 2380
.meas tran vdout2_7ck118 FIND v(dout2_7) AT=2380.1n

* CHECK dout2_8 Vdout2_8ck118 = 1.8 time = 2380
.meas tran vdout2_8ck118 FIND v(dout2_8) AT=2380.1n

* CHECK dout2_9 Vdout2_9ck118 = 0 time = 2380
.meas tran vdout2_9ck118 FIND v(dout2_9) AT=2380.1n

* CHECK dout2_10 Vdout2_10ck118 = 0 time = 2380
.meas tran vdout2_10ck118 FIND v(dout2_10) AT=2380.1n

* CHECK dout2_11 Vdout2_11ck118 = 1.8 time = 2380
.meas tran vdout2_11ck118 FIND v(dout2_11) AT=2380.1n

* CHECK dout2_12 Vdout2_12ck118 = 0 time = 2380
.meas tran vdout2_12ck118 FIND v(dout2_12) AT=2380.1n

* CHECK dout2_13 Vdout2_13ck118 = 0 time = 2380
.meas tran vdout2_13ck118 FIND v(dout2_13) AT=2380.1n

* CHECK dout2_14 Vdout2_14ck118 = 0 time = 2380
.meas tran vdout2_14ck118 FIND v(dout2_14) AT=2380.1n

* CHECK dout2_15 Vdout2_15ck118 = 0 time = 2380
.meas tran vdout2_15ck118 FIND v(dout2_15) AT=2380.1n

* CHECK dout2_16 Vdout2_16ck118 = 0 time = 2380
.meas tran vdout2_16ck118 FIND v(dout2_16) AT=2380.1n

* CHECK dout2_17 Vdout2_17ck118 = 1.8 time = 2380
.meas tran vdout2_17ck118 FIND v(dout2_17) AT=2380.1n

* CHECK dout2_18 Vdout2_18ck118 = 1.8 time = 2380
.meas tran vdout2_18ck118 FIND v(dout2_18) AT=2380.1n

* CHECK dout2_19 Vdout2_19ck118 = 0 time = 2380
.meas tran vdout2_19ck118 FIND v(dout2_19) AT=2380.1n

* CHECK dout2_20 Vdout2_20ck118 = 1.8 time = 2380
.meas tran vdout2_20ck118 FIND v(dout2_20) AT=2380.1n

* CHECK dout2_21 Vdout2_21ck118 = 0 time = 2380
.meas tran vdout2_21ck118 FIND v(dout2_21) AT=2380.1n

* CHECK dout2_22 Vdout2_22ck118 = 1.8 time = 2380
.meas tran vdout2_22ck118 FIND v(dout2_22) AT=2380.1n

* CHECK dout2_23 Vdout2_23ck118 = 0 time = 2380
.meas tran vdout2_23ck118 FIND v(dout2_23) AT=2380.1n

* CHECK dout2_24 Vdout2_24ck118 = 1.8 time = 2380
.meas tran vdout2_24ck118 FIND v(dout2_24) AT=2380.1n

* CHECK dout2_25 Vdout2_25ck118 = 1.8 time = 2380
.meas tran vdout2_25ck118 FIND v(dout2_25) AT=2380.1n

* CHECK dout2_26 Vdout2_26ck118 = 0 time = 2380
.meas tran vdout2_26ck118 FIND v(dout2_26) AT=2380.1n

* CHECK dout2_27 Vdout2_27ck118 = 1.8 time = 2380
.meas tran vdout2_27ck118 FIND v(dout2_27) AT=2380.1n

* CHECK dout2_28 Vdout2_28ck118 = 0 time = 2380
.meas tran vdout2_28ck118 FIND v(dout2_28) AT=2380.1n

* CHECK dout2_29 Vdout2_29ck118 = 0 time = 2380
.meas tran vdout2_29ck118 FIND v(dout2_29) AT=2380.1n

* CHECK dout2_30 Vdout2_30ck118 = 1.8 time = 2380
.meas tran vdout2_30ck118 FIND v(dout2_30) AT=2380.1n

* CHECK dout2_31 Vdout2_31ck118 = 1.8 time = 2380
.meas tran vdout2_31ck118 FIND v(dout2_31) AT=2380.1n

* CHECK dout1_0 Vdout1_0ck119 = 0 time = 2400
.meas tran vdout1_0ck119 FIND v(dout1_0) AT=2400.1n

* CHECK dout1_1 Vdout1_1ck119 = 1.8 time = 2400
.meas tran vdout1_1ck119 FIND v(dout1_1) AT=2400.1n

* CHECK dout1_2 Vdout1_2ck119 = 1.8 time = 2400
.meas tran vdout1_2ck119 FIND v(dout1_2) AT=2400.1n

* CHECK dout1_3 Vdout1_3ck119 = 0 time = 2400
.meas tran vdout1_3ck119 FIND v(dout1_3) AT=2400.1n

* CHECK dout1_4 Vdout1_4ck119 = 1.8 time = 2400
.meas tran vdout1_4ck119 FIND v(dout1_4) AT=2400.1n

* CHECK dout1_5 Vdout1_5ck119 = 0 time = 2400
.meas tran vdout1_5ck119 FIND v(dout1_5) AT=2400.1n

* CHECK dout1_6 Vdout1_6ck119 = 0 time = 2400
.meas tran vdout1_6ck119 FIND v(dout1_6) AT=2400.1n

* CHECK dout1_7 Vdout1_7ck119 = 0 time = 2400
.meas tran vdout1_7ck119 FIND v(dout1_7) AT=2400.1n

* CHECK dout1_8 Vdout1_8ck119 = 1.8 time = 2400
.meas tran vdout1_8ck119 FIND v(dout1_8) AT=2400.1n

* CHECK dout1_9 Vdout1_9ck119 = 1.8 time = 2400
.meas tran vdout1_9ck119 FIND v(dout1_9) AT=2400.1n

* CHECK dout1_10 Vdout1_10ck119 = 1.8 time = 2400
.meas tran vdout1_10ck119 FIND v(dout1_10) AT=2400.1n

* CHECK dout1_11 Vdout1_11ck119 = 1.8 time = 2400
.meas tran vdout1_11ck119 FIND v(dout1_11) AT=2400.1n

* CHECK dout1_12 Vdout1_12ck119 = 1.8 time = 2400
.meas tran vdout1_12ck119 FIND v(dout1_12) AT=2400.1n

* CHECK dout1_13 Vdout1_13ck119 = 1.8 time = 2400
.meas tran vdout1_13ck119 FIND v(dout1_13) AT=2400.1n

* CHECK dout1_14 Vdout1_14ck119 = 1.8 time = 2400
.meas tran vdout1_14ck119 FIND v(dout1_14) AT=2400.1n

* CHECK dout1_15 Vdout1_15ck119 = 0 time = 2400
.meas tran vdout1_15ck119 FIND v(dout1_15) AT=2400.1n

* CHECK dout1_16 Vdout1_16ck119 = 1.8 time = 2400
.meas tran vdout1_16ck119 FIND v(dout1_16) AT=2400.1n

* CHECK dout1_17 Vdout1_17ck119 = 1.8 time = 2400
.meas tran vdout1_17ck119 FIND v(dout1_17) AT=2400.1n

* CHECK dout1_18 Vdout1_18ck119 = 1.8 time = 2400
.meas tran vdout1_18ck119 FIND v(dout1_18) AT=2400.1n

* CHECK dout1_19 Vdout1_19ck119 = 1.8 time = 2400
.meas tran vdout1_19ck119 FIND v(dout1_19) AT=2400.1n

* CHECK dout1_20 Vdout1_20ck119 = 1.8 time = 2400
.meas tran vdout1_20ck119 FIND v(dout1_20) AT=2400.1n

* CHECK dout1_21 Vdout1_21ck119 = 1.8 time = 2400
.meas tran vdout1_21ck119 FIND v(dout1_21) AT=2400.1n

* CHECK dout1_22 Vdout1_22ck119 = 0 time = 2400
.meas tran vdout1_22ck119 FIND v(dout1_22) AT=2400.1n

* CHECK dout1_23 Vdout1_23ck119 = 0 time = 2400
.meas tran vdout1_23ck119 FIND v(dout1_23) AT=2400.1n

* CHECK dout1_24 Vdout1_24ck119 = 1.8 time = 2400
.meas tran vdout1_24ck119 FIND v(dout1_24) AT=2400.1n

* CHECK dout1_25 Vdout1_25ck119 = 1.8 time = 2400
.meas tran vdout1_25ck119 FIND v(dout1_25) AT=2400.1n

* CHECK dout1_26 Vdout1_26ck119 = 0 time = 2400
.meas tran vdout1_26ck119 FIND v(dout1_26) AT=2400.1n

* CHECK dout1_27 Vdout1_27ck119 = 1.8 time = 2400
.meas tran vdout1_27ck119 FIND v(dout1_27) AT=2400.1n

* CHECK dout1_28 Vdout1_28ck119 = 1.8 time = 2400
.meas tran vdout1_28ck119 FIND v(dout1_28) AT=2400.1n

* CHECK dout1_29 Vdout1_29ck119 = 1.8 time = 2400
.meas tran vdout1_29ck119 FIND v(dout1_29) AT=2400.1n

* CHECK dout1_30 Vdout1_30ck119 = 1.8 time = 2400
.meas tran vdout1_30ck119 FIND v(dout1_30) AT=2400.1n

* CHECK dout1_31 Vdout1_31ck119 = 0 time = 2400
.meas tran vdout1_31ck119 FIND v(dout1_31) AT=2400.1n

* CHECK dout2_0 Vdout2_0ck119 = 0 time = 2400
.meas tran vdout2_0ck119 FIND v(dout2_0) AT=2400.1n

* CHECK dout2_1 Vdout2_1ck119 = 1.8 time = 2400
.meas tran vdout2_1ck119 FIND v(dout2_1) AT=2400.1n

* CHECK dout2_2 Vdout2_2ck119 = 1.8 time = 2400
.meas tran vdout2_2ck119 FIND v(dout2_2) AT=2400.1n

* CHECK dout2_3 Vdout2_3ck119 = 0 time = 2400
.meas tran vdout2_3ck119 FIND v(dout2_3) AT=2400.1n

* CHECK dout2_4 Vdout2_4ck119 = 1.8 time = 2400
.meas tran vdout2_4ck119 FIND v(dout2_4) AT=2400.1n

* CHECK dout2_5 Vdout2_5ck119 = 0 time = 2400
.meas tran vdout2_5ck119 FIND v(dout2_5) AT=2400.1n

* CHECK dout2_6 Vdout2_6ck119 = 0 time = 2400
.meas tran vdout2_6ck119 FIND v(dout2_6) AT=2400.1n

* CHECK dout2_7 Vdout2_7ck119 = 0 time = 2400
.meas tran vdout2_7ck119 FIND v(dout2_7) AT=2400.1n

* CHECK dout2_8 Vdout2_8ck119 = 1.8 time = 2400
.meas tran vdout2_8ck119 FIND v(dout2_8) AT=2400.1n

* CHECK dout2_9 Vdout2_9ck119 = 1.8 time = 2400
.meas tran vdout2_9ck119 FIND v(dout2_9) AT=2400.1n

* CHECK dout2_10 Vdout2_10ck119 = 1.8 time = 2400
.meas tran vdout2_10ck119 FIND v(dout2_10) AT=2400.1n

* CHECK dout2_11 Vdout2_11ck119 = 1.8 time = 2400
.meas tran vdout2_11ck119 FIND v(dout2_11) AT=2400.1n

* CHECK dout2_12 Vdout2_12ck119 = 1.8 time = 2400
.meas tran vdout2_12ck119 FIND v(dout2_12) AT=2400.1n

* CHECK dout2_13 Vdout2_13ck119 = 1.8 time = 2400
.meas tran vdout2_13ck119 FIND v(dout2_13) AT=2400.1n

* CHECK dout2_14 Vdout2_14ck119 = 1.8 time = 2400
.meas tran vdout2_14ck119 FIND v(dout2_14) AT=2400.1n

* CHECK dout2_15 Vdout2_15ck119 = 0 time = 2400
.meas tran vdout2_15ck119 FIND v(dout2_15) AT=2400.1n

* CHECK dout2_16 Vdout2_16ck119 = 1.8 time = 2400
.meas tran vdout2_16ck119 FIND v(dout2_16) AT=2400.1n

* CHECK dout2_17 Vdout2_17ck119 = 1.8 time = 2400
.meas tran vdout2_17ck119 FIND v(dout2_17) AT=2400.1n

* CHECK dout2_18 Vdout2_18ck119 = 1.8 time = 2400
.meas tran vdout2_18ck119 FIND v(dout2_18) AT=2400.1n

* CHECK dout2_19 Vdout2_19ck119 = 1.8 time = 2400
.meas tran vdout2_19ck119 FIND v(dout2_19) AT=2400.1n

* CHECK dout2_20 Vdout2_20ck119 = 1.8 time = 2400
.meas tran vdout2_20ck119 FIND v(dout2_20) AT=2400.1n

* CHECK dout2_21 Vdout2_21ck119 = 1.8 time = 2400
.meas tran vdout2_21ck119 FIND v(dout2_21) AT=2400.1n

* CHECK dout2_22 Vdout2_22ck119 = 0 time = 2400
.meas tran vdout2_22ck119 FIND v(dout2_22) AT=2400.1n

* CHECK dout2_23 Vdout2_23ck119 = 0 time = 2400
.meas tran vdout2_23ck119 FIND v(dout2_23) AT=2400.1n

* CHECK dout2_24 Vdout2_24ck119 = 1.8 time = 2400
.meas tran vdout2_24ck119 FIND v(dout2_24) AT=2400.1n

* CHECK dout2_25 Vdout2_25ck119 = 1.8 time = 2400
.meas tran vdout2_25ck119 FIND v(dout2_25) AT=2400.1n

* CHECK dout2_26 Vdout2_26ck119 = 0 time = 2400
.meas tran vdout2_26ck119 FIND v(dout2_26) AT=2400.1n

* CHECK dout2_27 Vdout2_27ck119 = 1.8 time = 2400
.meas tran vdout2_27ck119 FIND v(dout2_27) AT=2400.1n

* CHECK dout2_28 Vdout2_28ck119 = 1.8 time = 2400
.meas tran vdout2_28ck119 FIND v(dout2_28) AT=2400.1n

* CHECK dout2_29 Vdout2_29ck119 = 1.8 time = 2400
.meas tran vdout2_29ck119 FIND v(dout2_29) AT=2400.1n

* CHECK dout2_30 Vdout2_30ck119 = 1.8 time = 2400
.meas tran vdout2_30ck119 FIND v(dout2_30) AT=2400.1n

* CHECK dout2_31 Vdout2_31ck119 = 0 time = 2400
.meas tran vdout2_31ck119 FIND v(dout2_31) AT=2400.1n

* CHECK dout1_0 Vdout1_0ck120 = 0 time = 2420
.meas tran vdout1_0ck120 FIND v(dout1_0) AT=2420.1n

* CHECK dout1_1 Vdout1_1ck120 = 1.8 time = 2420
.meas tran vdout1_1ck120 FIND v(dout1_1) AT=2420.1n

* CHECK dout1_2 Vdout1_2ck120 = 1.8 time = 2420
.meas tran vdout1_2ck120 FIND v(dout1_2) AT=2420.1n

* CHECK dout1_3 Vdout1_3ck120 = 1.8 time = 2420
.meas tran vdout1_3ck120 FIND v(dout1_3) AT=2420.1n

* CHECK dout1_4 Vdout1_4ck120 = 1.8 time = 2420
.meas tran vdout1_4ck120 FIND v(dout1_4) AT=2420.1n

* CHECK dout1_5 Vdout1_5ck120 = 1.8 time = 2420
.meas tran vdout1_5ck120 FIND v(dout1_5) AT=2420.1n

* CHECK dout1_6 Vdout1_6ck120 = 0 time = 2420
.meas tran vdout1_6ck120 FIND v(dout1_6) AT=2420.1n

* CHECK dout1_7 Vdout1_7ck120 = 1.8 time = 2420
.meas tran vdout1_7ck120 FIND v(dout1_7) AT=2420.1n

* CHECK dout1_8 Vdout1_8ck120 = 1.8 time = 2420
.meas tran vdout1_8ck120 FIND v(dout1_8) AT=2420.1n

* CHECK dout1_9 Vdout1_9ck120 = 0 time = 2420
.meas tran vdout1_9ck120 FIND v(dout1_9) AT=2420.1n

* CHECK dout1_10 Vdout1_10ck120 = 0 time = 2420
.meas tran vdout1_10ck120 FIND v(dout1_10) AT=2420.1n

* CHECK dout1_11 Vdout1_11ck120 = 1.8 time = 2420
.meas tran vdout1_11ck120 FIND v(dout1_11) AT=2420.1n

* CHECK dout1_12 Vdout1_12ck120 = 0 time = 2420
.meas tran vdout1_12ck120 FIND v(dout1_12) AT=2420.1n

* CHECK dout1_13 Vdout1_13ck120 = 0 time = 2420
.meas tran vdout1_13ck120 FIND v(dout1_13) AT=2420.1n

* CHECK dout1_14 Vdout1_14ck120 = 0 time = 2420
.meas tran vdout1_14ck120 FIND v(dout1_14) AT=2420.1n

* CHECK dout1_15 Vdout1_15ck120 = 0 time = 2420
.meas tran vdout1_15ck120 FIND v(dout1_15) AT=2420.1n

* CHECK dout1_16 Vdout1_16ck120 = 0 time = 2420
.meas tran vdout1_16ck120 FIND v(dout1_16) AT=2420.1n

* CHECK dout1_17 Vdout1_17ck120 = 1.8 time = 2420
.meas tran vdout1_17ck120 FIND v(dout1_17) AT=2420.1n

* CHECK dout1_18 Vdout1_18ck120 = 1.8 time = 2420
.meas tran vdout1_18ck120 FIND v(dout1_18) AT=2420.1n

* CHECK dout1_19 Vdout1_19ck120 = 0 time = 2420
.meas tran vdout1_19ck120 FIND v(dout1_19) AT=2420.1n

* CHECK dout1_20 Vdout1_20ck120 = 1.8 time = 2420
.meas tran vdout1_20ck120 FIND v(dout1_20) AT=2420.1n

* CHECK dout1_21 Vdout1_21ck120 = 0 time = 2420
.meas tran vdout1_21ck120 FIND v(dout1_21) AT=2420.1n

* CHECK dout1_22 Vdout1_22ck120 = 1.8 time = 2420
.meas tran vdout1_22ck120 FIND v(dout1_22) AT=2420.1n

* CHECK dout1_23 Vdout1_23ck120 = 0 time = 2420
.meas tran vdout1_23ck120 FIND v(dout1_23) AT=2420.1n

* CHECK dout1_24 Vdout1_24ck120 = 1.8 time = 2420
.meas tran vdout1_24ck120 FIND v(dout1_24) AT=2420.1n

* CHECK dout1_25 Vdout1_25ck120 = 1.8 time = 2420
.meas tran vdout1_25ck120 FIND v(dout1_25) AT=2420.1n

* CHECK dout1_26 Vdout1_26ck120 = 0 time = 2420
.meas tran vdout1_26ck120 FIND v(dout1_26) AT=2420.1n

* CHECK dout1_27 Vdout1_27ck120 = 1.8 time = 2420
.meas tran vdout1_27ck120 FIND v(dout1_27) AT=2420.1n

* CHECK dout1_28 Vdout1_28ck120 = 0 time = 2420
.meas tran vdout1_28ck120 FIND v(dout1_28) AT=2420.1n

* CHECK dout1_29 Vdout1_29ck120 = 0 time = 2420
.meas tran vdout1_29ck120 FIND v(dout1_29) AT=2420.1n

* CHECK dout1_30 Vdout1_30ck120 = 1.8 time = 2420
.meas tran vdout1_30ck120 FIND v(dout1_30) AT=2420.1n

* CHECK dout1_31 Vdout1_31ck120 = 1.8 time = 2420
.meas tran vdout1_31ck120 FIND v(dout1_31) AT=2420.1n

* CHECK dout1_0 Vdout1_0ck122 = 0 time = 2460
.meas tran vdout1_0ck122 FIND v(dout1_0) AT=2460.1n

* CHECK dout1_1 Vdout1_1ck122 = 1.8 time = 2460
.meas tran vdout1_1ck122 FIND v(dout1_1) AT=2460.1n

* CHECK dout1_2 Vdout1_2ck122 = 1.8 time = 2460
.meas tran vdout1_2ck122 FIND v(dout1_2) AT=2460.1n

* CHECK dout1_3 Vdout1_3ck122 = 1.8 time = 2460
.meas tran vdout1_3ck122 FIND v(dout1_3) AT=2460.1n

* CHECK dout1_4 Vdout1_4ck122 = 1.8 time = 2460
.meas tran vdout1_4ck122 FIND v(dout1_4) AT=2460.1n

* CHECK dout1_5 Vdout1_5ck122 = 1.8 time = 2460
.meas tran vdout1_5ck122 FIND v(dout1_5) AT=2460.1n

* CHECK dout1_6 Vdout1_6ck122 = 0 time = 2460
.meas tran vdout1_6ck122 FIND v(dout1_6) AT=2460.1n

* CHECK dout1_7 Vdout1_7ck122 = 1.8 time = 2460
.meas tran vdout1_7ck122 FIND v(dout1_7) AT=2460.1n

* CHECK dout1_8 Vdout1_8ck122 = 1.8 time = 2460
.meas tran vdout1_8ck122 FIND v(dout1_8) AT=2460.1n

* CHECK dout1_9 Vdout1_9ck122 = 0 time = 2460
.meas tran vdout1_9ck122 FIND v(dout1_9) AT=2460.1n

* CHECK dout1_10 Vdout1_10ck122 = 0 time = 2460
.meas tran vdout1_10ck122 FIND v(dout1_10) AT=2460.1n

* CHECK dout1_11 Vdout1_11ck122 = 1.8 time = 2460
.meas tran vdout1_11ck122 FIND v(dout1_11) AT=2460.1n

* CHECK dout1_12 Vdout1_12ck122 = 0 time = 2460
.meas tran vdout1_12ck122 FIND v(dout1_12) AT=2460.1n

* CHECK dout1_13 Vdout1_13ck122 = 0 time = 2460
.meas tran vdout1_13ck122 FIND v(dout1_13) AT=2460.1n

* CHECK dout1_14 Vdout1_14ck122 = 0 time = 2460
.meas tran vdout1_14ck122 FIND v(dout1_14) AT=2460.1n

* CHECK dout1_15 Vdout1_15ck122 = 0 time = 2460
.meas tran vdout1_15ck122 FIND v(dout1_15) AT=2460.1n

* CHECK dout1_16 Vdout1_16ck122 = 0 time = 2460
.meas tran vdout1_16ck122 FIND v(dout1_16) AT=2460.1n

* CHECK dout1_17 Vdout1_17ck122 = 1.8 time = 2460
.meas tran vdout1_17ck122 FIND v(dout1_17) AT=2460.1n

* CHECK dout1_18 Vdout1_18ck122 = 1.8 time = 2460
.meas tran vdout1_18ck122 FIND v(dout1_18) AT=2460.1n

* CHECK dout1_19 Vdout1_19ck122 = 0 time = 2460
.meas tran vdout1_19ck122 FIND v(dout1_19) AT=2460.1n

* CHECK dout1_20 Vdout1_20ck122 = 1.8 time = 2460
.meas tran vdout1_20ck122 FIND v(dout1_20) AT=2460.1n

* CHECK dout1_21 Vdout1_21ck122 = 0 time = 2460
.meas tran vdout1_21ck122 FIND v(dout1_21) AT=2460.1n

* CHECK dout1_22 Vdout1_22ck122 = 1.8 time = 2460
.meas tran vdout1_22ck122 FIND v(dout1_22) AT=2460.1n

* CHECK dout1_23 Vdout1_23ck122 = 0 time = 2460
.meas tran vdout1_23ck122 FIND v(dout1_23) AT=2460.1n

* CHECK dout1_24 Vdout1_24ck122 = 1.8 time = 2460
.meas tran vdout1_24ck122 FIND v(dout1_24) AT=2460.1n

* CHECK dout1_25 Vdout1_25ck122 = 1.8 time = 2460
.meas tran vdout1_25ck122 FIND v(dout1_25) AT=2460.1n

* CHECK dout1_26 Vdout1_26ck122 = 0 time = 2460
.meas tran vdout1_26ck122 FIND v(dout1_26) AT=2460.1n

* CHECK dout1_27 Vdout1_27ck122 = 1.8 time = 2460
.meas tran vdout1_27ck122 FIND v(dout1_27) AT=2460.1n

* CHECK dout1_28 Vdout1_28ck122 = 0 time = 2460
.meas tran vdout1_28ck122 FIND v(dout1_28) AT=2460.1n

* CHECK dout1_29 Vdout1_29ck122 = 0 time = 2460
.meas tran vdout1_29ck122 FIND v(dout1_29) AT=2460.1n

* CHECK dout1_30 Vdout1_30ck122 = 1.8 time = 2460
.meas tran vdout1_30ck122 FIND v(dout1_30) AT=2460.1n

* CHECK dout1_31 Vdout1_31ck122 = 1.8 time = 2460
.meas tran vdout1_31ck122 FIND v(dout1_31) AT=2460.1n

* CHECK dout2_0 Vdout2_0ck122 = 0 time = 2460
.meas tran vdout2_0ck122 FIND v(dout2_0) AT=2460.1n

* CHECK dout2_1 Vdout2_1ck122 = 1.8 time = 2460
.meas tran vdout2_1ck122 FIND v(dout2_1) AT=2460.1n

* CHECK dout2_2 Vdout2_2ck122 = 1.8 time = 2460
.meas tran vdout2_2ck122 FIND v(dout2_2) AT=2460.1n

* CHECK dout2_3 Vdout2_3ck122 = 1.8 time = 2460
.meas tran vdout2_3ck122 FIND v(dout2_3) AT=2460.1n

* CHECK dout2_4 Vdout2_4ck122 = 1.8 time = 2460
.meas tran vdout2_4ck122 FIND v(dout2_4) AT=2460.1n

* CHECK dout2_5 Vdout2_5ck122 = 1.8 time = 2460
.meas tran vdout2_5ck122 FIND v(dout2_5) AT=2460.1n

* CHECK dout2_6 Vdout2_6ck122 = 0 time = 2460
.meas tran vdout2_6ck122 FIND v(dout2_6) AT=2460.1n

* CHECK dout2_7 Vdout2_7ck122 = 1.8 time = 2460
.meas tran vdout2_7ck122 FIND v(dout2_7) AT=2460.1n

* CHECK dout2_8 Vdout2_8ck122 = 1.8 time = 2460
.meas tran vdout2_8ck122 FIND v(dout2_8) AT=2460.1n

* CHECK dout2_9 Vdout2_9ck122 = 0 time = 2460
.meas tran vdout2_9ck122 FIND v(dout2_9) AT=2460.1n

* CHECK dout2_10 Vdout2_10ck122 = 0 time = 2460
.meas tran vdout2_10ck122 FIND v(dout2_10) AT=2460.1n

* CHECK dout2_11 Vdout2_11ck122 = 1.8 time = 2460
.meas tran vdout2_11ck122 FIND v(dout2_11) AT=2460.1n

* CHECK dout2_12 Vdout2_12ck122 = 0 time = 2460
.meas tran vdout2_12ck122 FIND v(dout2_12) AT=2460.1n

* CHECK dout2_13 Vdout2_13ck122 = 0 time = 2460
.meas tran vdout2_13ck122 FIND v(dout2_13) AT=2460.1n

* CHECK dout2_14 Vdout2_14ck122 = 0 time = 2460
.meas tran vdout2_14ck122 FIND v(dout2_14) AT=2460.1n

* CHECK dout2_15 Vdout2_15ck122 = 0 time = 2460
.meas tran vdout2_15ck122 FIND v(dout2_15) AT=2460.1n

* CHECK dout2_16 Vdout2_16ck122 = 0 time = 2460
.meas tran vdout2_16ck122 FIND v(dout2_16) AT=2460.1n

* CHECK dout2_17 Vdout2_17ck122 = 1.8 time = 2460
.meas tran vdout2_17ck122 FIND v(dout2_17) AT=2460.1n

* CHECK dout2_18 Vdout2_18ck122 = 1.8 time = 2460
.meas tran vdout2_18ck122 FIND v(dout2_18) AT=2460.1n

* CHECK dout2_19 Vdout2_19ck122 = 0 time = 2460
.meas tran vdout2_19ck122 FIND v(dout2_19) AT=2460.1n

* CHECK dout2_20 Vdout2_20ck122 = 1.8 time = 2460
.meas tran vdout2_20ck122 FIND v(dout2_20) AT=2460.1n

* CHECK dout2_21 Vdout2_21ck122 = 0 time = 2460
.meas tran vdout2_21ck122 FIND v(dout2_21) AT=2460.1n

* CHECK dout2_22 Vdout2_22ck122 = 1.8 time = 2460
.meas tran vdout2_22ck122 FIND v(dout2_22) AT=2460.1n

* CHECK dout2_23 Vdout2_23ck122 = 0 time = 2460
.meas tran vdout2_23ck122 FIND v(dout2_23) AT=2460.1n

* CHECK dout2_24 Vdout2_24ck122 = 1.8 time = 2460
.meas tran vdout2_24ck122 FIND v(dout2_24) AT=2460.1n

* CHECK dout2_25 Vdout2_25ck122 = 1.8 time = 2460
.meas tran vdout2_25ck122 FIND v(dout2_25) AT=2460.1n

* CHECK dout2_26 Vdout2_26ck122 = 0 time = 2460
.meas tran vdout2_26ck122 FIND v(dout2_26) AT=2460.1n

* CHECK dout2_27 Vdout2_27ck122 = 1.8 time = 2460
.meas tran vdout2_27ck122 FIND v(dout2_27) AT=2460.1n

* CHECK dout2_28 Vdout2_28ck122 = 0 time = 2460
.meas tran vdout2_28ck122 FIND v(dout2_28) AT=2460.1n

* CHECK dout2_29 Vdout2_29ck122 = 0 time = 2460
.meas tran vdout2_29ck122 FIND v(dout2_29) AT=2460.1n

* CHECK dout2_30 Vdout2_30ck122 = 1.8 time = 2460
.meas tran vdout2_30ck122 FIND v(dout2_30) AT=2460.1n

* CHECK dout2_31 Vdout2_31ck122 = 1.8 time = 2460
.meas tran vdout2_31ck122 FIND v(dout2_31) AT=2460.1n

* CHECK dout1_0 Vdout1_0ck123 = 1.8 time = 2480
.meas tran vdout1_0ck123 FIND v(dout1_0) AT=2480.1n

* CHECK dout1_1 Vdout1_1ck123 = 1.8 time = 2480
.meas tran vdout1_1ck123 FIND v(dout1_1) AT=2480.1n

* CHECK dout1_2 Vdout1_2ck123 = 1.8 time = 2480
.meas tran vdout1_2ck123 FIND v(dout1_2) AT=2480.1n

* CHECK dout1_3 Vdout1_3ck123 = 1.8 time = 2480
.meas tran vdout1_3ck123 FIND v(dout1_3) AT=2480.1n

* CHECK dout1_4 Vdout1_4ck123 = 1.8 time = 2480
.meas tran vdout1_4ck123 FIND v(dout1_4) AT=2480.1n

* CHECK dout1_5 Vdout1_5ck123 = 0 time = 2480
.meas tran vdout1_5ck123 FIND v(dout1_5) AT=2480.1n

* CHECK dout1_6 Vdout1_6ck123 = 0 time = 2480
.meas tran vdout1_6ck123 FIND v(dout1_6) AT=2480.1n

* CHECK dout1_7 Vdout1_7ck123 = 0 time = 2480
.meas tran vdout1_7ck123 FIND v(dout1_7) AT=2480.1n

* CHECK dout1_8 Vdout1_8ck123 = 0 time = 2480
.meas tran vdout1_8ck123 FIND v(dout1_8) AT=2480.1n

* CHECK dout1_9 Vdout1_9ck123 = 0 time = 2480
.meas tran vdout1_9ck123 FIND v(dout1_9) AT=2480.1n

* CHECK dout1_10 Vdout1_10ck123 = 0 time = 2480
.meas tran vdout1_10ck123 FIND v(dout1_10) AT=2480.1n

* CHECK dout1_11 Vdout1_11ck123 = 1.8 time = 2480
.meas tran vdout1_11ck123 FIND v(dout1_11) AT=2480.1n

* CHECK dout1_12 Vdout1_12ck123 = 0 time = 2480
.meas tran vdout1_12ck123 FIND v(dout1_12) AT=2480.1n

* CHECK dout1_13 Vdout1_13ck123 = 0 time = 2480
.meas tran vdout1_13ck123 FIND v(dout1_13) AT=2480.1n

* CHECK dout1_14 Vdout1_14ck123 = 0 time = 2480
.meas tran vdout1_14ck123 FIND v(dout1_14) AT=2480.1n

* CHECK dout1_15 Vdout1_15ck123 = 1.8 time = 2480
.meas tran vdout1_15ck123 FIND v(dout1_15) AT=2480.1n

* CHECK dout1_16 Vdout1_16ck123 = 0 time = 2480
.meas tran vdout1_16ck123 FIND v(dout1_16) AT=2480.1n

* CHECK dout1_17 Vdout1_17ck123 = 0 time = 2480
.meas tran vdout1_17ck123 FIND v(dout1_17) AT=2480.1n

* CHECK dout1_18 Vdout1_18ck123 = 1.8 time = 2480
.meas tran vdout1_18ck123 FIND v(dout1_18) AT=2480.1n

* CHECK dout1_19 Vdout1_19ck123 = 0 time = 2480
.meas tran vdout1_19ck123 FIND v(dout1_19) AT=2480.1n

* CHECK dout1_20 Vdout1_20ck123 = 1.8 time = 2480
.meas tran vdout1_20ck123 FIND v(dout1_20) AT=2480.1n

* CHECK dout1_21 Vdout1_21ck123 = 0 time = 2480
.meas tran vdout1_21ck123 FIND v(dout1_21) AT=2480.1n

* CHECK dout1_22 Vdout1_22ck123 = 1.8 time = 2480
.meas tran vdout1_22ck123 FIND v(dout1_22) AT=2480.1n

* CHECK dout1_23 Vdout1_23ck123 = 0 time = 2480
.meas tran vdout1_23ck123 FIND v(dout1_23) AT=2480.1n

* CHECK dout1_24 Vdout1_24ck123 = 0 time = 2480
.meas tran vdout1_24ck123 FIND v(dout1_24) AT=2480.1n

* CHECK dout1_25 Vdout1_25ck123 = 1.8 time = 2480
.meas tran vdout1_25ck123 FIND v(dout1_25) AT=2480.1n

* CHECK dout1_26 Vdout1_26ck123 = 0 time = 2480
.meas tran vdout1_26ck123 FIND v(dout1_26) AT=2480.1n

* CHECK dout1_27 Vdout1_27ck123 = 0 time = 2480
.meas tran vdout1_27ck123 FIND v(dout1_27) AT=2480.1n

* CHECK dout1_28 Vdout1_28ck123 = 1.8 time = 2480
.meas tran vdout1_28ck123 FIND v(dout1_28) AT=2480.1n

* CHECK dout1_29 Vdout1_29ck123 = 0 time = 2480
.meas tran vdout1_29ck123 FIND v(dout1_29) AT=2480.1n

* CHECK dout1_30 Vdout1_30ck123 = 1.8 time = 2480
.meas tran vdout1_30ck123 FIND v(dout1_30) AT=2480.1n

* CHECK dout1_31 Vdout1_31ck123 = 1.8 time = 2480
.meas tran vdout1_31ck123 FIND v(dout1_31) AT=2480.1n

* CHECK dout2_0 Vdout2_0ck123 = 0 time = 2480
.meas tran vdout2_0ck123 FIND v(dout2_0) AT=2480.1n

* CHECK dout2_1 Vdout2_1ck123 = 0 time = 2480
.meas tran vdout2_1ck123 FIND v(dout2_1) AT=2480.1n

* CHECK dout2_2 Vdout2_2ck123 = 1.8 time = 2480
.meas tran vdout2_2ck123 FIND v(dout2_2) AT=2480.1n

* CHECK dout2_3 Vdout2_3ck123 = 0 time = 2480
.meas tran vdout2_3ck123 FIND v(dout2_3) AT=2480.1n

* CHECK dout2_4 Vdout2_4ck123 = 1.8 time = 2480
.meas tran vdout2_4ck123 FIND v(dout2_4) AT=2480.1n

* CHECK dout2_5 Vdout2_5ck123 = 1.8 time = 2480
.meas tran vdout2_5ck123 FIND v(dout2_5) AT=2480.1n

* CHECK dout2_6 Vdout2_6ck123 = 0 time = 2480
.meas tran vdout2_6ck123 FIND v(dout2_6) AT=2480.1n

* CHECK dout2_7 Vdout2_7ck123 = 1.8 time = 2480
.meas tran vdout2_7ck123 FIND v(dout2_7) AT=2480.1n

* CHECK dout2_8 Vdout2_8ck123 = 1.8 time = 2480
.meas tran vdout2_8ck123 FIND v(dout2_8) AT=2480.1n

* CHECK dout2_9 Vdout2_9ck123 = 1.8 time = 2480
.meas tran vdout2_9ck123 FIND v(dout2_9) AT=2480.1n

* CHECK dout2_10 Vdout2_10ck123 = 0 time = 2480
.meas tran vdout2_10ck123 FIND v(dout2_10) AT=2480.1n

* CHECK dout2_11 Vdout2_11ck123 = 1.8 time = 2480
.meas tran vdout2_11ck123 FIND v(dout2_11) AT=2480.1n

* CHECK dout2_12 Vdout2_12ck123 = 0 time = 2480
.meas tran vdout2_12ck123 FIND v(dout2_12) AT=2480.1n

* CHECK dout2_13 Vdout2_13ck123 = 0 time = 2480
.meas tran vdout2_13ck123 FIND v(dout2_13) AT=2480.1n

* CHECK dout2_14 Vdout2_14ck123 = 1.8 time = 2480
.meas tran vdout2_14ck123 FIND v(dout2_14) AT=2480.1n

* CHECK dout2_15 Vdout2_15ck123 = 0 time = 2480
.meas tran vdout2_15ck123 FIND v(dout2_15) AT=2480.1n

* CHECK dout2_16 Vdout2_16ck123 = 1.8 time = 2480
.meas tran vdout2_16ck123 FIND v(dout2_16) AT=2480.1n

* CHECK dout2_17 Vdout2_17ck123 = 0 time = 2480
.meas tran vdout2_17ck123 FIND v(dout2_17) AT=2480.1n

* CHECK dout2_18 Vdout2_18ck123 = 0 time = 2480
.meas tran vdout2_18ck123 FIND v(dout2_18) AT=2480.1n

* CHECK dout2_19 Vdout2_19ck123 = 1.8 time = 2480
.meas tran vdout2_19ck123 FIND v(dout2_19) AT=2480.1n

* CHECK dout2_20 Vdout2_20ck123 = 1.8 time = 2480
.meas tran vdout2_20ck123 FIND v(dout2_20) AT=2480.1n

* CHECK dout2_21 Vdout2_21ck123 = 0 time = 2480
.meas tran vdout2_21ck123 FIND v(dout2_21) AT=2480.1n

* CHECK dout2_22 Vdout2_22ck123 = 1.8 time = 2480
.meas tran vdout2_22ck123 FIND v(dout2_22) AT=2480.1n

* CHECK dout2_23 Vdout2_23ck123 = 1.8 time = 2480
.meas tran vdout2_23ck123 FIND v(dout2_23) AT=2480.1n

* CHECK dout2_24 Vdout2_24ck123 = 0 time = 2480
.meas tran vdout2_24ck123 FIND v(dout2_24) AT=2480.1n

* CHECK dout2_25 Vdout2_25ck123 = 0 time = 2480
.meas tran vdout2_25ck123 FIND v(dout2_25) AT=2480.1n

* CHECK dout2_26 Vdout2_26ck123 = 0 time = 2480
.meas tran vdout2_26ck123 FIND v(dout2_26) AT=2480.1n

* CHECK dout2_27 Vdout2_27ck123 = 1.8 time = 2480
.meas tran vdout2_27ck123 FIND v(dout2_27) AT=2480.1n

* CHECK dout2_28 Vdout2_28ck123 = 0 time = 2480
.meas tran vdout2_28ck123 FIND v(dout2_28) AT=2480.1n

* CHECK dout2_29 Vdout2_29ck123 = 0 time = 2480
.meas tran vdout2_29ck123 FIND v(dout2_29) AT=2480.1n

* CHECK dout2_30 Vdout2_30ck123 = 1.8 time = 2480
.meas tran vdout2_30ck123 FIND v(dout2_30) AT=2480.1n

* CHECK dout2_31 Vdout2_31ck123 = 0 time = 2480
.meas tran vdout2_31ck123 FIND v(dout2_31) AT=2480.1n

* CHECK dout1_0 Vdout1_0ck124 = 1.8 time = 2500
.meas tran vdout1_0ck124 FIND v(dout1_0) AT=2500.1n

* CHECK dout1_1 Vdout1_1ck124 = 1.8 time = 2500
.meas tran vdout1_1ck124 FIND v(dout1_1) AT=2500.1n

* CHECK dout1_2 Vdout1_2ck124 = 0 time = 2500
.meas tran vdout1_2ck124 FIND v(dout1_2) AT=2500.1n

* CHECK dout1_3 Vdout1_3ck124 = 0 time = 2500
.meas tran vdout1_3ck124 FIND v(dout1_3) AT=2500.1n

* CHECK dout1_4 Vdout1_4ck124 = 1.8 time = 2500
.meas tran vdout1_4ck124 FIND v(dout1_4) AT=2500.1n

* CHECK dout1_5 Vdout1_5ck124 = 1.8 time = 2500
.meas tran vdout1_5ck124 FIND v(dout1_5) AT=2500.1n

* CHECK dout1_6 Vdout1_6ck124 = 1.8 time = 2500
.meas tran vdout1_6ck124 FIND v(dout1_6) AT=2500.1n

* CHECK dout1_7 Vdout1_7ck124 = 0 time = 2500
.meas tran vdout1_7ck124 FIND v(dout1_7) AT=2500.1n

* CHECK dout1_8 Vdout1_8ck124 = 0 time = 2500
.meas tran vdout1_8ck124 FIND v(dout1_8) AT=2500.1n

* CHECK dout1_9 Vdout1_9ck124 = 1.8 time = 2500
.meas tran vdout1_9ck124 FIND v(dout1_9) AT=2500.1n

* CHECK dout1_10 Vdout1_10ck124 = 1.8 time = 2500
.meas tran vdout1_10ck124 FIND v(dout1_10) AT=2500.1n

* CHECK dout1_11 Vdout1_11ck124 = 1.8 time = 2500
.meas tran vdout1_11ck124 FIND v(dout1_11) AT=2500.1n

* CHECK dout1_12 Vdout1_12ck124 = 0 time = 2500
.meas tran vdout1_12ck124 FIND v(dout1_12) AT=2500.1n

* CHECK dout1_13 Vdout1_13ck124 = 1.8 time = 2500
.meas tran vdout1_13ck124 FIND v(dout1_13) AT=2500.1n

* CHECK dout1_14 Vdout1_14ck124 = 0 time = 2500
.meas tran vdout1_14ck124 FIND v(dout1_14) AT=2500.1n

* CHECK dout1_15 Vdout1_15ck124 = 0 time = 2500
.meas tran vdout1_15ck124 FIND v(dout1_15) AT=2500.1n

* CHECK dout1_16 Vdout1_16ck124 = 1.8 time = 2500
.meas tran vdout1_16ck124 FIND v(dout1_16) AT=2500.1n

* CHECK dout1_17 Vdout1_17ck124 = 0 time = 2500
.meas tran vdout1_17ck124 FIND v(dout1_17) AT=2500.1n

* CHECK dout1_18 Vdout1_18ck124 = 1.8 time = 2500
.meas tran vdout1_18ck124 FIND v(dout1_18) AT=2500.1n

* CHECK dout1_19 Vdout1_19ck124 = 1.8 time = 2500
.meas tran vdout1_19ck124 FIND v(dout1_19) AT=2500.1n

* CHECK dout1_20 Vdout1_20ck124 = 1.8 time = 2500
.meas tran vdout1_20ck124 FIND v(dout1_20) AT=2500.1n

* CHECK dout1_21 Vdout1_21ck124 = 0 time = 2500
.meas tran vdout1_21ck124 FIND v(dout1_21) AT=2500.1n

* CHECK dout1_22 Vdout1_22ck124 = 0 time = 2500
.meas tran vdout1_22ck124 FIND v(dout1_22) AT=2500.1n

* CHECK dout1_23 Vdout1_23ck124 = 0 time = 2500
.meas tran vdout1_23ck124 FIND v(dout1_23) AT=2500.1n

* CHECK dout1_24 Vdout1_24ck124 = 1.8 time = 2500
.meas tran vdout1_24ck124 FIND v(dout1_24) AT=2500.1n

* CHECK dout1_25 Vdout1_25ck124 = 1.8 time = 2500
.meas tran vdout1_25ck124 FIND v(dout1_25) AT=2500.1n

* CHECK dout1_26 Vdout1_26ck124 = 1.8 time = 2500
.meas tran vdout1_26ck124 FIND v(dout1_26) AT=2500.1n

* CHECK dout1_27 Vdout1_27ck124 = 1.8 time = 2500
.meas tran vdout1_27ck124 FIND v(dout1_27) AT=2500.1n

* CHECK dout1_28 Vdout1_28ck124 = 1.8 time = 2500
.meas tran vdout1_28ck124 FIND v(dout1_28) AT=2500.1n

* CHECK dout1_29 Vdout1_29ck124 = 1.8 time = 2500
.meas tran vdout1_29ck124 FIND v(dout1_29) AT=2500.1n

* CHECK dout1_30 Vdout1_30ck124 = 1.8 time = 2500
.meas tran vdout1_30ck124 FIND v(dout1_30) AT=2500.1n

* CHECK dout1_31 Vdout1_31ck124 = 1.8 time = 2500
.meas tran vdout1_31ck124 FIND v(dout1_31) AT=2500.1n

* CHECK dout2_0 Vdout2_0ck124 = 0 time = 2500
.meas tran vdout2_0ck124 FIND v(dout2_0) AT=2500.1n

* CHECK dout2_1 Vdout2_1ck124 = 0 time = 2500
.meas tran vdout2_1ck124 FIND v(dout2_1) AT=2500.1n

* CHECK dout2_2 Vdout2_2ck124 = 1.8 time = 2500
.meas tran vdout2_2ck124 FIND v(dout2_2) AT=2500.1n

* CHECK dout2_3 Vdout2_3ck124 = 0 time = 2500
.meas tran vdout2_3ck124 FIND v(dout2_3) AT=2500.1n

* CHECK dout2_4 Vdout2_4ck124 = 1.8 time = 2500
.meas tran vdout2_4ck124 FIND v(dout2_4) AT=2500.1n

* CHECK dout2_5 Vdout2_5ck124 = 1.8 time = 2500
.meas tran vdout2_5ck124 FIND v(dout2_5) AT=2500.1n

* CHECK dout2_6 Vdout2_6ck124 = 0 time = 2500
.meas tran vdout2_6ck124 FIND v(dout2_6) AT=2500.1n

* CHECK dout2_7 Vdout2_7ck124 = 1.8 time = 2500
.meas tran vdout2_7ck124 FIND v(dout2_7) AT=2500.1n

* CHECK dout2_8 Vdout2_8ck124 = 1.8 time = 2500
.meas tran vdout2_8ck124 FIND v(dout2_8) AT=2500.1n

* CHECK dout2_9 Vdout2_9ck124 = 1.8 time = 2500
.meas tran vdout2_9ck124 FIND v(dout2_9) AT=2500.1n

* CHECK dout2_10 Vdout2_10ck124 = 0 time = 2500
.meas tran vdout2_10ck124 FIND v(dout2_10) AT=2500.1n

* CHECK dout2_11 Vdout2_11ck124 = 1.8 time = 2500
.meas tran vdout2_11ck124 FIND v(dout2_11) AT=2500.1n

* CHECK dout2_12 Vdout2_12ck124 = 0 time = 2500
.meas tran vdout2_12ck124 FIND v(dout2_12) AT=2500.1n

* CHECK dout2_13 Vdout2_13ck124 = 0 time = 2500
.meas tran vdout2_13ck124 FIND v(dout2_13) AT=2500.1n

* CHECK dout2_14 Vdout2_14ck124 = 1.8 time = 2500
.meas tran vdout2_14ck124 FIND v(dout2_14) AT=2500.1n

* CHECK dout2_15 Vdout2_15ck124 = 0 time = 2500
.meas tran vdout2_15ck124 FIND v(dout2_15) AT=2500.1n

* CHECK dout2_16 Vdout2_16ck124 = 1.8 time = 2500
.meas tran vdout2_16ck124 FIND v(dout2_16) AT=2500.1n

* CHECK dout2_17 Vdout2_17ck124 = 0 time = 2500
.meas tran vdout2_17ck124 FIND v(dout2_17) AT=2500.1n

* CHECK dout2_18 Vdout2_18ck124 = 0 time = 2500
.meas tran vdout2_18ck124 FIND v(dout2_18) AT=2500.1n

* CHECK dout2_19 Vdout2_19ck124 = 1.8 time = 2500
.meas tran vdout2_19ck124 FIND v(dout2_19) AT=2500.1n

* CHECK dout2_20 Vdout2_20ck124 = 1.8 time = 2500
.meas tran vdout2_20ck124 FIND v(dout2_20) AT=2500.1n

* CHECK dout2_21 Vdout2_21ck124 = 0 time = 2500
.meas tran vdout2_21ck124 FIND v(dout2_21) AT=2500.1n

* CHECK dout2_22 Vdout2_22ck124 = 1.8 time = 2500
.meas tran vdout2_22ck124 FIND v(dout2_22) AT=2500.1n

* CHECK dout2_23 Vdout2_23ck124 = 1.8 time = 2500
.meas tran vdout2_23ck124 FIND v(dout2_23) AT=2500.1n

* CHECK dout2_24 Vdout2_24ck124 = 0 time = 2500
.meas tran vdout2_24ck124 FIND v(dout2_24) AT=2500.1n

* CHECK dout2_25 Vdout2_25ck124 = 0 time = 2500
.meas tran vdout2_25ck124 FIND v(dout2_25) AT=2500.1n

* CHECK dout2_26 Vdout2_26ck124 = 0 time = 2500
.meas tran vdout2_26ck124 FIND v(dout2_26) AT=2500.1n

* CHECK dout2_27 Vdout2_27ck124 = 1.8 time = 2500
.meas tran vdout2_27ck124 FIND v(dout2_27) AT=2500.1n

* CHECK dout2_28 Vdout2_28ck124 = 0 time = 2500
.meas tran vdout2_28ck124 FIND v(dout2_28) AT=2500.1n

* CHECK dout2_29 Vdout2_29ck124 = 0 time = 2500
.meas tran vdout2_29ck124 FIND v(dout2_29) AT=2500.1n

* CHECK dout2_30 Vdout2_30ck124 = 1.8 time = 2500
.meas tran vdout2_30ck124 FIND v(dout2_30) AT=2500.1n

* CHECK dout2_31 Vdout2_31ck124 = 0 time = 2500
.meas tran vdout2_31ck124 FIND v(dout2_31) AT=2500.1n

* CHECK dout1_0 Vdout1_0ck125 = 0 time = 2520
.meas tran vdout1_0ck125 FIND v(dout1_0) AT=2520.1n

* CHECK dout1_1 Vdout1_1ck125 = 0 time = 2520
.meas tran vdout1_1ck125 FIND v(dout1_1) AT=2520.1n

* CHECK dout1_2 Vdout1_2ck125 = 1.8 time = 2520
.meas tran vdout1_2ck125 FIND v(dout1_2) AT=2520.1n

* CHECK dout1_3 Vdout1_3ck125 = 0 time = 2520
.meas tran vdout1_3ck125 FIND v(dout1_3) AT=2520.1n

* CHECK dout1_4 Vdout1_4ck125 = 1.8 time = 2520
.meas tran vdout1_4ck125 FIND v(dout1_4) AT=2520.1n

* CHECK dout1_5 Vdout1_5ck125 = 1.8 time = 2520
.meas tran vdout1_5ck125 FIND v(dout1_5) AT=2520.1n

* CHECK dout1_6 Vdout1_6ck125 = 0 time = 2520
.meas tran vdout1_6ck125 FIND v(dout1_6) AT=2520.1n

* CHECK dout1_7 Vdout1_7ck125 = 1.8 time = 2520
.meas tran vdout1_7ck125 FIND v(dout1_7) AT=2520.1n

* CHECK dout1_8 Vdout1_8ck125 = 1.8 time = 2520
.meas tran vdout1_8ck125 FIND v(dout1_8) AT=2520.1n

* CHECK dout1_9 Vdout1_9ck125 = 1.8 time = 2520
.meas tran vdout1_9ck125 FIND v(dout1_9) AT=2520.1n

* CHECK dout1_10 Vdout1_10ck125 = 0 time = 2520
.meas tran vdout1_10ck125 FIND v(dout1_10) AT=2520.1n

* CHECK dout1_11 Vdout1_11ck125 = 1.8 time = 2520
.meas tran vdout1_11ck125 FIND v(dout1_11) AT=2520.1n

* CHECK dout1_12 Vdout1_12ck125 = 0 time = 2520
.meas tran vdout1_12ck125 FIND v(dout1_12) AT=2520.1n

* CHECK dout1_13 Vdout1_13ck125 = 0 time = 2520
.meas tran vdout1_13ck125 FIND v(dout1_13) AT=2520.1n

* CHECK dout1_14 Vdout1_14ck125 = 1.8 time = 2520
.meas tran vdout1_14ck125 FIND v(dout1_14) AT=2520.1n

* CHECK dout1_15 Vdout1_15ck125 = 0 time = 2520
.meas tran vdout1_15ck125 FIND v(dout1_15) AT=2520.1n

* CHECK dout1_16 Vdout1_16ck125 = 1.8 time = 2520
.meas tran vdout1_16ck125 FIND v(dout1_16) AT=2520.1n

* CHECK dout1_17 Vdout1_17ck125 = 0 time = 2520
.meas tran vdout1_17ck125 FIND v(dout1_17) AT=2520.1n

* CHECK dout1_18 Vdout1_18ck125 = 0 time = 2520
.meas tran vdout1_18ck125 FIND v(dout1_18) AT=2520.1n

* CHECK dout1_19 Vdout1_19ck125 = 1.8 time = 2520
.meas tran vdout1_19ck125 FIND v(dout1_19) AT=2520.1n

* CHECK dout1_20 Vdout1_20ck125 = 1.8 time = 2520
.meas tran vdout1_20ck125 FIND v(dout1_20) AT=2520.1n

* CHECK dout1_21 Vdout1_21ck125 = 0 time = 2520
.meas tran vdout1_21ck125 FIND v(dout1_21) AT=2520.1n

* CHECK dout1_22 Vdout1_22ck125 = 1.8 time = 2520
.meas tran vdout1_22ck125 FIND v(dout1_22) AT=2520.1n

* CHECK dout1_23 Vdout1_23ck125 = 1.8 time = 2520
.meas tran vdout1_23ck125 FIND v(dout1_23) AT=2520.1n

* CHECK dout1_24 Vdout1_24ck125 = 0 time = 2520
.meas tran vdout1_24ck125 FIND v(dout1_24) AT=2520.1n

* CHECK dout1_25 Vdout1_25ck125 = 0 time = 2520
.meas tran vdout1_25ck125 FIND v(dout1_25) AT=2520.1n

* CHECK dout1_26 Vdout1_26ck125 = 0 time = 2520
.meas tran vdout1_26ck125 FIND v(dout1_26) AT=2520.1n

* CHECK dout1_27 Vdout1_27ck125 = 1.8 time = 2520
.meas tran vdout1_27ck125 FIND v(dout1_27) AT=2520.1n

* CHECK dout1_28 Vdout1_28ck125 = 0 time = 2520
.meas tran vdout1_28ck125 FIND v(dout1_28) AT=2520.1n

* CHECK dout1_29 Vdout1_29ck125 = 0 time = 2520
.meas tran vdout1_29ck125 FIND v(dout1_29) AT=2520.1n

* CHECK dout1_30 Vdout1_30ck125 = 1.8 time = 2520
.meas tran vdout1_30ck125 FIND v(dout1_30) AT=2520.1n

* CHECK dout1_31 Vdout1_31ck125 = 0 time = 2520
.meas tran vdout1_31ck125 FIND v(dout1_31) AT=2520.1n

* CHECK dout2_0 Vdout2_0ck125 = 1.8 time = 2520
.meas tran vdout2_0ck125 FIND v(dout2_0) AT=2520.1n

* CHECK dout2_1 Vdout2_1ck125 = 1.8 time = 2520
.meas tran vdout2_1ck125 FIND v(dout2_1) AT=2520.1n

* CHECK dout2_2 Vdout2_2ck125 = 1.8 time = 2520
.meas tran vdout2_2ck125 FIND v(dout2_2) AT=2520.1n

* CHECK dout2_3 Vdout2_3ck125 = 1.8 time = 2520
.meas tran vdout2_3ck125 FIND v(dout2_3) AT=2520.1n

* CHECK dout2_4 Vdout2_4ck125 = 1.8 time = 2520
.meas tran vdout2_4ck125 FIND v(dout2_4) AT=2520.1n

* CHECK dout2_5 Vdout2_5ck125 = 0 time = 2520
.meas tran vdout2_5ck125 FIND v(dout2_5) AT=2520.1n

* CHECK dout2_6 Vdout2_6ck125 = 0 time = 2520
.meas tran vdout2_6ck125 FIND v(dout2_6) AT=2520.1n

* CHECK dout2_7 Vdout2_7ck125 = 0 time = 2520
.meas tran vdout2_7ck125 FIND v(dout2_7) AT=2520.1n

* CHECK dout2_8 Vdout2_8ck125 = 0 time = 2520
.meas tran vdout2_8ck125 FIND v(dout2_8) AT=2520.1n

* CHECK dout2_9 Vdout2_9ck125 = 0 time = 2520
.meas tran vdout2_9ck125 FIND v(dout2_9) AT=2520.1n

* CHECK dout2_10 Vdout2_10ck125 = 0 time = 2520
.meas tran vdout2_10ck125 FIND v(dout2_10) AT=2520.1n

* CHECK dout2_11 Vdout2_11ck125 = 1.8 time = 2520
.meas tran vdout2_11ck125 FIND v(dout2_11) AT=2520.1n

* CHECK dout2_12 Vdout2_12ck125 = 0 time = 2520
.meas tran vdout2_12ck125 FIND v(dout2_12) AT=2520.1n

* CHECK dout2_13 Vdout2_13ck125 = 0 time = 2520
.meas tran vdout2_13ck125 FIND v(dout2_13) AT=2520.1n

* CHECK dout2_14 Vdout2_14ck125 = 0 time = 2520
.meas tran vdout2_14ck125 FIND v(dout2_14) AT=2520.1n

* CHECK dout2_15 Vdout2_15ck125 = 1.8 time = 2520
.meas tran vdout2_15ck125 FIND v(dout2_15) AT=2520.1n

* CHECK dout2_16 Vdout2_16ck125 = 0 time = 2520
.meas tran vdout2_16ck125 FIND v(dout2_16) AT=2520.1n

* CHECK dout2_17 Vdout2_17ck125 = 0 time = 2520
.meas tran vdout2_17ck125 FIND v(dout2_17) AT=2520.1n

* CHECK dout2_18 Vdout2_18ck125 = 1.8 time = 2520
.meas tran vdout2_18ck125 FIND v(dout2_18) AT=2520.1n

* CHECK dout2_19 Vdout2_19ck125 = 0 time = 2520
.meas tran vdout2_19ck125 FIND v(dout2_19) AT=2520.1n

* CHECK dout2_20 Vdout2_20ck125 = 1.8 time = 2520
.meas tran vdout2_20ck125 FIND v(dout2_20) AT=2520.1n

* CHECK dout2_21 Vdout2_21ck125 = 0 time = 2520
.meas tran vdout2_21ck125 FIND v(dout2_21) AT=2520.1n

* CHECK dout2_22 Vdout2_22ck125 = 1.8 time = 2520
.meas tran vdout2_22ck125 FIND v(dout2_22) AT=2520.1n

* CHECK dout2_23 Vdout2_23ck125 = 0 time = 2520
.meas tran vdout2_23ck125 FIND v(dout2_23) AT=2520.1n

* CHECK dout2_24 Vdout2_24ck125 = 0 time = 2520
.meas tran vdout2_24ck125 FIND v(dout2_24) AT=2520.1n

* CHECK dout2_25 Vdout2_25ck125 = 1.8 time = 2520
.meas tran vdout2_25ck125 FIND v(dout2_25) AT=2520.1n

* CHECK dout2_26 Vdout2_26ck125 = 0 time = 2520
.meas tran vdout2_26ck125 FIND v(dout2_26) AT=2520.1n

* CHECK dout2_27 Vdout2_27ck125 = 0 time = 2520
.meas tran vdout2_27ck125 FIND v(dout2_27) AT=2520.1n

* CHECK dout2_28 Vdout2_28ck125 = 1.8 time = 2520
.meas tran vdout2_28ck125 FIND v(dout2_28) AT=2520.1n

* CHECK dout2_29 Vdout2_29ck125 = 0 time = 2520
.meas tran vdout2_29ck125 FIND v(dout2_29) AT=2520.1n

* CHECK dout2_30 Vdout2_30ck125 = 1.8 time = 2520
.meas tran vdout2_30ck125 FIND v(dout2_30) AT=2520.1n

* CHECK dout2_31 Vdout2_31ck125 = 1.8 time = 2520
.meas tran vdout2_31ck125 FIND v(dout2_31) AT=2520.1n

* CHECK dout1_0 Vdout1_0ck126 = 1.8 time = 2540
.meas tran vdout1_0ck126 FIND v(dout1_0) AT=2540.1n

* CHECK dout1_1 Vdout1_1ck126 = 1.8 time = 2540
.meas tran vdout1_1ck126 FIND v(dout1_1) AT=2540.1n

* CHECK dout1_2 Vdout1_2ck126 = 1.8 time = 2540
.meas tran vdout1_2ck126 FIND v(dout1_2) AT=2540.1n

* CHECK dout1_3 Vdout1_3ck126 = 1.8 time = 2540
.meas tran vdout1_3ck126 FIND v(dout1_3) AT=2540.1n

* CHECK dout1_4 Vdout1_4ck126 = 1.8 time = 2540
.meas tran vdout1_4ck126 FIND v(dout1_4) AT=2540.1n

* CHECK dout1_5 Vdout1_5ck126 = 0 time = 2540
.meas tran vdout1_5ck126 FIND v(dout1_5) AT=2540.1n

* CHECK dout1_6 Vdout1_6ck126 = 0 time = 2540
.meas tran vdout1_6ck126 FIND v(dout1_6) AT=2540.1n

* CHECK dout1_7 Vdout1_7ck126 = 0 time = 2540
.meas tran vdout1_7ck126 FIND v(dout1_7) AT=2540.1n

* CHECK dout1_8 Vdout1_8ck126 = 0 time = 2540
.meas tran vdout1_8ck126 FIND v(dout1_8) AT=2540.1n

* CHECK dout1_9 Vdout1_9ck126 = 0 time = 2540
.meas tran vdout1_9ck126 FIND v(dout1_9) AT=2540.1n

* CHECK dout1_10 Vdout1_10ck126 = 0 time = 2540
.meas tran vdout1_10ck126 FIND v(dout1_10) AT=2540.1n

* CHECK dout1_11 Vdout1_11ck126 = 1.8 time = 2540
.meas tran vdout1_11ck126 FIND v(dout1_11) AT=2540.1n

* CHECK dout1_12 Vdout1_12ck126 = 0 time = 2540
.meas tran vdout1_12ck126 FIND v(dout1_12) AT=2540.1n

* CHECK dout1_13 Vdout1_13ck126 = 0 time = 2540
.meas tran vdout1_13ck126 FIND v(dout1_13) AT=2540.1n

* CHECK dout1_14 Vdout1_14ck126 = 0 time = 2540
.meas tran vdout1_14ck126 FIND v(dout1_14) AT=2540.1n

* CHECK dout1_15 Vdout1_15ck126 = 1.8 time = 2540
.meas tran vdout1_15ck126 FIND v(dout1_15) AT=2540.1n

* CHECK dout1_16 Vdout1_16ck126 = 0 time = 2540
.meas tran vdout1_16ck126 FIND v(dout1_16) AT=2540.1n

* CHECK dout1_17 Vdout1_17ck126 = 0 time = 2540
.meas tran vdout1_17ck126 FIND v(dout1_17) AT=2540.1n

* CHECK dout1_18 Vdout1_18ck126 = 1.8 time = 2540
.meas tran vdout1_18ck126 FIND v(dout1_18) AT=2540.1n

* CHECK dout1_19 Vdout1_19ck126 = 0 time = 2540
.meas tran vdout1_19ck126 FIND v(dout1_19) AT=2540.1n

* CHECK dout1_20 Vdout1_20ck126 = 1.8 time = 2540
.meas tran vdout1_20ck126 FIND v(dout1_20) AT=2540.1n

* CHECK dout1_21 Vdout1_21ck126 = 0 time = 2540
.meas tran vdout1_21ck126 FIND v(dout1_21) AT=2540.1n

* CHECK dout1_22 Vdout1_22ck126 = 1.8 time = 2540
.meas tran vdout1_22ck126 FIND v(dout1_22) AT=2540.1n

* CHECK dout1_23 Vdout1_23ck126 = 0 time = 2540
.meas tran vdout1_23ck126 FIND v(dout1_23) AT=2540.1n

* CHECK dout1_24 Vdout1_24ck126 = 0 time = 2540
.meas tran vdout1_24ck126 FIND v(dout1_24) AT=2540.1n

* CHECK dout1_25 Vdout1_25ck126 = 1.8 time = 2540
.meas tran vdout1_25ck126 FIND v(dout1_25) AT=2540.1n

* CHECK dout1_26 Vdout1_26ck126 = 0 time = 2540
.meas tran vdout1_26ck126 FIND v(dout1_26) AT=2540.1n

* CHECK dout1_27 Vdout1_27ck126 = 0 time = 2540
.meas tran vdout1_27ck126 FIND v(dout1_27) AT=2540.1n

* CHECK dout1_28 Vdout1_28ck126 = 1.8 time = 2540
.meas tran vdout1_28ck126 FIND v(dout1_28) AT=2540.1n

* CHECK dout1_29 Vdout1_29ck126 = 0 time = 2540
.meas tran vdout1_29ck126 FIND v(dout1_29) AT=2540.1n

* CHECK dout1_30 Vdout1_30ck126 = 1.8 time = 2540
.meas tran vdout1_30ck126 FIND v(dout1_30) AT=2540.1n

* CHECK dout1_31 Vdout1_31ck126 = 1.8 time = 2540
.meas tran vdout1_31ck126 FIND v(dout1_31) AT=2540.1n

* CHECK dout2_0 Vdout2_0ck126 = 1.8 time = 2540
.meas tran vdout2_0ck126 FIND v(dout2_0) AT=2540.1n

* CHECK dout2_1 Vdout2_1ck126 = 1.8 time = 2540
.meas tran vdout2_1ck126 FIND v(dout2_1) AT=2540.1n

* CHECK dout2_2 Vdout2_2ck126 = 1.8 time = 2540
.meas tran vdout2_2ck126 FIND v(dout2_2) AT=2540.1n

* CHECK dout2_3 Vdout2_3ck126 = 1.8 time = 2540
.meas tran vdout2_3ck126 FIND v(dout2_3) AT=2540.1n

* CHECK dout2_4 Vdout2_4ck126 = 1.8 time = 2540
.meas tran vdout2_4ck126 FIND v(dout2_4) AT=2540.1n

* CHECK dout2_5 Vdout2_5ck126 = 0 time = 2540
.meas tran vdout2_5ck126 FIND v(dout2_5) AT=2540.1n

* CHECK dout2_6 Vdout2_6ck126 = 0 time = 2540
.meas tran vdout2_6ck126 FIND v(dout2_6) AT=2540.1n

* CHECK dout2_7 Vdout2_7ck126 = 0 time = 2540
.meas tran vdout2_7ck126 FIND v(dout2_7) AT=2540.1n

* CHECK dout2_8 Vdout2_8ck126 = 0 time = 2540
.meas tran vdout2_8ck126 FIND v(dout2_8) AT=2540.1n

* CHECK dout2_9 Vdout2_9ck126 = 0 time = 2540
.meas tran vdout2_9ck126 FIND v(dout2_9) AT=2540.1n

* CHECK dout2_10 Vdout2_10ck126 = 0 time = 2540
.meas tran vdout2_10ck126 FIND v(dout2_10) AT=2540.1n

* CHECK dout2_11 Vdout2_11ck126 = 1.8 time = 2540
.meas tran vdout2_11ck126 FIND v(dout2_11) AT=2540.1n

* CHECK dout2_12 Vdout2_12ck126 = 0 time = 2540
.meas tran vdout2_12ck126 FIND v(dout2_12) AT=2540.1n

* CHECK dout2_13 Vdout2_13ck126 = 0 time = 2540
.meas tran vdout2_13ck126 FIND v(dout2_13) AT=2540.1n

* CHECK dout2_14 Vdout2_14ck126 = 0 time = 2540
.meas tran vdout2_14ck126 FIND v(dout2_14) AT=2540.1n

* CHECK dout2_15 Vdout2_15ck126 = 1.8 time = 2540
.meas tran vdout2_15ck126 FIND v(dout2_15) AT=2540.1n

* CHECK dout2_16 Vdout2_16ck126 = 0 time = 2540
.meas tran vdout2_16ck126 FIND v(dout2_16) AT=2540.1n

* CHECK dout2_17 Vdout2_17ck126 = 0 time = 2540
.meas tran vdout2_17ck126 FIND v(dout2_17) AT=2540.1n

* CHECK dout2_18 Vdout2_18ck126 = 1.8 time = 2540
.meas tran vdout2_18ck126 FIND v(dout2_18) AT=2540.1n

* CHECK dout2_19 Vdout2_19ck126 = 0 time = 2540
.meas tran vdout2_19ck126 FIND v(dout2_19) AT=2540.1n

* CHECK dout2_20 Vdout2_20ck126 = 1.8 time = 2540
.meas tran vdout2_20ck126 FIND v(dout2_20) AT=2540.1n

* CHECK dout2_21 Vdout2_21ck126 = 0 time = 2540
.meas tran vdout2_21ck126 FIND v(dout2_21) AT=2540.1n

* CHECK dout2_22 Vdout2_22ck126 = 1.8 time = 2540
.meas tran vdout2_22ck126 FIND v(dout2_22) AT=2540.1n

* CHECK dout2_23 Vdout2_23ck126 = 0 time = 2540
.meas tran vdout2_23ck126 FIND v(dout2_23) AT=2540.1n

* CHECK dout2_24 Vdout2_24ck126 = 0 time = 2540
.meas tran vdout2_24ck126 FIND v(dout2_24) AT=2540.1n

* CHECK dout2_25 Vdout2_25ck126 = 1.8 time = 2540
.meas tran vdout2_25ck126 FIND v(dout2_25) AT=2540.1n

* CHECK dout2_26 Vdout2_26ck126 = 0 time = 2540
.meas tran vdout2_26ck126 FIND v(dout2_26) AT=2540.1n

* CHECK dout2_27 Vdout2_27ck126 = 0 time = 2540
.meas tran vdout2_27ck126 FIND v(dout2_27) AT=2540.1n

* CHECK dout2_28 Vdout2_28ck126 = 1.8 time = 2540
.meas tran vdout2_28ck126 FIND v(dout2_28) AT=2540.1n

* CHECK dout2_29 Vdout2_29ck126 = 0 time = 2540
.meas tran vdout2_29ck126 FIND v(dout2_29) AT=2540.1n

* CHECK dout2_30 Vdout2_30ck126 = 1.8 time = 2540
.meas tran vdout2_30ck126 FIND v(dout2_30) AT=2540.1n

* CHECK dout2_31 Vdout2_31ck126 = 1.8 time = 2540
.meas tran vdout2_31ck126 FIND v(dout2_31) AT=2540.1n

* CHECK dout2_0 Vdout2_0ck127 = 0 time = 2560
.meas tran vdout2_0ck127 FIND v(dout2_0) AT=2560.1n

* CHECK dout2_1 Vdout2_1ck127 = 0 time = 2560
.meas tran vdout2_1ck127 FIND v(dout2_1) AT=2560.1n

* CHECK dout2_2 Vdout2_2ck127 = 1.8 time = 2560
.meas tran vdout2_2ck127 FIND v(dout2_2) AT=2560.1n

* CHECK dout2_3 Vdout2_3ck127 = 0 time = 2560
.meas tran vdout2_3ck127 FIND v(dout2_3) AT=2560.1n

* CHECK dout2_4 Vdout2_4ck127 = 1.8 time = 2560
.meas tran vdout2_4ck127 FIND v(dout2_4) AT=2560.1n

* CHECK dout2_5 Vdout2_5ck127 = 1.8 time = 2560
.meas tran vdout2_5ck127 FIND v(dout2_5) AT=2560.1n

* CHECK dout2_6 Vdout2_6ck127 = 0 time = 2560
.meas tran vdout2_6ck127 FIND v(dout2_6) AT=2560.1n

* CHECK dout2_7 Vdout2_7ck127 = 1.8 time = 2560
.meas tran vdout2_7ck127 FIND v(dout2_7) AT=2560.1n

* CHECK dout2_8 Vdout2_8ck127 = 1.8 time = 2560
.meas tran vdout2_8ck127 FIND v(dout2_8) AT=2560.1n

* CHECK dout2_9 Vdout2_9ck127 = 1.8 time = 2560
.meas tran vdout2_9ck127 FIND v(dout2_9) AT=2560.1n

* CHECK dout2_10 Vdout2_10ck127 = 0 time = 2560
.meas tran vdout2_10ck127 FIND v(dout2_10) AT=2560.1n

* CHECK dout2_11 Vdout2_11ck127 = 1.8 time = 2560
.meas tran vdout2_11ck127 FIND v(dout2_11) AT=2560.1n

* CHECK dout2_12 Vdout2_12ck127 = 0 time = 2560
.meas tran vdout2_12ck127 FIND v(dout2_12) AT=2560.1n

* CHECK dout2_13 Vdout2_13ck127 = 0 time = 2560
.meas tran vdout2_13ck127 FIND v(dout2_13) AT=2560.1n

* CHECK dout2_14 Vdout2_14ck127 = 1.8 time = 2560
.meas tran vdout2_14ck127 FIND v(dout2_14) AT=2560.1n

* CHECK dout2_15 Vdout2_15ck127 = 0 time = 2560
.meas tran vdout2_15ck127 FIND v(dout2_15) AT=2560.1n

* CHECK dout2_16 Vdout2_16ck127 = 1.8 time = 2560
.meas tran vdout2_16ck127 FIND v(dout2_16) AT=2560.1n

* CHECK dout2_17 Vdout2_17ck127 = 0 time = 2560
.meas tran vdout2_17ck127 FIND v(dout2_17) AT=2560.1n

* CHECK dout2_18 Vdout2_18ck127 = 0 time = 2560
.meas tran vdout2_18ck127 FIND v(dout2_18) AT=2560.1n

* CHECK dout2_19 Vdout2_19ck127 = 1.8 time = 2560
.meas tran vdout2_19ck127 FIND v(dout2_19) AT=2560.1n

* CHECK dout2_20 Vdout2_20ck127 = 1.8 time = 2560
.meas tran vdout2_20ck127 FIND v(dout2_20) AT=2560.1n

* CHECK dout2_21 Vdout2_21ck127 = 0 time = 2560
.meas tran vdout2_21ck127 FIND v(dout2_21) AT=2560.1n

* CHECK dout2_22 Vdout2_22ck127 = 1.8 time = 2560
.meas tran vdout2_22ck127 FIND v(dout2_22) AT=2560.1n

* CHECK dout2_23 Vdout2_23ck127 = 1.8 time = 2560
.meas tran vdout2_23ck127 FIND v(dout2_23) AT=2560.1n

* CHECK dout2_24 Vdout2_24ck127 = 0 time = 2560
.meas tran vdout2_24ck127 FIND v(dout2_24) AT=2560.1n

* CHECK dout2_25 Vdout2_25ck127 = 0 time = 2560
.meas tran vdout2_25ck127 FIND v(dout2_25) AT=2560.1n

* CHECK dout2_26 Vdout2_26ck127 = 0 time = 2560
.meas tran vdout2_26ck127 FIND v(dout2_26) AT=2560.1n

* CHECK dout2_27 Vdout2_27ck127 = 1.8 time = 2560
.meas tran vdout2_27ck127 FIND v(dout2_27) AT=2560.1n

* CHECK dout2_28 Vdout2_28ck127 = 0 time = 2560
.meas tran vdout2_28ck127 FIND v(dout2_28) AT=2560.1n

* CHECK dout2_29 Vdout2_29ck127 = 0 time = 2560
.meas tran vdout2_29ck127 FIND v(dout2_29) AT=2560.1n

* CHECK dout2_30 Vdout2_30ck127 = 1.8 time = 2560
.meas tran vdout2_30ck127 FIND v(dout2_30) AT=2560.1n

* CHECK dout2_31 Vdout2_31ck127 = 0 time = 2560
.meas tran vdout2_31ck127 FIND v(dout2_31) AT=2560.1n

* CHECK dout1_0 Vdout1_0ck129 = 0 time = 2600
.meas tran vdout1_0ck129 FIND v(dout1_0) AT=2600.1n

* CHECK dout1_1 Vdout1_1ck129 = 0 time = 2600
.meas tran vdout1_1ck129 FIND v(dout1_1) AT=2600.1n

* CHECK dout1_2 Vdout1_2ck129 = 1.8 time = 2600
.meas tran vdout1_2ck129 FIND v(dout1_2) AT=2600.1n

* CHECK dout1_3 Vdout1_3ck129 = 0 time = 2600
.meas tran vdout1_3ck129 FIND v(dout1_3) AT=2600.1n

* CHECK dout1_4 Vdout1_4ck129 = 1.8 time = 2600
.meas tran vdout1_4ck129 FIND v(dout1_4) AT=2600.1n

* CHECK dout1_5 Vdout1_5ck129 = 1.8 time = 2600
.meas tran vdout1_5ck129 FIND v(dout1_5) AT=2600.1n

* CHECK dout1_6 Vdout1_6ck129 = 0 time = 2600
.meas tran vdout1_6ck129 FIND v(dout1_6) AT=2600.1n

* CHECK dout1_7 Vdout1_7ck129 = 1.8 time = 2600
.meas tran vdout1_7ck129 FIND v(dout1_7) AT=2600.1n

* CHECK dout1_8 Vdout1_8ck129 = 1.8 time = 2600
.meas tran vdout1_8ck129 FIND v(dout1_8) AT=2600.1n

* CHECK dout1_9 Vdout1_9ck129 = 1.8 time = 2600
.meas tran vdout1_9ck129 FIND v(dout1_9) AT=2600.1n

* CHECK dout1_10 Vdout1_10ck129 = 0 time = 2600
.meas tran vdout1_10ck129 FIND v(dout1_10) AT=2600.1n

* CHECK dout1_11 Vdout1_11ck129 = 1.8 time = 2600
.meas tran vdout1_11ck129 FIND v(dout1_11) AT=2600.1n

* CHECK dout1_12 Vdout1_12ck129 = 0 time = 2600
.meas tran vdout1_12ck129 FIND v(dout1_12) AT=2600.1n

* CHECK dout1_13 Vdout1_13ck129 = 0 time = 2600
.meas tran vdout1_13ck129 FIND v(dout1_13) AT=2600.1n

* CHECK dout1_14 Vdout1_14ck129 = 1.8 time = 2600
.meas tran vdout1_14ck129 FIND v(dout1_14) AT=2600.1n

* CHECK dout1_15 Vdout1_15ck129 = 0 time = 2600
.meas tran vdout1_15ck129 FIND v(dout1_15) AT=2600.1n

* CHECK dout1_16 Vdout1_16ck129 = 1.8 time = 2600
.meas tran vdout1_16ck129 FIND v(dout1_16) AT=2600.1n

* CHECK dout1_17 Vdout1_17ck129 = 0 time = 2600
.meas tran vdout1_17ck129 FIND v(dout1_17) AT=2600.1n

* CHECK dout1_18 Vdout1_18ck129 = 0 time = 2600
.meas tran vdout1_18ck129 FIND v(dout1_18) AT=2600.1n

* CHECK dout1_19 Vdout1_19ck129 = 1.8 time = 2600
.meas tran vdout1_19ck129 FIND v(dout1_19) AT=2600.1n

* CHECK dout1_20 Vdout1_20ck129 = 1.8 time = 2600
.meas tran vdout1_20ck129 FIND v(dout1_20) AT=2600.1n

* CHECK dout1_21 Vdout1_21ck129 = 0 time = 2600
.meas tran vdout1_21ck129 FIND v(dout1_21) AT=2600.1n

* CHECK dout1_22 Vdout1_22ck129 = 1.8 time = 2600
.meas tran vdout1_22ck129 FIND v(dout1_22) AT=2600.1n

* CHECK dout1_23 Vdout1_23ck129 = 1.8 time = 2600
.meas tran vdout1_23ck129 FIND v(dout1_23) AT=2600.1n

* CHECK dout1_24 Vdout1_24ck129 = 0 time = 2600
.meas tran vdout1_24ck129 FIND v(dout1_24) AT=2600.1n

* CHECK dout1_25 Vdout1_25ck129 = 0 time = 2600
.meas tran vdout1_25ck129 FIND v(dout1_25) AT=2600.1n

* CHECK dout1_26 Vdout1_26ck129 = 0 time = 2600
.meas tran vdout1_26ck129 FIND v(dout1_26) AT=2600.1n

* CHECK dout1_27 Vdout1_27ck129 = 1.8 time = 2600
.meas tran vdout1_27ck129 FIND v(dout1_27) AT=2600.1n

* CHECK dout1_28 Vdout1_28ck129 = 0 time = 2600
.meas tran vdout1_28ck129 FIND v(dout1_28) AT=2600.1n

* CHECK dout1_29 Vdout1_29ck129 = 0 time = 2600
.meas tran vdout1_29ck129 FIND v(dout1_29) AT=2600.1n

* CHECK dout1_30 Vdout1_30ck129 = 1.8 time = 2600
.meas tran vdout1_30ck129 FIND v(dout1_30) AT=2600.1n

* CHECK dout1_31 Vdout1_31ck129 = 0 time = 2600
.meas tran vdout1_31ck129 FIND v(dout1_31) AT=2600.1n

* CHECK dout2_0 Vdout2_0ck129 = 0 time = 2600
.meas tran vdout2_0ck129 FIND v(dout2_0) AT=2600.1n

* CHECK dout2_1 Vdout2_1ck129 = 0 time = 2600
.meas tran vdout2_1ck129 FIND v(dout2_1) AT=2600.1n

* CHECK dout2_2 Vdout2_2ck129 = 1.8 time = 2600
.meas tran vdout2_2ck129 FIND v(dout2_2) AT=2600.1n

* CHECK dout2_3 Vdout2_3ck129 = 0 time = 2600
.meas tran vdout2_3ck129 FIND v(dout2_3) AT=2600.1n

* CHECK dout2_4 Vdout2_4ck129 = 1.8 time = 2600
.meas tran vdout2_4ck129 FIND v(dout2_4) AT=2600.1n

* CHECK dout2_5 Vdout2_5ck129 = 1.8 time = 2600
.meas tran vdout2_5ck129 FIND v(dout2_5) AT=2600.1n

* CHECK dout2_6 Vdout2_6ck129 = 0 time = 2600
.meas tran vdout2_6ck129 FIND v(dout2_6) AT=2600.1n

* CHECK dout2_7 Vdout2_7ck129 = 1.8 time = 2600
.meas tran vdout2_7ck129 FIND v(dout2_7) AT=2600.1n

* CHECK dout2_8 Vdout2_8ck129 = 1.8 time = 2600
.meas tran vdout2_8ck129 FIND v(dout2_8) AT=2600.1n

* CHECK dout2_9 Vdout2_9ck129 = 1.8 time = 2600
.meas tran vdout2_9ck129 FIND v(dout2_9) AT=2600.1n

* CHECK dout2_10 Vdout2_10ck129 = 0 time = 2600
.meas tran vdout2_10ck129 FIND v(dout2_10) AT=2600.1n

* CHECK dout2_11 Vdout2_11ck129 = 1.8 time = 2600
.meas tran vdout2_11ck129 FIND v(dout2_11) AT=2600.1n

* CHECK dout2_12 Vdout2_12ck129 = 0 time = 2600
.meas tran vdout2_12ck129 FIND v(dout2_12) AT=2600.1n

* CHECK dout2_13 Vdout2_13ck129 = 0 time = 2600
.meas tran vdout2_13ck129 FIND v(dout2_13) AT=2600.1n

* CHECK dout2_14 Vdout2_14ck129 = 1.8 time = 2600
.meas tran vdout2_14ck129 FIND v(dout2_14) AT=2600.1n

* CHECK dout2_15 Vdout2_15ck129 = 0 time = 2600
.meas tran vdout2_15ck129 FIND v(dout2_15) AT=2600.1n

* CHECK dout2_16 Vdout2_16ck129 = 1.8 time = 2600
.meas tran vdout2_16ck129 FIND v(dout2_16) AT=2600.1n

* CHECK dout2_17 Vdout2_17ck129 = 0 time = 2600
.meas tran vdout2_17ck129 FIND v(dout2_17) AT=2600.1n

* CHECK dout2_18 Vdout2_18ck129 = 0 time = 2600
.meas tran vdout2_18ck129 FIND v(dout2_18) AT=2600.1n

* CHECK dout2_19 Vdout2_19ck129 = 1.8 time = 2600
.meas tran vdout2_19ck129 FIND v(dout2_19) AT=2600.1n

* CHECK dout2_20 Vdout2_20ck129 = 1.8 time = 2600
.meas tran vdout2_20ck129 FIND v(dout2_20) AT=2600.1n

* CHECK dout2_21 Vdout2_21ck129 = 0 time = 2600
.meas tran vdout2_21ck129 FIND v(dout2_21) AT=2600.1n

* CHECK dout2_22 Vdout2_22ck129 = 1.8 time = 2600
.meas tran vdout2_22ck129 FIND v(dout2_22) AT=2600.1n

* CHECK dout2_23 Vdout2_23ck129 = 1.8 time = 2600
.meas tran vdout2_23ck129 FIND v(dout2_23) AT=2600.1n

* CHECK dout2_24 Vdout2_24ck129 = 0 time = 2600
.meas tran vdout2_24ck129 FIND v(dout2_24) AT=2600.1n

* CHECK dout2_25 Vdout2_25ck129 = 0 time = 2600
.meas tran vdout2_25ck129 FIND v(dout2_25) AT=2600.1n

* CHECK dout2_26 Vdout2_26ck129 = 0 time = 2600
.meas tran vdout2_26ck129 FIND v(dout2_26) AT=2600.1n

* CHECK dout2_27 Vdout2_27ck129 = 1.8 time = 2600
.meas tran vdout2_27ck129 FIND v(dout2_27) AT=2600.1n

* CHECK dout2_28 Vdout2_28ck129 = 0 time = 2600
.meas tran vdout2_28ck129 FIND v(dout2_28) AT=2600.1n

* CHECK dout2_29 Vdout2_29ck129 = 0 time = 2600
.meas tran vdout2_29ck129 FIND v(dout2_29) AT=2600.1n

* CHECK dout2_30 Vdout2_30ck129 = 1.8 time = 2600
.meas tran vdout2_30ck129 FIND v(dout2_30) AT=2600.1n

* CHECK dout2_31 Vdout2_31ck129 = 0 time = 2600
.meas tran vdout2_31ck129 FIND v(dout2_31) AT=2600.1n

* CHECK dout1_0 Vdout1_0ck130 = 0 time = 2620
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=2620.1n

* CHECK dout1_1 Vdout1_1ck130 = 0 time = 2620
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=2620.1n

* CHECK dout1_2 Vdout1_2ck130 = 0 time = 2620
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=2620.1n

* CHECK dout1_3 Vdout1_3ck130 = 1.8 time = 2620
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=2620.1n

* CHECK dout1_4 Vdout1_4ck130 = 0 time = 2620
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=2620.1n

* CHECK dout1_5 Vdout1_5ck130 = 0 time = 2620
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=2620.1n

* CHECK dout1_6 Vdout1_6ck130 = 0 time = 2620
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=2620.1n

* CHECK dout1_7 Vdout1_7ck130 = 0 time = 2620
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=2620.1n

* CHECK dout1_8 Vdout1_8ck130 = 0 time = 2620
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=2620.1n

* CHECK dout1_9 Vdout1_9ck130 = 1.8 time = 2620
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=2620.1n

* CHECK dout1_10 Vdout1_10ck130 = 1.8 time = 2620
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=2620.1n

* CHECK dout1_11 Vdout1_11ck130 = 0 time = 2620
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=2620.1n

* CHECK dout1_12 Vdout1_12ck130 = 0 time = 2620
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=2620.1n

* CHECK dout1_13 Vdout1_13ck130 = 1.8 time = 2620
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=2620.1n

* CHECK dout1_14 Vdout1_14ck130 = 0 time = 2620
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=2620.1n

* CHECK dout1_15 Vdout1_15ck130 = 0 time = 2620
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=2620.1n

* CHECK dout1_16 Vdout1_16ck130 = 0 time = 2620
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=2620.1n

* CHECK dout1_17 Vdout1_17ck130 = 0 time = 2620
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=2620.1n

* CHECK dout1_18 Vdout1_18ck130 = 0 time = 2620
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=2620.1n

* CHECK dout1_19 Vdout1_19ck130 = 1.8 time = 2620
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=2620.1n

* CHECK dout1_20 Vdout1_20ck130 = 0 time = 2620
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=2620.1n

* CHECK dout1_21 Vdout1_21ck130 = 0 time = 2620
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=2620.1n

* CHECK dout1_22 Vdout1_22ck130 = 0 time = 2620
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=2620.1n

* CHECK dout1_23 Vdout1_23ck130 = 0 time = 2620
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=2620.1n

* CHECK dout1_24 Vdout1_24ck130 = 1.8 time = 2620
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=2620.1n

* CHECK dout1_25 Vdout1_25ck130 = 1.8 time = 2620
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=2620.1n

* CHECK dout1_26 Vdout1_26ck130 = 0 time = 2620
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=2620.1n

* CHECK dout1_27 Vdout1_27ck130 = 1.8 time = 2620
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=2620.1n

* CHECK dout1_28 Vdout1_28ck130 = 1.8 time = 2620
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=2620.1n

* CHECK dout1_29 Vdout1_29ck130 = 1.8 time = 2620
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=2620.1n

* CHECK dout1_30 Vdout1_30ck130 = 0 time = 2620
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=2620.1n

* CHECK dout1_31 Vdout1_31ck130 = 1.8 time = 2620
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=2620.1n

* CHECK dout2_0 Vdout2_0ck130 = 0 time = 2620
.meas tran vdout2_0ck130 FIND v(dout2_0) AT=2620.1n

* CHECK dout2_1 Vdout2_1ck130 = 0 time = 2620
.meas tran vdout2_1ck130 FIND v(dout2_1) AT=2620.1n

* CHECK dout2_2 Vdout2_2ck130 = 0 time = 2620
.meas tran vdout2_2ck130 FIND v(dout2_2) AT=2620.1n

* CHECK dout2_3 Vdout2_3ck130 = 1.8 time = 2620
.meas tran vdout2_3ck130 FIND v(dout2_3) AT=2620.1n

* CHECK dout2_4 Vdout2_4ck130 = 0 time = 2620
.meas tran vdout2_4ck130 FIND v(dout2_4) AT=2620.1n

* CHECK dout2_5 Vdout2_5ck130 = 0 time = 2620
.meas tran vdout2_5ck130 FIND v(dout2_5) AT=2620.1n

* CHECK dout2_6 Vdout2_6ck130 = 0 time = 2620
.meas tran vdout2_6ck130 FIND v(dout2_6) AT=2620.1n

* CHECK dout2_7 Vdout2_7ck130 = 0 time = 2620
.meas tran vdout2_7ck130 FIND v(dout2_7) AT=2620.1n

* CHECK dout2_8 Vdout2_8ck130 = 0 time = 2620
.meas tran vdout2_8ck130 FIND v(dout2_8) AT=2620.1n

* CHECK dout2_9 Vdout2_9ck130 = 1.8 time = 2620
.meas tran vdout2_9ck130 FIND v(dout2_9) AT=2620.1n

* CHECK dout2_10 Vdout2_10ck130 = 1.8 time = 2620
.meas tran vdout2_10ck130 FIND v(dout2_10) AT=2620.1n

* CHECK dout2_11 Vdout2_11ck130 = 0 time = 2620
.meas tran vdout2_11ck130 FIND v(dout2_11) AT=2620.1n

* CHECK dout2_12 Vdout2_12ck130 = 0 time = 2620
.meas tran vdout2_12ck130 FIND v(dout2_12) AT=2620.1n

* CHECK dout2_13 Vdout2_13ck130 = 1.8 time = 2620
.meas tran vdout2_13ck130 FIND v(dout2_13) AT=2620.1n

* CHECK dout2_14 Vdout2_14ck130 = 0 time = 2620
.meas tran vdout2_14ck130 FIND v(dout2_14) AT=2620.1n

* CHECK dout2_15 Vdout2_15ck130 = 0 time = 2620
.meas tran vdout2_15ck130 FIND v(dout2_15) AT=2620.1n

* CHECK dout2_16 Vdout2_16ck130 = 0 time = 2620
.meas tran vdout2_16ck130 FIND v(dout2_16) AT=2620.1n

* CHECK dout2_17 Vdout2_17ck130 = 0 time = 2620
.meas tran vdout2_17ck130 FIND v(dout2_17) AT=2620.1n

* CHECK dout2_18 Vdout2_18ck130 = 0 time = 2620
.meas tran vdout2_18ck130 FIND v(dout2_18) AT=2620.1n

* CHECK dout2_19 Vdout2_19ck130 = 1.8 time = 2620
.meas tran vdout2_19ck130 FIND v(dout2_19) AT=2620.1n

* CHECK dout2_20 Vdout2_20ck130 = 0 time = 2620
.meas tran vdout2_20ck130 FIND v(dout2_20) AT=2620.1n

* CHECK dout2_21 Vdout2_21ck130 = 0 time = 2620
.meas tran vdout2_21ck130 FIND v(dout2_21) AT=2620.1n

* CHECK dout2_22 Vdout2_22ck130 = 0 time = 2620
.meas tran vdout2_22ck130 FIND v(dout2_22) AT=2620.1n

* CHECK dout2_23 Vdout2_23ck130 = 0 time = 2620
.meas tran vdout2_23ck130 FIND v(dout2_23) AT=2620.1n

* CHECK dout2_24 Vdout2_24ck130 = 1.8 time = 2620
.meas tran vdout2_24ck130 FIND v(dout2_24) AT=2620.1n

* CHECK dout2_25 Vdout2_25ck130 = 1.8 time = 2620
.meas tran vdout2_25ck130 FIND v(dout2_25) AT=2620.1n

* CHECK dout2_26 Vdout2_26ck130 = 0 time = 2620
.meas tran vdout2_26ck130 FIND v(dout2_26) AT=2620.1n

* CHECK dout2_27 Vdout2_27ck130 = 1.8 time = 2620
.meas tran vdout2_27ck130 FIND v(dout2_27) AT=2620.1n

* CHECK dout2_28 Vdout2_28ck130 = 1.8 time = 2620
.meas tran vdout2_28ck130 FIND v(dout2_28) AT=2620.1n

* CHECK dout2_29 Vdout2_29ck130 = 1.8 time = 2620
.meas tran vdout2_29ck130 FIND v(dout2_29) AT=2620.1n

* CHECK dout2_30 Vdout2_30ck130 = 0 time = 2620
.meas tran vdout2_30ck130 FIND v(dout2_30) AT=2620.1n

* CHECK dout2_31 Vdout2_31ck130 = 1.8 time = 2620
.meas tran vdout2_31ck130 FIND v(dout2_31) AT=2620.1n

* CHECK dout1_0 Vdout1_0ck131 = 0 time = 2640
.meas tran vdout1_0ck131 FIND v(dout1_0) AT=2640.1n

* CHECK dout1_1 Vdout1_1ck131 = 1.8 time = 2640
.meas tran vdout1_1ck131 FIND v(dout1_1) AT=2640.1n

* CHECK dout1_2 Vdout1_2ck131 = 1.8 time = 2640
.meas tran vdout1_2ck131 FIND v(dout1_2) AT=2640.1n

* CHECK dout1_3 Vdout1_3ck131 = 1.8 time = 2640
.meas tran vdout1_3ck131 FIND v(dout1_3) AT=2640.1n

* CHECK dout1_4 Vdout1_4ck131 = 1.8 time = 2640
.meas tran vdout1_4ck131 FIND v(dout1_4) AT=2640.1n

* CHECK dout1_5 Vdout1_5ck131 = 0 time = 2640
.meas tran vdout1_5ck131 FIND v(dout1_5) AT=2640.1n

* CHECK dout1_6 Vdout1_6ck131 = 1.8 time = 2640
.meas tran vdout1_6ck131 FIND v(dout1_6) AT=2640.1n

* CHECK dout1_7 Vdout1_7ck131 = 1.8 time = 2640
.meas tran vdout1_7ck131 FIND v(dout1_7) AT=2640.1n

* CHECK dout1_8 Vdout1_8ck131 = 0 time = 2640
.meas tran vdout1_8ck131 FIND v(dout1_8) AT=2640.1n

* CHECK dout1_9 Vdout1_9ck131 = 0 time = 2640
.meas tran vdout1_9ck131 FIND v(dout1_9) AT=2640.1n

* CHECK dout1_10 Vdout1_10ck131 = 0 time = 2640
.meas tran vdout1_10ck131 FIND v(dout1_10) AT=2640.1n

* CHECK dout1_11 Vdout1_11ck131 = 1.8 time = 2640
.meas tran vdout1_11ck131 FIND v(dout1_11) AT=2640.1n

* CHECK dout1_12 Vdout1_12ck131 = 1.8 time = 2640
.meas tran vdout1_12ck131 FIND v(dout1_12) AT=2640.1n

* CHECK dout1_13 Vdout1_13ck131 = 0 time = 2640
.meas tran vdout1_13ck131 FIND v(dout1_13) AT=2640.1n

* CHECK dout1_14 Vdout1_14ck131 = 1.8 time = 2640
.meas tran vdout1_14ck131 FIND v(dout1_14) AT=2640.1n

* CHECK dout1_15 Vdout1_15ck131 = 0 time = 2640
.meas tran vdout1_15ck131 FIND v(dout1_15) AT=2640.1n

* CHECK dout1_16 Vdout1_16ck131 = 0 time = 2640
.meas tran vdout1_16ck131 FIND v(dout1_16) AT=2640.1n

* CHECK dout1_17 Vdout1_17ck131 = 1.8 time = 2640
.meas tran vdout1_17ck131 FIND v(dout1_17) AT=2640.1n

* CHECK dout1_18 Vdout1_18ck131 = 0 time = 2640
.meas tran vdout1_18ck131 FIND v(dout1_18) AT=2640.1n

* CHECK dout1_19 Vdout1_19ck131 = 0 time = 2640
.meas tran vdout1_19ck131 FIND v(dout1_19) AT=2640.1n

* CHECK dout1_20 Vdout1_20ck131 = 0 time = 2640
.meas tran vdout1_20ck131 FIND v(dout1_20) AT=2640.1n

* CHECK dout1_21 Vdout1_21ck131 = 1.8 time = 2640
.meas tran vdout1_21ck131 FIND v(dout1_21) AT=2640.1n

* CHECK dout1_22 Vdout1_22ck131 = 0 time = 2640
.meas tran vdout1_22ck131 FIND v(dout1_22) AT=2640.1n

* CHECK dout1_23 Vdout1_23ck131 = 0 time = 2640
.meas tran vdout1_23ck131 FIND v(dout1_23) AT=2640.1n

* CHECK dout1_24 Vdout1_24ck131 = 1.8 time = 2640
.meas tran vdout1_24ck131 FIND v(dout1_24) AT=2640.1n

* CHECK dout1_25 Vdout1_25ck131 = 0 time = 2640
.meas tran vdout1_25ck131 FIND v(dout1_25) AT=2640.1n

* CHECK dout1_26 Vdout1_26ck131 = 0 time = 2640
.meas tran vdout1_26ck131 FIND v(dout1_26) AT=2640.1n

* CHECK dout1_27 Vdout1_27ck131 = 1.8 time = 2640
.meas tran vdout1_27ck131 FIND v(dout1_27) AT=2640.1n

* CHECK dout1_28 Vdout1_28ck131 = 1.8 time = 2640
.meas tran vdout1_28ck131 FIND v(dout1_28) AT=2640.1n

* CHECK dout1_29 Vdout1_29ck131 = 0 time = 2640
.meas tran vdout1_29ck131 FIND v(dout1_29) AT=2640.1n

* CHECK dout1_30 Vdout1_30ck131 = 0 time = 2640
.meas tran vdout1_30ck131 FIND v(dout1_30) AT=2640.1n

* CHECK dout1_31 Vdout1_31ck131 = 0 time = 2640
.meas tran vdout1_31ck131 FIND v(dout1_31) AT=2640.1n

* CHECK dout1_0 Vdout1_0ck132 = 1.8 time = 2660
.meas tran vdout1_0ck132 FIND v(dout1_0) AT=2660.1n

* CHECK dout1_1 Vdout1_1ck132 = 0 time = 2660
.meas tran vdout1_1ck132 FIND v(dout1_1) AT=2660.1n

* CHECK dout1_2 Vdout1_2ck132 = 1.8 time = 2660
.meas tran vdout1_2ck132 FIND v(dout1_2) AT=2660.1n

* CHECK dout1_3 Vdout1_3ck132 = 0 time = 2660
.meas tran vdout1_3ck132 FIND v(dout1_3) AT=2660.1n

* CHECK dout1_4 Vdout1_4ck132 = 1.8 time = 2660
.meas tran vdout1_4ck132 FIND v(dout1_4) AT=2660.1n

* CHECK dout1_5 Vdout1_5ck132 = 1.8 time = 2660
.meas tran vdout1_5ck132 FIND v(dout1_5) AT=2660.1n

* CHECK dout1_6 Vdout1_6ck132 = 0 time = 2660
.meas tran vdout1_6ck132 FIND v(dout1_6) AT=2660.1n

* CHECK dout1_7 Vdout1_7ck132 = 0 time = 2660
.meas tran vdout1_7ck132 FIND v(dout1_7) AT=2660.1n

* CHECK dout1_8 Vdout1_8ck132 = 0 time = 2660
.meas tran vdout1_8ck132 FIND v(dout1_8) AT=2660.1n

* CHECK dout1_9 Vdout1_9ck132 = 0 time = 2660
.meas tran vdout1_9ck132 FIND v(dout1_9) AT=2660.1n

* CHECK dout1_10 Vdout1_10ck132 = 1.8 time = 2660
.meas tran vdout1_10ck132 FIND v(dout1_10) AT=2660.1n

* CHECK dout1_11 Vdout1_11ck132 = 0 time = 2660
.meas tran vdout1_11ck132 FIND v(dout1_11) AT=2660.1n

* CHECK dout1_12 Vdout1_12ck132 = 1.8 time = 2660
.meas tran vdout1_12ck132 FIND v(dout1_12) AT=2660.1n

* CHECK dout1_13 Vdout1_13ck132 = 1.8 time = 2660
.meas tran vdout1_13ck132 FIND v(dout1_13) AT=2660.1n

* CHECK dout1_14 Vdout1_14ck132 = 0 time = 2660
.meas tran vdout1_14ck132 FIND v(dout1_14) AT=2660.1n

* CHECK dout1_15 Vdout1_15ck132 = 0 time = 2660
.meas tran vdout1_15ck132 FIND v(dout1_15) AT=2660.1n

* CHECK dout1_16 Vdout1_16ck132 = 1.8 time = 2660
.meas tran vdout1_16ck132 FIND v(dout1_16) AT=2660.1n

* CHECK dout1_17 Vdout1_17ck132 = 0 time = 2660
.meas tran vdout1_17ck132 FIND v(dout1_17) AT=2660.1n

* CHECK dout1_18 Vdout1_18ck132 = 0 time = 2660
.meas tran vdout1_18ck132 FIND v(dout1_18) AT=2660.1n

* CHECK dout1_19 Vdout1_19ck132 = 1.8 time = 2660
.meas tran vdout1_19ck132 FIND v(dout1_19) AT=2660.1n

* CHECK dout1_20 Vdout1_20ck132 = 1.8 time = 2660
.meas tran vdout1_20ck132 FIND v(dout1_20) AT=2660.1n

* CHECK dout1_21 Vdout1_21ck132 = 0 time = 2660
.meas tran vdout1_21ck132 FIND v(dout1_21) AT=2660.1n

* CHECK dout1_22 Vdout1_22ck132 = 1.8 time = 2660
.meas tran vdout1_22ck132 FIND v(dout1_22) AT=2660.1n

* CHECK dout1_23 Vdout1_23ck132 = 1.8 time = 2660
.meas tran vdout1_23ck132 FIND v(dout1_23) AT=2660.1n

* CHECK dout1_24 Vdout1_24ck132 = 1.8 time = 2660
.meas tran vdout1_24ck132 FIND v(dout1_24) AT=2660.1n

* CHECK dout1_25 Vdout1_25ck132 = 1.8 time = 2660
.meas tran vdout1_25ck132 FIND v(dout1_25) AT=2660.1n

* CHECK dout1_26 Vdout1_26ck132 = 1.8 time = 2660
.meas tran vdout1_26ck132 FIND v(dout1_26) AT=2660.1n

* CHECK dout1_27 Vdout1_27ck132 = 0 time = 2660
.meas tran vdout1_27ck132 FIND v(dout1_27) AT=2660.1n

* CHECK dout1_28 Vdout1_28ck132 = 1.8 time = 2660
.meas tran vdout1_28ck132 FIND v(dout1_28) AT=2660.1n

* CHECK dout1_29 Vdout1_29ck132 = 0 time = 2660
.meas tran vdout1_29ck132 FIND v(dout1_29) AT=2660.1n

* CHECK dout1_30 Vdout1_30ck132 = 0 time = 2660
.meas tran vdout1_30ck132 FIND v(dout1_30) AT=2660.1n

* CHECK dout1_31 Vdout1_31ck132 = 0 time = 2660
.meas tran vdout1_31ck132 FIND v(dout1_31) AT=2660.1n

* CHECK dout2_0 Vdout2_0ck132 = 1.8 time = 2660
.meas tran vdout2_0ck132 FIND v(dout2_0) AT=2660.1n

* CHECK dout2_1 Vdout2_1ck132 = 0 time = 2660
.meas tran vdout2_1ck132 FIND v(dout2_1) AT=2660.1n

* CHECK dout2_2 Vdout2_2ck132 = 1.8 time = 2660
.meas tran vdout2_2ck132 FIND v(dout2_2) AT=2660.1n

* CHECK dout2_3 Vdout2_3ck132 = 0 time = 2660
.meas tran vdout2_3ck132 FIND v(dout2_3) AT=2660.1n

* CHECK dout2_4 Vdout2_4ck132 = 1.8 time = 2660
.meas tran vdout2_4ck132 FIND v(dout2_4) AT=2660.1n

* CHECK dout2_5 Vdout2_5ck132 = 1.8 time = 2660
.meas tran vdout2_5ck132 FIND v(dout2_5) AT=2660.1n

* CHECK dout2_6 Vdout2_6ck132 = 0 time = 2660
.meas tran vdout2_6ck132 FIND v(dout2_6) AT=2660.1n

* CHECK dout2_7 Vdout2_7ck132 = 0 time = 2660
.meas tran vdout2_7ck132 FIND v(dout2_7) AT=2660.1n

* CHECK dout2_8 Vdout2_8ck132 = 0 time = 2660
.meas tran vdout2_8ck132 FIND v(dout2_8) AT=2660.1n

* CHECK dout2_9 Vdout2_9ck132 = 0 time = 2660
.meas tran vdout2_9ck132 FIND v(dout2_9) AT=2660.1n

* CHECK dout2_10 Vdout2_10ck132 = 1.8 time = 2660
.meas tran vdout2_10ck132 FIND v(dout2_10) AT=2660.1n

* CHECK dout2_11 Vdout2_11ck132 = 0 time = 2660
.meas tran vdout2_11ck132 FIND v(dout2_11) AT=2660.1n

* CHECK dout2_12 Vdout2_12ck132 = 1.8 time = 2660
.meas tran vdout2_12ck132 FIND v(dout2_12) AT=2660.1n

* CHECK dout2_13 Vdout2_13ck132 = 1.8 time = 2660
.meas tran vdout2_13ck132 FIND v(dout2_13) AT=2660.1n

* CHECK dout2_14 Vdout2_14ck132 = 0 time = 2660
.meas tran vdout2_14ck132 FIND v(dout2_14) AT=2660.1n

* CHECK dout2_15 Vdout2_15ck132 = 0 time = 2660
.meas tran vdout2_15ck132 FIND v(dout2_15) AT=2660.1n

* CHECK dout2_16 Vdout2_16ck132 = 1.8 time = 2660
.meas tran vdout2_16ck132 FIND v(dout2_16) AT=2660.1n

* CHECK dout2_17 Vdout2_17ck132 = 0 time = 2660
.meas tran vdout2_17ck132 FIND v(dout2_17) AT=2660.1n

* CHECK dout2_18 Vdout2_18ck132 = 0 time = 2660
.meas tran vdout2_18ck132 FIND v(dout2_18) AT=2660.1n

* CHECK dout2_19 Vdout2_19ck132 = 1.8 time = 2660
.meas tran vdout2_19ck132 FIND v(dout2_19) AT=2660.1n

* CHECK dout2_20 Vdout2_20ck132 = 1.8 time = 2660
.meas tran vdout2_20ck132 FIND v(dout2_20) AT=2660.1n

* CHECK dout2_21 Vdout2_21ck132 = 0 time = 2660
.meas tran vdout2_21ck132 FIND v(dout2_21) AT=2660.1n

* CHECK dout2_22 Vdout2_22ck132 = 1.8 time = 2660
.meas tran vdout2_22ck132 FIND v(dout2_22) AT=2660.1n

* CHECK dout2_23 Vdout2_23ck132 = 1.8 time = 2660
.meas tran vdout2_23ck132 FIND v(dout2_23) AT=2660.1n

* CHECK dout2_24 Vdout2_24ck132 = 1.8 time = 2660
.meas tran vdout2_24ck132 FIND v(dout2_24) AT=2660.1n

* CHECK dout2_25 Vdout2_25ck132 = 1.8 time = 2660
.meas tran vdout2_25ck132 FIND v(dout2_25) AT=2660.1n

* CHECK dout2_26 Vdout2_26ck132 = 1.8 time = 2660
.meas tran vdout2_26ck132 FIND v(dout2_26) AT=2660.1n

* CHECK dout2_27 Vdout2_27ck132 = 0 time = 2660
.meas tran vdout2_27ck132 FIND v(dout2_27) AT=2660.1n

* CHECK dout2_28 Vdout2_28ck132 = 1.8 time = 2660
.meas tran vdout2_28ck132 FIND v(dout2_28) AT=2660.1n

* CHECK dout2_29 Vdout2_29ck132 = 0 time = 2660
.meas tran vdout2_29ck132 FIND v(dout2_29) AT=2660.1n

* CHECK dout2_30 Vdout2_30ck132 = 0 time = 2660
.meas tran vdout2_30ck132 FIND v(dout2_30) AT=2660.1n

* CHECK dout2_31 Vdout2_31ck132 = 0 time = 2660
.meas tran vdout2_31ck132 FIND v(dout2_31) AT=2660.1n

* CHECK dout1_0 Vdout1_0ck133 = 0 time = 2680
.meas tran vdout1_0ck133 FIND v(dout1_0) AT=2680.1n

* CHECK dout1_1 Vdout1_1ck133 = 1.8 time = 2680
.meas tran vdout1_1ck133 FIND v(dout1_1) AT=2680.1n

* CHECK dout1_2 Vdout1_2ck133 = 1.8 time = 2680
.meas tran vdout1_2ck133 FIND v(dout1_2) AT=2680.1n

* CHECK dout1_3 Vdout1_3ck133 = 1.8 time = 2680
.meas tran vdout1_3ck133 FIND v(dout1_3) AT=2680.1n

* CHECK dout1_4 Vdout1_4ck133 = 1.8 time = 2680
.meas tran vdout1_4ck133 FIND v(dout1_4) AT=2680.1n

* CHECK dout1_5 Vdout1_5ck133 = 0 time = 2680
.meas tran vdout1_5ck133 FIND v(dout1_5) AT=2680.1n

* CHECK dout1_6 Vdout1_6ck133 = 0 time = 2680
.meas tran vdout1_6ck133 FIND v(dout1_6) AT=2680.1n

* CHECK dout1_7 Vdout1_7ck133 = 0 time = 2680
.meas tran vdout1_7ck133 FIND v(dout1_7) AT=2680.1n

* CHECK dout1_8 Vdout1_8ck133 = 1.8 time = 2680
.meas tran vdout1_8ck133 FIND v(dout1_8) AT=2680.1n

* CHECK dout1_9 Vdout1_9ck133 = 0 time = 2680
.meas tran vdout1_9ck133 FIND v(dout1_9) AT=2680.1n

* CHECK dout1_10 Vdout1_10ck133 = 0 time = 2680
.meas tran vdout1_10ck133 FIND v(dout1_10) AT=2680.1n

* CHECK dout1_11 Vdout1_11ck133 = 0 time = 2680
.meas tran vdout1_11ck133 FIND v(dout1_11) AT=2680.1n

* CHECK dout1_12 Vdout1_12ck133 = 1.8 time = 2680
.meas tran vdout1_12ck133 FIND v(dout1_12) AT=2680.1n

* CHECK dout1_13 Vdout1_13ck133 = 1.8 time = 2680
.meas tran vdout1_13ck133 FIND v(dout1_13) AT=2680.1n

* CHECK dout1_14 Vdout1_14ck133 = 1.8 time = 2680
.meas tran vdout1_14ck133 FIND v(dout1_14) AT=2680.1n

* CHECK dout1_15 Vdout1_15ck133 = 1.8 time = 2680
.meas tran vdout1_15ck133 FIND v(dout1_15) AT=2680.1n

* CHECK dout1_16 Vdout1_16ck133 = 1.8 time = 2680
.meas tran vdout1_16ck133 FIND v(dout1_16) AT=2680.1n

* CHECK dout1_17 Vdout1_17ck133 = 0 time = 2680
.meas tran vdout1_17ck133 FIND v(dout1_17) AT=2680.1n

* CHECK dout1_18 Vdout1_18ck133 = 0 time = 2680
.meas tran vdout1_18ck133 FIND v(dout1_18) AT=2680.1n

* CHECK dout1_19 Vdout1_19ck133 = 0 time = 2680
.meas tran vdout1_19ck133 FIND v(dout1_19) AT=2680.1n

* CHECK dout1_20 Vdout1_20ck133 = 0 time = 2680
.meas tran vdout1_20ck133 FIND v(dout1_20) AT=2680.1n

* CHECK dout1_21 Vdout1_21ck133 = 0 time = 2680
.meas tran vdout1_21ck133 FIND v(dout1_21) AT=2680.1n

* CHECK dout1_22 Vdout1_22ck133 = 1.8 time = 2680
.meas tran vdout1_22ck133 FIND v(dout1_22) AT=2680.1n

* CHECK dout1_23 Vdout1_23ck133 = 0 time = 2680
.meas tran vdout1_23ck133 FIND v(dout1_23) AT=2680.1n

* CHECK dout1_24 Vdout1_24ck133 = 1.8 time = 2680
.meas tran vdout1_24ck133 FIND v(dout1_24) AT=2680.1n

* CHECK dout1_25 Vdout1_25ck133 = 0 time = 2680
.meas tran vdout1_25ck133 FIND v(dout1_25) AT=2680.1n

* CHECK dout1_26 Vdout1_26ck133 = 0 time = 2680
.meas tran vdout1_26ck133 FIND v(dout1_26) AT=2680.1n

* CHECK dout1_27 Vdout1_27ck133 = 1.8 time = 2680
.meas tran vdout1_27ck133 FIND v(dout1_27) AT=2680.1n

* CHECK dout1_28 Vdout1_28ck133 = 0 time = 2680
.meas tran vdout1_28ck133 FIND v(dout1_28) AT=2680.1n

* CHECK dout1_29 Vdout1_29ck133 = 0 time = 2680
.meas tran vdout1_29ck133 FIND v(dout1_29) AT=2680.1n

* CHECK dout1_30 Vdout1_30ck133 = 1.8 time = 2680
.meas tran vdout1_30ck133 FIND v(dout1_30) AT=2680.1n

* CHECK dout1_31 Vdout1_31ck133 = 1.8 time = 2680
.meas tran vdout1_31ck133 FIND v(dout1_31) AT=2680.1n

* CHECK dout1_0 Vdout1_0ck134 = 1.8 time = 2700
.meas tran vdout1_0ck134 FIND v(dout1_0) AT=2700.1n

* CHECK dout1_1 Vdout1_1ck134 = 0 time = 2700
.meas tran vdout1_1ck134 FIND v(dout1_1) AT=2700.1n

* CHECK dout1_2 Vdout1_2ck134 = 1.8 time = 2700
.meas tran vdout1_2ck134 FIND v(dout1_2) AT=2700.1n

* CHECK dout1_3 Vdout1_3ck134 = 0 time = 2700
.meas tran vdout1_3ck134 FIND v(dout1_3) AT=2700.1n

* CHECK dout1_4 Vdout1_4ck134 = 1.8 time = 2700
.meas tran vdout1_4ck134 FIND v(dout1_4) AT=2700.1n

* CHECK dout1_5 Vdout1_5ck134 = 1.8 time = 2700
.meas tran vdout1_5ck134 FIND v(dout1_5) AT=2700.1n

* CHECK dout1_6 Vdout1_6ck134 = 0 time = 2700
.meas tran vdout1_6ck134 FIND v(dout1_6) AT=2700.1n

* CHECK dout1_7 Vdout1_7ck134 = 0 time = 2700
.meas tran vdout1_7ck134 FIND v(dout1_7) AT=2700.1n

* CHECK dout1_8 Vdout1_8ck134 = 0 time = 2700
.meas tran vdout1_8ck134 FIND v(dout1_8) AT=2700.1n

* CHECK dout1_9 Vdout1_9ck134 = 0 time = 2700
.meas tran vdout1_9ck134 FIND v(dout1_9) AT=2700.1n

* CHECK dout1_10 Vdout1_10ck134 = 1.8 time = 2700
.meas tran vdout1_10ck134 FIND v(dout1_10) AT=2700.1n

* CHECK dout1_11 Vdout1_11ck134 = 0 time = 2700
.meas tran vdout1_11ck134 FIND v(dout1_11) AT=2700.1n

* CHECK dout1_12 Vdout1_12ck134 = 1.8 time = 2700
.meas tran vdout1_12ck134 FIND v(dout1_12) AT=2700.1n

* CHECK dout1_13 Vdout1_13ck134 = 1.8 time = 2700
.meas tran vdout1_13ck134 FIND v(dout1_13) AT=2700.1n

* CHECK dout1_14 Vdout1_14ck134 = 0 time = 2700
.meas tran vdout1_14ck134 FIND v(dout1_14) AT=2700.1n

* CHECK dout1_15 Vdout1_15ck134 = 0 time = 2700
.meas tran vdout1_15ck134 FIND v(dout1_15) AT=2700.1n

* CHECK dout1_16 Vdout1_16ck134 = 1.8 time = 2700
.meas tran vdout1_16ck134 FIND v(dout1_16) AT=2700.1n

* CHECK dout1_17 Vdout1_17ck134 = 0 time = 2700
.meas tran vdout1_17ck134 FIND v(dout1_17) AT=2700.1n

* CHECK dout1_18 Vdout1_18ck134 = 0 time = 2700
.meas tran vdout1_18ck134 FIND v(dout1_18) AT=2700.1n

* CHECK dout1_19 Vdout1_19ck134 = 1.8 time = 2700
.meas tran vdout1_19ck134 FIND v(dout1_19) AT=2700.1n

* CHECK dout1_20 Vdout1_20ck134 = 1.8 time = 2700
.meas tran vdout1_20ck134 FIND v(dout1_20) AT=2700.1n

* CHECK dout1_21 Vdout1_21ck134 = 0 time = 2700
.meas tran vdout1_21ck134 FIND v(dout1_21) AT=2700.1n

* CHECK dout1_22 Vdout1_22ck134 = 1.8 time = 2700
.meas tran vdout1_22ck134 FIND v(dout1_22) AT=2700.1n

* CHECK dout1_23 Vdout1_23ck134 = 1.8 time = 2700
.meas tran vdout1_23ck134 FIND v(dout1_23) AT=2700.1n

* CHECK dout1_24 Vdout1_24ck134 = 1.8 time = 2700
.meas tran vdout1_24ck134 FIND v(dout1_24) AT=2700.1n

* CHECK dout1_25 Vdout1_25ck134 = 1.8 time = 2700
.meas tran vdout1_25ck134 FIND v(dout1_25) AT=2700.1n

* CHECK dout1_26 Vdout1_26ck134 = 1.8 time = 2700
.meas tran vdout1_26ck134 FIND v(dout1_26) AT=2700.1n

* CHECK dout1_27 Vdout1_27ck134 = 0 time = 2700
.meas tran vdout1_27ck134 FIND v(dout1_27) AT=2700.1n

* CHECK dout1_28 Vdout1_28ck134 = 1.8 time = 2700
.meas tran vdout1_28ck134 FIND v(dout1_28) AT=2700.1n

* CHECK dout1_29 Vdout1_29ck134 = 0 time = 2700
.meas tran vdout1_29ck134 FIND v(dout1_29) AT=2700.1n

* CHECK dout1_30 Vdout1_30ck134 = 0 time = 2700
.meas tran vdout1_30ck134 FIND v(dout1_30) AT=2700.1n

* CHECK dout1_31 Vdout1_31ck134 = 0 time = 2700
.meas tran vdout1_31ck134 FIND v(dout1_31) AT=2700.1n

* CHECK dout2_0 Vdout2_0ck134 = 0 time = 2700
.meas tran vdout2_0ck134 FIND v(dout2_0) AT=2700.1n

* CHECK dout2_1 Vdout2_1ck134 = 0 time = 2700
.meas tran vdout2_1ck134 FIND v(dout2_1) AT=2700.1n

* CHECK dout2_2 Vdout2_2ck134 = 0 time = 2700
.meas tran vdout2_2ck134 FIND v(dout2_2) AT=2700.1n

* CHECK dout2_3 Vdout2_3ck134 = 1.8 time = 2700
.meas tran vdout2_3ck134 FIND v(dout2_3) AT=2700.1n

* CHECK dout2_4 Vdout2_4ck134 = 0 time = 2700
.meas tran vdout2_4ck134 FIND v(dout2_4) AT=2700.1n

* CHECK dout2_5 Vdout2_5ck134 = 0 time = 2700
.meas tran vdout2_5ck134 FIND v(dout2_5) AT=2700.1n

* CHECK dout2_6 Vdout2_6ck134 = 0 time = 2700
.meas tran vdout2_6ck134 FIND v(dout2_6) AT=2700.1n

* CHECK dout2_7 Vdout2_7ck134 = 0 time = 2700
.meas tran vdout2_7ck134 FIND v(dout2_7) AT=2700.1n

* CHECK dout2_8 Vdout2_8ck134 = 0 time = 2700
.meas tran vdout2_8ck134 FIND v(dout2_8) AT=2700.1n

* CHECK dout2_9 Vdout2_9ck134 = 1.8 time = 2700
.meas tran vdout2_9ck134 FIND v(dout2_9) AT=2700.1n

* CHECK dout2_10 Vdout2_10ck134 = 1.8 time = 2700
.meas tran vdout2_10ck134 FIND v(dout2_10) AT=2700.1n

* CHECK dout2_11 Vdout2_11ck134 = 0 time = 2700
.meas tran vdout2_11ck134 FIND v(dout2_11) AT=2700.1n

* CHECK dout2_12 Vdout2_12ck134 = 0 time = 2700
.meas tran vdout2_12ck134 FIND v(dout2_12) AT=2700.1n

* CHECK dout2_13 Vdout2_13ck134 = 1.8 time = 2700
.meas tran vdout2_13ck134 FIND v(dout2_13) AT=2700.1n

* CHECK dout2_14 Vdout2_14ck134 = 0 time = 2700
.meas tran vdout2_14ck134 FIND v(dout2_14) AT=2700.1n

* CHECK dout2_15 Vdout2_15ck134 = 0 time = 2700
.meas tran vdout2_15ck134 FIND v(dout2_15) AT=2700.1n

* CHECK dout2_16 Vdout2_16ck134 = 0 time = 2700
.meas tran vdout2_16ck134 FIND v(dout2_16) AT=2700.1n

* CHECK dout2_17 Vdout2_17ck134 = 0 time = 2700
.meas tran vdout2_17ck134 FIND v(dout2_17) AT=2700.1n

* CHECK dout2_18 Vdout2_18ck134 = 0 time = 2700
.meas tran vdout2_18ck134 FIND v(dout2_18) AT=2700.1n

* CHECK dout2_19 Vdout2_19ck134 = 1.8 time = 2700
.meas tran vdout2_19ck134 FIND v(dout2_19) AT=2700.1n

* CHECK dout2_20 Vdout2_20ck134 = 0 time = 2700
.meas tran vdout2_20ck134 FIND v(dout2_20) AT=2700.1n

* CHECK dout2_21 Vdout2_21ck134 = 0 time = 2700
.meas tran vdout2_21ck134 FIND v(dout2_21) AT=2700.1n

* CHECK dout2_22 Vdout2_22ck134 = 0 time = 2700
.meas tran vdout2_22ck134 FIND v(dout2_22) AT=2700.1n

* CHECK dout2_23 Vdout2_23ck134 = 0 time = 2700
.meas tran vdout2_23ck134 FIND v(dout2_23) AT=2700.1n

* CHECK dout2_24 Vdout2_24ck134 = 1.8 time = 2700
.meas tran vdout2_24ck134 FIND v(dout2_24) AT=2700.1n

* CHECK dout2_25 Vdout2_25ck134 = 1.8 time = 2700
.meas tran vdout2_25ck134 FIND v(dout2_25) AT=2700.1n

* CHECK dout2_26 Vdout2_26ck134 = 0 time = 2700
.meas tran vdout2_26ck134 FIND v(dout2_26) AT=2700.1n

* CHECK dout2_27 Vdout2_27ck134 = 1.8 time = 2700
.meas tran vdout2_27ck134 FIND v(dout2_27) AT=2700.1n

* CHECK dout2_28 Vdout2_28ck134 = 1.8 time = 2700
.meas tran vdout2_28ck134 FIND v(dout2_28) AT=2700.1n

* CHECK dout2_29 Vdout2_29ck134 = 1.8 time = 2700
.meas tran vdout2_29ck134 FIND v(dout2_29) AT=2700.1n

* CHECK dout2_30 Vdout2_30ck134 = 0 time = 2700
.meas tran vdout2_30ck134 FIND v(dout2_30) AT=2700.1n

* CHECK dout2_31 Vdout2_31ck134 = 1.8 time = 2700
.meas tran vdout2_31ck134 FIND v(dout2_31) AT=2700.1n

* CHECK dout2_0 Vdout2_0ck135 = 1.8 time = 2720
.meas tran vdout2_0ck135 FIND v(dout2_0) AT=2720.1n

* CHECK dout2_1 Vdout2_1ck135 = 0 time = 2720
.meas tran vdout2_1ck135 FIND v(dout2_1) AT=2720.1n

* CHECK dout2_2 Vdout2_2ck135 = 1.8 time = 2720
.meas tran vdout2_2ck135 FIND v(dout2_2) AT=2720.1n

* CHECK dout2_3 Vdout2_3ck135 = 0 time = 2720
.meas tran vdout2_3ck135 FIND v(dout2_3) AT=2720.1n

* CHECK dout2_4 Vdout2_4ck135 = 1.8 time = 2720
.meas tran vdout2_4ck135 FIND v(dout2_4) AT=2720.1n

* CHECK dout2_5 Vdout2_5ck135 = 1.8 time = 2720
.meas tran vdout2_5ck135 FIND v(dout2_5) AT=2720.1n

* CHECK dout2_6 Vdout2_6ck135 = 0 time = 2720
.meas tran vdout2_6ck135 FIND v(dout2_6) AT=2720.1n

* CHECK dout2_7 Vdout2_7ck135 = 0 time = 2720
.meas tran vdout2_7ck135 FIND v(dout2_7) AT=2720.1n

* CHECK dout2_8 Vdout2_8ck135 = 0 time = 2720
.meas tran vdout2_8ck135 FIND v(dout2_8) AT=2720.1n

* CHECK dout2_9 Vdout2_9ck135 = 0 time = 2720
.meas tran vdout2_9ck135 FIND v(dout2_9) AT=2720.1n

* CHECK dout2_10 Vdout2_10ck135 = 1.8 time = 2720
.meas tran vdout2_10ck135 FIND v(dout2_10) AT=2720.1n

* CHECK dout2_11 Vdout2_11ck135 = 0 time = 2720
.meas tran vdout2_11ck135 FIND v(dout2_11) AT=2720.1n

* CHECK dout2_12 Vdout2_12ck135 = 1.8 time = 2720
.meas tran vdout2_12ck135 FIND v(dout2_12) AT=2720.1n

* CHECK dout2_13 Vdout2_13ck135 = 1.8 time = 2720
.meas tran vdout2_13ck135 FIND v(dout2_13) AT=2720.1n

* CHECK dout2_14 Vdout2_14ck135 = 0 time = 2720
.meas tran vdout2_14ck135 FIND v(dout2_14) AT=2720.1n

* CHECK dout2_15 Vdout2_15ck135 = 0 time = 2720
.meas tran vdout2_15ck135 FIND v(dout2_15) AT=2720.1n

* CHECK dout2_16 Vdout2_16ck135 = 1.8 time = 2720
.meas tran vdout2_16ck135 FIND v(dout2_16) AT=2720.1n

* CHECK dout2_17 Vdout2_17ck135 = 0 time = 2720
.meas tran vdout2_17ck135 FIND v(dout2_17) AT=2720.1n

* CHECK dout2_18 Vdout2_18ck135 = 0 time = 2720
.meas tran vdout2_18ck135 FIND v(dout2_18) AT=2720.1n

* CHECK dout2_19 Vdout2_19ck135 = 1.8 time = 2720
.meas tran vdout2_19ck135 FIND v(dout2_19) AT=2720.1n

* CHECK dout2_20 Vdout2_20ck135 = 1.8 time = 2720
.meas tran vdout2_20ck135 FIND v(dout2_20) AT=2720.1n

* CHECK dout2_21 Vdout2_21ck135 = 0 time = 2720
.meas tran vdout2_21ck135 FIND v(dout2_21) AT=2720.1n

* CHECK dout2_22 Vdout2_22ck135 = 1.8 time = 2720
.meas tran vdout2_22ck135 FIND v(dout2_22) AT=2720.1n

* CHECK dout2_23 Vdout2_23ck135 = 1.8 time = 2720
.meas tran vdout2_23ck135 FIND v(dout2_23) AT=2720.1n

* CHECK dout2_24 Vdout2_24ck135 = 1.8 time = 2720
.meas tran vdout2_24ck135 FIND v(dout2_24) AT=2720.1n

* CHECK dout2_25 Vdout2_25ck135 = 1.8 time = 2720
.meas tran vdout2_25ck135 FIND v(dout2_25) AT=2720.1n

* CHECK dout2_26 Vdout2_26ck135 = 1.8 time = 2720
.meas tran vdout2_26ck135 FIND v(dout2_26) AT=2720.1n

* CHECK dout2_27 Vdout2_27ck135 = 0 time = 2720
.meas tran vdout2_27ck135 FIND v(dout2_27) AT=2720.1n

* CHECK dout2_28 Vdout2_28ck135 = 1.8 time = 2720
.meas tran vdout2_28ck135 FIND v(dout2_28) AT=2720.1n

* CHECK dout2_29 Vdout2_29ck135 = 0 time = 2720
.meas tran vdout2_29ck135 FIND v(dout2_29) AT=2720.1n

* CHECK dout2_30 Vdout2_30ck135 = 0 time = 2720
.meas tran vdout2_30ck135 FIND v(dout2_30) AT=2720.1n

* CHECK dout2_31 Vdout2_31ck135 = 0 time = 2720
.meas tran vdout2_31ck135 FIND v(dout2_31) AT=2720.1n

* CHECK dout1_0 Vdout1_0ck136 = 1.8 time = 2740
.meas tran vdout1_0ck136 FIND v(dout1_0) AT=2740.1n

* CHECK dout1_1 Vdout1_1ck136 = 1.8 time = 2740
.meas tran vdout1_1ck136 FIND v(dout1_1) AT=2740.1n

* CHECK dout1_2 Vdout1_2ck136 = 1.8 time = 2740
.meas tran vdout1_2ck136 FIND v(dout1_2) AT=2740.1n

* CHECK dout1_3 Vdout1_3ck136 = 1.8 time = 2740
.meas tran vdout1_3ck136 FIND v(dout1_3) AT=2740.1n

* CHECK dout1_4 Vdout1_4ck136 = 0 time = 2740
.meas tran vdout1_4ck136 FIND v(dout1_4) AT=2740.1n

* CHECK dout1_5 Vdout1_5ck136 = 1.8 time = 2740
.meas tran vdout1_5ck136 FIND v(dout1_5) AT=2740.1n

* CHECK dout1_6 Vdout1_6ck136 = 1.8 time = 2740
.meas tran vdout1_6ck136 FIND v(dout1_6) AT=2740.1n

* CHECK dout1_7 Vdout1_7ck136 = 0 time = 2740
.meas tran vdout1_7ck136 FIND v(dout1_7) AT=2740.1n

* CHECK dout1_8 Vdout1_8ck136 = 0 time = 2740
.meas tran vdout1_8ck136 FIND v(dout1_8) AT=2740.1n

* CHECK dout1_9 Vdout1_9ck136 = 1.8 time = 2740
.meas tran vdout1_9ck136 FIND v(dout1_9) AT=2740.1n

* CHECK dout1_10 Vdout1_10ck136 = 0 time = 2740
.meas tran vdout1_10ck136 FIND v(dout1_10) AT=2740.1n

* CHECK dout1_11 Vdout1_11ck136 = 0 time = 2740
.meas tran vdout1_11ck136 FIND v(dout1_11) AT=2740.1n

* CHECK dout1_12 Vdout1_12ck136 = 0 time = 2740
.meas tran vdout1_12ck136 FIND v(dout1_12) AT=2740.1n

* CHECK dout1_13 Vdout1_13ck136 = 0 time = 2740
.meas tran vdout1_13ck136 FIND v(dout1_13) AT=2740.1n

* CHECK dout1_14 Vdout1_14ck136 = 0 time = 2740
.meas tran vdout1_14ck136 FIND v(dout1_14) AT=2740.1n

* CHECK dout1_15 Vdout1_15ck136 = 1.8 time = 2740
.meas tran vdout1_15ck136 FIND v(dout1_15) AT=2740.1n

* CHECK dout1_16 Vdout1_16ck136 = 0 time = 2740
.meas tran vdout1_16ck136 FIND v(dout1_16) AT=2740.1n

* CHECK dout1_17 Vdout1_17ck136 = 0 time = 2740
.meas tran vdout1_17ck136 FIND v(dout1_17) AT=2740.1n

* CHECK dout1_18 Vdout1_18ck136 = 0 time = 2740
.meas tran vdout1_18ck136 FIND v(dout1_18) AT=2740.1n

* CHECK dout1_19 Vdout1_19ck136 = 0 time = 2740
.meas tran vdout1_19ck136 FIND v(dout1_19) AT=2740.1n

* CHECK dout1_20 Vdout1_20ck136 = 0 time = 2740
.meas tran vdout1_20ck136 FIND v(dout1_20) AT=2740.1n

* CHECK dout1_21 Vdout1_21ck136 = 1.8 time = 2740
.meas tran vdout1_21ck136 FIND v(dout1_21) AT=2740.1n

* CHECK dout1_22 Vdout1_22ck136 = 1.8 time = 2740
.meas tran vdout1_22ck136 FIND v(dout1_22) AT=2740.1n

* CHECK dout1_23 Vdout1_23ck136 = 1.8 time = 2740
.meas tran vdout1_23ck136 FIND v(dout1_23) AT=2740.1n

* CHECK dout1_24 Vdout1_24ck136 = 1.8 time = 2740
.meas tran vdout1_24ck136 FIND v(dout1_24) AT=2740.1n

* CHECK dout1_25 Vdout1_25ck136 = 1.8 time = 2740
.meas tran vdout1_25ck136 FIND v(dout1_25) AT=2740.1n

* CHECK dout1_26 Vdout1_26ck136 = 0 time = 2740
.meas tran vdout1_26ck136 FIND v(dout1_26) AT=2740.1n

* CHECK dout1_27 Vdout1_27ck136 = 0 time = 2740
.meas tran vdout1_27ck136 FIND v(dout1_27) AT=2740.1n

* CHECK dout1_28 Vdout1_28ck136 = 1.8 time = 2740
.meas tran vdout1_28ck136 FIND v(dout1_28) AT=2740.1n

* CHECK dout1_29 Vdout1_29ck136 = 0 time = 2740
.meas tran vdout1_29ck136 FIND v(dout1_29) AT=2740.1n

* CHECK dout1_30 Vdout1_30ck136 = 1.8 time = 2740
.meas tran vdout1_30ck136 FIND v(dout1_30) AT=2740.1n

* CHECK dout1_31 Vdout1_31ck136 = 0 time = 2740
.meas tran vdout1_31ck136 FIND v(dout1_31) AT=2740.1n

* CHECK dout2_0 Vdout2_0ck136 = 0 time = 2740
.meas tran vdout2_0ck136 FIND v(dout2_0) AT=2740.1n

* CHECK dout2_1 Vdout2_1ck136 = 1.8 time = 2740
.meas tran vdout2_1ck136 FIND v(dout2_1) AT=2740.1n

* CHECK dout2_2 Vdout2_2ck136 = 0 time = 2740
.meas tran vdout2_2ck136 FIND v(dout2_2) AT=2740.1n

* CHECK dout2_3 Vdout2_3ck136 = 0 time = 2740
.meas tran vdout2_3ck136 FIND v(dout2_3) AT=2740.1n

* CHECK dout2_4 Vdout2_4ck136 = 1.8 time = 2740
.meas tran vdout2_4ck136 FIND v(dout2_4) AT=2740.1n

* CHECK dout2_5 Vdout2_5ck136 = 0 time = 2740
.meas tran vdout2_5ck136 FIND v(dout2_5) AT=2740.1n

* CHECK dout2_6 Vdout2_6ck136 = 0 time = 2740
.meas tran vdout2_6ck136 FIND v(dout2_6) AT=2740.1n

* CHECK dout2_7 Vdout2_7ck136 = 0 time = 2740
.meas tran vdout2_7ck136 FIND v(dout2_7) AT=2740.1n

* CHECK dout2_8 Vdout2_8ck136 = 0 time = 2740
.meas tran vdout2_8ck136 FIND v(dout2_8) AT=2740.1n

* CHECK dout2_9 Vdout2_9ck136 = 0 time = 2740
.meas tran vdout2_9ck136 FIND v(dout2_9) AT=2740.1n

* CHECK dout2_10 Vdout2_10ck136 = 1.8 time = 2740
.meas tran vdout2_10ck136 FIND v(dout2_10) AT=2740.1n

* CHECK dout2_11 Vdout2_11ck136 = 0 time = 2740
.meas tran vdout2_11ck136 FIND v(dout2_11) AT=2740.1n

* CHECK dout2_12 Vdout2_12ck136 = 1.8 time = 2740
.meas tran vdout2_12ck136 FIND v(dout2_12) AT=2740.1n

* CHECK dout2_13 Vdout2_13ck136 = 1.8 time = 2740
.meas tran vdout2_13ck136 FIND v(dout2_13) AT=2740.1n

* CHECK dout2_14 Vdout2_14ck136 = 1.8 time = 2740
.meas tran vdout2_14ck136 FIND v(dout2_14) AT=2740.1n

* CHECK dout2_15 Vdout2_15ck136 = 0 time = 2740
.meas tran vdout2_15ck136 FIND v(dout2_15) AT=2740.1n

* CHECK dout2_16 Vdout2_16ck136 = 1.8 time = 2740
.meas tran vdout2_16ck136 FIND v(dout2_16) AT=2740.1n

* CHECK dout2_17 Vdout2_17ck136 = 1.8 time = 2740
.meas tran vdout2_17ck136 FIND v(dout2_17) AT=2740.1n

* CHECK dout2_18 Vdout2_18ck136 = 0 time = 2740
.meas tran vdout2_18ck136 FIND v(dout2_18) AT=2740.1n

* CHECK dout2_19 Vdout2_19ck136 = 1.8 time = 2740
.meas tran vdout2_19ck136 FIND v(dout2_19) AT=2740.1n

* CHECK dout2_20 Vdout2_20ck136 = 0 time = 2740
.meas tran vdout2_20ck136 FIND v(dout2_20) AT=2740.1n

* CHECK dout2_21 Vdout2_21ck136 = 0 time = 2740
.meas tran vdout2_21ck136 FIND v(dout2_21) AT=2740.1n

* CHECK dout2_22 Vdout2_22ck136 = 1.8 time = 2740
.meas tran vdout2_22ck136 FIND v(dout2_22) AT=2740.1n

* CHECK dout2_23 Vdout2_23ck136 = 0 time = 2740
.meas tran vdout2_23ck136 FIND v(dout2_23) AT=2740.1n

* CHECK dout2_24 Vdout2_24ck136 = 0 time = 2740
.meas tran vdout2_24ck136 FIND v(dout2_24) AT=2740.1n

* CHECK dout2_25 Vdout2_25ck136 = 1.8 time = 2740
.meas tran vdout2_25ck136 FIND v(dout2_25) AT=2740.1n

* CHECK dout2_26 Vdout2_26ck136 = 0 time = 2740
.meas tran vdout2_26ck136 FIND v(dout2_26) AT=2740.1n

* CHECK dout2_27 Vdout2_27ck136 = 0 time = 2740
.meas tran vdout2_27ck136 FIND v(dout2_27) AT=2740.1n

* CHECK dout2_28 Vdout2_28ck136 = 0 time = 2740
.meas tran vdout2_28ck136 FIND v(dout2_28) AT=2740.1n

* CHECK dout2_29 Vdout2_29ck136 = 1.8 time = 2740
.meas tran vdout2_29ck136 FIND v(dout2_29) AT=2740.1n

* CHECK dout2_30 Vdout2_30ck136 = 0 time = 2740
.meas tran vdout2_30ck136 FIND v(dout2_30) AT=2740.1n

* CHECK dout2_31 Vdout2_31ck136 = 1.8 time = 2740
.meas tran vdout2_31ck136 FIND v(dout2_31) AT=2740.1n

* CHECK dout1_0 Vdout1_0ck137 = 0 time = 2760
.meas tran vdout1_0ck137 FIND v(dout1_0) AT=2760.1n

* CHECK dout1_1 Vdout1_1ck137 = 1.8 time = 2760
.meas tran vdout1_1ck137 FIND v(dout1_1) AT=2760.1n

* CHECK dout1_2 Vdout1_2ck137 = 0 time = 2760
.meas tran vdout1_2ck137 FIND v(dout1_2) AT=2760.1n

* CHECK dout1_3 Vdout1_3ck137 = 0 time = 2760
.meas tran vdout1_3ck137 FIND v(dout1_3) AT=2760.1n

* CHECK dout1_4 Vdout1_4ck137 = 1.8 time = 2760
.meas tran vdout1_4ck137 FIND v(dout1_4) AT=2760.1n

* CHECK dout1_5 Vdout1_5ck137 = 0 time = 2760
.meas tran vdout1_5ck137 FIND v(dout1_5) AT=2760.1n

* CHECK dout1_6 Vdout1_6ck137 = 0 time = 2760
.meas tran vdout1_6ck137 FIND v(dout1_6) AT=2760.1n

* CHECK dout1_7 Vdout1_7ck137 = 0 time = 2760
.meas tran vdout1_7ck137 FIND v(dout1_7) AT=2760.1n

* CHECK dout1_8 Vdout1_8ck137 = 0 time = 2760
.meas tran vdout1_8ck137 FIND v(dout1_8) AT=2760.1n

* CHECK dout1_9 Vdout1_9ck137 = 0 time = 2760
.meas tran vdout1_9ck137 FIND v(dout1_9) AT=2760.1n

* CHECK dout1_10 Vdout1_10ck137 = 1.8 time = 2760
.meas tran vdout1_10ck137 FIND v(dout1_10) AT=2760.1n

* CHECK dout1_11 Vdout1_11ck137 = 0 time = 2760
.meas tran vdout1_11ck137 FIND v(dout1_11) AT=2760.1n

* CHECK dout1_12 Vdout1_12ck137 = 1.8 time = 2760
.meas tran vdout1_12ck137 FIND v(dout1_12) AT=2760.1n

* CHECK dout1_13 Vdout1_13ck137 = 1.8 time = 2760
.meas tran vdout1_13ck137 FIND v(dout1_13) AT=2760.1n

* CHECK dout1_14 Vdout1_14ck137 = 1.8 time = 2760
.meas tran vdout1_14ck137 FIND v(dout1_14) AT=2760.1n

* CHECK dout1_15 Vdout1_15ck137 = 0 time = 2760
.meas tran vdout1_15ck137 FIND v(dout1_15) AT=2760.1n

* CHECK dout1_16 Vdout1_16ck137 = 1.8 time = 2760
.meas tran vdout1_16ck137 FIND v(dout1_16) AT=2760.1n

* CHECK dout1_17 Vdout1_17ck137 = 1.8 time = 2760
.meas tran vdout1_17ck137 FIND v(dout1_17) AT=2760.1n

* CHECK dout1_18 Vdout1_18ck137 = 0 time = 2760
.meas tran vdout1_18ck137 FIND v(dout1_18) AT=2760.1n

* CHECK dout1_19 Vdout1_19ck137 = 1.8 time = 2760
.meas tran vdout1_19ck137 FIND v(dout1_19) AT=2760.1n

* CHECK dout1_20 Vdout1_20ck137 = 0 time = 2760
.meas tran vdout1_20ck137 FIND v(dout1_20) AT=2760.1n

* CHECK dout1_21 Vdout1_21ck137 = 0 time = 2760
.meas tran vdout1_21ck137 FIND v(dout1_21) AT=2760.1n

* CHECK dout1_22 Vdout1_22ck137 = 1.8 time = 2760
.meas tran vdout1_22ck137 FIND v(dout1_22) AT=2760.1n

* CHECK dout1_23 Vdout1_23ck137 = 0 time = 2760
.meas tran vdout1_23ck137 FIND v(dout1_23) AT=2760.1n

* CHECK dout1_24 Vdout1_24ck137 = 0 time = 2760
.meas tran vdout1_24ck137 FIND v(dout1_24) AT=2760.1n

* CHECK dout1_25 Vdout1_25ck137 = 1.8 time = 2760
.meas tran vdout1_25ck137 FIND v(dout1_25) AT=2760.1n

* CHECK dout1_26 Vdout1_26ck137 = 0 time = 2760
.meas tran vdout1_26ck137 FIND v(dout1_26) AT=2760.1n

* CHECK dout1_27 Vdout1_27ck137 = 0 time = 2760
.meas tran vdout1_27ck137 FIND v(dout1_27) AT=2760.1n

* CHECK dout1_28 Vdout1_28ck137 = 0 time = 2760
.meas tran vdout1_28ck137 FIND v(dout1_28) AT=2760.1n

* CHECK dout1_29 Vdout1_29ck137 = 1.8 time = 2760
.meas tran vdout1_29ck137 FIND v(dout1_29) AT=2760.1n

* CHECK dout1_30 Vdout1_30ck137 = 0 time = 2760
.meas tran vdout1_30ck137 FIND v(dout1_30) AT=2760.1n

* CHECK dout1_31 Vdout1_31ck137 = 1.8 time = 2760
.meas tran vdout1_31ck137 FIND v(dout1_31) AT=2760.1n

* CHECK dout2_0 Vdout2_0ck137 = 1.8 time = 2760
.meas tran vdout2_0ck137 FIND v(dout2_0) AT=2760.1n

* CHECK dout2_1 Vdout2_1ck137 = 0 time = 2760
.meas tran vdout2_1ck137 FIND v(dout2_1) AT=2760.1n

* CHECK dout2_2 Vdout2_2ck137 = 1.8 time = 2760
.meas tran vdout2_2ck137 FIND v(dout2_2) AT=2760.1n

* CHECK dout2_3 Vdout2_3ck137 = 0 time = 2760
.meas tran vdout2_3ck137 FIND v(dout2_3) AT=2760.1n

* CHECK dout2_4 Vdout2_4ck137 = 1.8 time = 2760
.meas tran vdout2_4ck137 FIND v(dout2_4) AT=2760.1n

* CHECK dout2_5 Vdout2_5ck137 = 1.8 time = 2760
.meas tran vdout2_5ck137 FIND v(dout2_5) AT=2760.1n

* CHECK dout2_6 Vdout2_6ck137 = 0 time = 2760
.meas tran vdout2_6ck137 FIND v(dout2_6) AT=2760.1n

* CHECK dout2_7 Vdout2_7ck137 = 0 time = 2760
.meas tran vdout2_7ck137 FIND v(dout2_7) AT=2760.1n

* CHECK dout2_8 Vdout2_8ck137 = 0 time = 2760
.meas tran vdout2_8ck137 FIND v(dout2_8) AT=2760.1n

* CHECK dout2_9 Vdout2_9ck137 = 0 time = 2760
.meas tran vdout2_9ck137 FIND v(dout2_9) AT=2760.1n

* CHECK dout2_10 Vdout2_10ck137 = 1.8 time = 2760
.meas tran vdout2_10ck137 FIND v(dout2_10) AT=2760.1n

* CHECK dout2_11 Vdout2_11ck137 = 0 time = 2760
.meas tran vdout2_11ck137 FIND v(dout2_11) AT=2760.1n

* CHECK dout2_12 Vdout2_12ck137 = 1.8 time = 2760
.meas tran vdout2_12ck137 FIND v(dout2_12) AT=2760.1n

* CHECK dout2_13 Vdout2_13ck137 = 1.8 time = 2760
.meas tran vdout2_13ck137 FIND v(dout2_13) AT=2760.1n

* CHECK dout2_14 Vdout2_14ck137 = 0 time = 2760
.meas tran vdout2_14ck137 FIND v(dout2_14) AT=2760.1n

* CHECK dout2_15 Vdout2_15ck137 = 0 time = 2760
.meas tran vdout2_15ck137 FIND v(dout2_15) AT=2760.1n

* CHECK dout2_16 Vdout2_16ck137 = 1.8 time = 2760
.meas tran vdout2_16ck137 FIND v(dout2_16) AT=2760.1n

* CHECK dout2_17 Vdout2_17ck137 = 0 time = 2760
.meas tran vdout2_17ck137 FIND v(dout2_17) AT=2760.1n

* CHECK dout2_18 Vdout2_18ck137 = 0 time = 2760
.meas tran vdout2_18ck137 FIND v(dout2_18) AT=2760.1n

* CHECK dout2_19 Vdout2_19ck137 = 1.8 time = 2760
.meas tran vdout2_19ck137 FIND v(dout2_19) AT=2760.1n

* CHECK dout2_20 Vdout2_20ck137 = 1.8 time = 2760
.meas tran vdout2_20ck137 FIND v(dout2_20) AT=2760.1n

* CHECK dout2_21 Vdout2_21ck137 = 0 time = 2760
.meas tran vdout2_21ck137 FIND v(dout2_21) AT=2760.1n

* CHECK dout2_22 Vdout2_22ck137 = 1.8 time = 2760
.meas tran vdout2_22ck137 FIND v(dout2_22) AT=2760.1n

* CHECK dout2_23 Vdout2_23ck137 = 1.8 time = 2760
.meas tran vdout2_23ck137 FIND v(dout2_23) AT=2760.1n

* CHECK dout2_24 Vdout2_24ck137 = 1.8 time = 2760
.meas tran vdout2_24ck137 FIND v(dout2_24) AT=2760.1n

* CHECK dout2_25 Vdout2_25ck137 = 1.8 time = 2760
.meas tran vdout2_25ck137 FIND v(dout2_25) AT=2760.1n

* CHECK dout2_26 Vdout2_26ck137 = 1.8 time = 2760
.meas tran vdout2_26ck137 FIND v(dout2_26) AT=2760.1n

* CHECK dout2_27 Vdout2_27ck137 = 0 time = 2760
.meas tran vdout2_27ck137 FIND v(dout2_27) AT=2760.1n

* CHECK dout2_28 Vdout2_28ck137 = 1.8 time = 2760
.meas tran vdout2_28ck137 FIND v(dout2_28) AT=2760.1n

* CHECK dout2_29 Vdout2_29ck137 = 0 time = 2760
.meas tran vdout2_29ck137 FIND v(dout2_29) AT=2760.1n

* CHECK dout2_30 Vdout2_30ck137 = 0 time = 2760
.meas tran vdout2_30ck137 FIND v(dout2_30) AT=2760.1n

* CHECK dout2_31 Vdout2_31ck137 = 0 time = 2760
.meas tran vdout2_31ck137 FIND v(dout2_31) AT=2760.1n

* CHECK dout1_0 Vdout1_0ck138 = 0 time = 2780
.meas tran vdout1_0ck138 FIND v(dout1_0) AT=2780.1n

* CHECK dout1_1 Vdout1_1ck138 = 1.8 time = 2780
.meas tran vdout1_1ck138 FIND v(dout1_1) AT=2780.1n

* CHECK dout1_2 Vdout1_2ck138 = 0 time = 2780
.meas tran vdout1_2ck138 FIND v(dout1_2) AT=2780.1n

* CHECK dout1_3 Vdout1_3ck138 = 0 time = 2780
.meas tran vdout1_3ck138 FIND v(dout1_3) AT=2780.1n

* CHECK dout1_4 Vdout1_4ck138 = 1.8 time = 2780
.meas tran vdout1_4ck138 FIND v(dout1_4) AT=2780.1n

* CHECK dout1_5 Vdout1_5ck138 = 0 time = 2780
.meas tran vdout1_5ck138 FIND v(dout1_5) AT=2780.1n

* CHECK dout1_6 Vdout1_6ck138 = 0 time = 2780
.meas tran vdout1_6ck138 FIND v(dout1_6) AT=2780.1n

* CHECK dout1_7 Vdout1_7ck138 = 0 time = 2780
.meas tran vdout1_7ck138 FIND v(dout1_7) AT=2780.1n

* CHECK dout1_8 Vdout1_8ck138 = 0 time = 2780
.meas tran vdout1_8ck138 FIND v(dout1_8) AT=2780.1n

* CHECK dout1_9 Vdout1_9ck138 = 0 time = 2780
.meas tran vdout1_9ck138 FIND v(dout1_9) AT=2780.1n

* CHECK dout1_10 Vdout1_10ck138 = 1.8 time = 2780
.meas tran vdout1_10ck138 FIND v(dout1_10) AT=2780.1n

* CHECK dout1_11 Vdout1_11ck138 = 0 time = 2780
.meas tran vdout1_11ck138 FIND v(dout1_11) AT=2780.1n

* CHECK dout1_12 Vdout1_12ck138 = 1.8 time = 2780
.meas tran vdout1_12ck138 FIND v(dout1_12) AT=2780.1n

* CHECK dout1_13 Vdout1_13ck138 = 1.8 time = 2780
.meas tran vdout1_13ck138 FIND v(dout1_13) AT=2780.1n

* CHECK dout1_14 Vdout1_14ck138 = 1.8 time = 2780
.meas tran vdout1_14ck138 FIND v(dout1_14) AT=2780.1n

* CHECK dout1_15 Vdout1_15ck138 = 0 time = 2780
.meas tran vdout1_15ck138 FIND v(dout1_15) AT=2780.1n

* CHECK dout1_16 Vdout1_16ck138 = 1.8 time = 2780
.meas tran vdout1_16ck138 FIND v(dout1_16) AT=2780.1n

* CHECK dout1_17 Vdout1_17ck138 = 1.8 time = 2780
.meas tran vdout1_17ck138 FIND v(dout1_17) AT=2780.1n

* CHECK dout1_18 Vdout1_18ck138 = 0 time = 2780
.meas tran vdout1_18ck138 FIND v(dout1_18) AT=2780.1n

* CHECK dout1_19 Vdout1_19ck138 = 1.8 time = 2780
.meas tran vdout1_19ck138 FIND v(dout1_19) AT=2780.1n

* CHECK dout1_20 Vdout1_20ck138 = 0 time = 2780
.meas tran vdout1_20ck138 FIND v(dout1_20) AT=2780.1n

* CHECK dout1_21 Vdout1_21ck138 = 0 time = 2780
.meas tran vdout1_21ck138 FIND v(dout1_21) AT=2780.1n

* CHECK dout1_22 Vdout1_22ck138 = 1.8 time = 2780
.meas tran vdout1_22ck138 FIND v(dout1_22) AT=2780.1n

* CHECK dout1_23 Vdout1_23ck138 = 0 time = 2780
.meas tran vdout1_23ck138 FIND v(dout1_23) AT=2780.1n

* CHECK dout1_24 Vdout1_24ck138 = 0 time = 2780
.meas tran vdout1_24ck138 FIND v(dout1_24) AT=2780.1n

* CHECK dout1_25 Vdout1_25ck138 = 1.8 time = 2780
.meas tran vdout1_25ck138 FIND v(dout1_25) AT=2780.1n

* CHECK dout1_26 Vdout1_26ck138 = 0 time = 2780
.meas tran vdout1_26ck138 FIND v(dout1_26) AT=2780.1n

* CHECK dout1_27 Vdout1_27ck138 = 0 time = 2780
.meas tran vdout1_27ck138 FIND v(dout1_27) AT=2780.1n

* CHECK dout1_28 Vdout1_28ck138 = 0 time = 2780
.meas tran vdout1_28ck138 FIND v(dout1_28) AT=2780.1n

* CHECK dout1_29 Vdout1_29ck138 = 1.8 time = 2780
.meas tran vdout1_29ck138 FIND v(dout1_29) AT=2780.1n

* CHECK dout1_30 Vdout1_30ck138 = 0 time = 2780
.meas tran vdout1_30ck138 FIND v(dout1_30) AT=2780.1n

* CHECK dout1_31 Vdout1_31ck138 = 1.8 time = 2780
.meas tran vdout1_31ck138 FIND v(dout1_31) AT=2780.1n

* CHECK dout2_0 Vdout2_0ck138 = 1.8 time = 2780
.meas tran vdout2_0ck138 FIND v(dout2_0) AT=2780.1n

* CHECK dout2_1 Vdout2_1ck138 = 0 time = 2780
.meas tran vdout2_1ck138 FIND v(dout2_1) AT=2780.1n

* CHECK dout2_2 Vdout2_2ck138 = 1.8 time = 2780
.meas tran vdout2_2ck138 FIND v(dout2_2) AT=2780.1n

* CHECK dout2_3 Vdout2_3ck138 = 0 time = 2780
.meas tran vdout2_3ck138 FIND v(dout2_3) AT=2780.1n

* CHECK dout2_4 Vdout2_4ck138 = 1.8 time = 2780
.meas tran vdout2_4ck138 FIND v(dout2_4) AT=2780.1n

* CHECK dout2_5 Vdout2_5ck138 = 1.8 time = 2780
.meas tran vdout2_5ck138 FIND v(dout2_5) AT=2780.1n

* CHECK dout2_6 Vdout2_6ck138 = 0 time = 2780
.meas tran vdout2_6ck138 FIND v(dout2_6) AT=2780.1n

* CHECK dout2_7 Vdout2_7ck138 = 0 time = 2780
.meas tran vdout2_7ck138 FIND v(dout2_7) AT=2780.1n

* CHECK dout2_8 Vdout2_8ck138 = 0 time = 2780
.meas tran vdout2_8ck138 FIND v(dout2_8) AT=2780.1n

* CHECK dout2_9 Vdout2_9ck138 = 0 time = 2780
.meas tran vdout2_9ck138 FIND v(dout2_9) AT=2780.1n

* CHECK dout2_10 Vdout2_10ck138 = 1.8 time = 2780
.meas tran vdout2_10ck138 FIND v(dout2_10) AT=2780.1n

* CHECK dout2_11 Vdout2_11ck138 = 0 time = 2780
.meas tran vdout2_11ck138 FIND v(dout2_11) AT=2780.1n

* CHECK dout2_12 Vdout2_12ck138 = 1.8 time = 2780
.meas tran vdout2_12ck138 FIND v(dout2_12) AT=2780.1n

* CHECK dout2_13 Vdout2_13ck138 = 1.8 time = 2780
.meas tran vdout2_13ck138 FIND v(dout2_13) AT=2780.1n

* CHECK dout2_14 Vdout2_14ck138 = 0 time = 2780
.meas tran vdout2_14ck138 FIND v(dout2_14) AT=2780.1n

* CHECK dout2_15 Vdout2_15ck138 = 0 time = 2780
.meas tran vdout2_15ck138 FIND v(dout2_15) AT=2780.1n

* CHECK dout2_16 Vdout2_16ck138 = 1.8 time = 2780
.meas tran vdout2_16ck138 FIND v(dout2_16) AT=2780.1n

* CHECK dout2_17 Vdout2_17ck138 = 0 time = 2780
.meas tran vdout2_17ck138 FIND v(dout2_17) AT=2780.1n

* CHECK dout2_18 Vdout2_18ck138 = 0 time = 2780
.meas tran vdout2_18ck138 FIND v(dout2_18) AT=2780.1n

* CHECK dout2_19 Vdout2_19ck138 = 1.8 time = 2780
.meas tran vdout2_19ck138 FIND v(dout2_19) AT=2780.1n

* CHECK dout2_20 Vdout2_20ck138 = 1.8 time = 2780
.meas tran vdout2_20ck138 FIND v(dout2_20) AT=2780.1n

* CHECK dout2_21 Vdout2_21ck138 = 0 time = 2780
.meas tran vdout2_21ck138 FIND v(dout2_21) AT=2780.1n

* CHECK dout2_22 Vdout2_22ck138 = 1.8 time = 2780
.meas tran vdout2_22ck138 FIND v(dout2_22) AT=2780.1n

* CHECK dout2_23 Vdout2_23ck138 = 1.8 time = 2780
.meas tran vdout2_23ck138 FIND v(dout2_23) AT=2780.1n

* CHECK dout2_24 Vdout2_24ck138 = 1.8 time = 2780
.meas tran vdout2_24ck138 FIND v(dout2_24) AT=2780.1n

* CHECK dout2_25 Vdout2_25ck138 = 1.8 time = 2780
.meas tran vdout2_25ck138 FIND v(dout2_25) AT=2780.1n

* CHECK dout2_26 Vdout2_26ck138 = 1.8 time = 2780
.meas tran vdout2_26ck138 FIND v(dout2_26) AT=2780.1n

* CHECK dout2_27 Vdout2_27ck138 = 0 time = 2780
.meas tran vdout2_27ck138 FIND v(dout2_27) AT=2780.1n

* CHECK dout2_28 Vdout2_28ck138 = 1.8 time = 2780
.meas tran vdout2_28ck138 FIND v(dout2_28) AT=2780.1n

* CHECK dout2_29 Vdout2_29ck138 = 0 time = 2780
.meas tran vdout2_29ck138 FIND v(dout2_29) AT=2780.1n

* CHECK dout2_30 Vdout2_30ck138 = 0 time = 2780
.meas tran vdout2_30ck138 FIND v(dout2_30) AT=2780.1n

* CHECK dout2_31 Vdout2_31ck138 = 0 time = 2780
.meas tran vdout2_31ck138 FIND v(dout2_31) AT=2780.1n

* CHECK dout1_0 Vdout1_0ck139 = 0 time = 2800
.meas tran vdout1_0ck139 FIND v(dout1_0) AT=2800.1n

* CHECK dout1_1 Vdout1_1ck139 = 0 time = 2800
.meas tran vdout1_1ck139 FIND v(dout1_1) AT=2800.1n

* CHECK dout1_2 Vdout1_2ck139 = 1.8 time = 2800
.meas tran vdout1_2ck139 FIND v(dout1_2) AT=2800.1n

* CHECK dout1_3 Vdout1_3ck139 = 0 time = 2800
.meas tran vdout1_3ck139 FIND v(dout1_3) AT=2800.1n

* CHECK dout1_4 Vdout1_4ck139 = 0 time = 2800
.meas tran vdout1_4ck139 FIND v(dout1_4) AT=2800.1n

* CHECK dout1_5 Vdout1_5ck139 = 1.8 time = 2800
.meas tran vdout1_5ck139 FIND v(dout1_5) AT=2800.1n

* CHECK dout1_6 Vdout1_6ck139 = 1.8 time = 2800
.meas tran vdout1_6ck139 FIND v(dout1_6) AT=2800.1n

* CHECK dout1_7 Vdout1_7ck139 = 0 time = 2800
.meas tran vdout1_7ck139 FIND v(dout1_7) AT=2800.1n

* CHECK dout1_8 Vdout1_8ck139 = 0 time = 2800
.meas tran vdout1_8ck139 FIND v(dout1_8) AT=2800.1n

* CHECK dout1_9 Vdout1_9ck139 = 0 time = 2800
.meas tran vdout1_9ck139 FIND v(dout1_9) AT=2800.1n

* CHECK dout1_10 Vdout1_10ck139 = 1.8 time = 2800
.meas tran vdout1_10ck139 FIND v(dout1_10) AT=2800.1n

* CHECK dout1_11 Vdout1_11ck139 = 1.8 time = 2800
.meas tran vdout1_11ck139 FIND v(dout1_11) AT=2800.1n

* CHECK dout1_12 Vdout1_12ck139 = 1.8 time = 2800
.meas tran vdout1_12ck139 FIND v(dout1_12) AT=2800.1n

* CHECK dout1_13 Vdout1_13ck139 = 1.8 time = 2800
.meas tran vdout1_13ck139 FIND v(dout1_13) AT=2800.1n

* CHECK dout1_14 Vdout1_14ck139 = 0 time = 2800
.meas tran vdout1_14ck139 FIND v(dout1_14) AT=2800.1n

* CHECK dout1_15 Vdout1_15ck139 = 1.8 time = 2800
.meas tran vdout1_15ck139 FIND v(dout1_15) AT=2800.1n

* CHECK dout1_16 Vdout1_16ck139 = 0 time = 2800
.meas tran vdout1_16ck139 FIND v(dout1_16) AT=2800.1n

* CHECK dout1_17 Vdout1_17ck139 = 0 time = 2800
.meas tran vdout1_17ck139 FIND v(dout1_17) AT=2800.1n

* CHECK dout1_18 Vdout1_18ck139 = 0 time = 2800
.meas tran vdout1_18ck139 FIND v(dout1_18) AT=2800.1n

* CHECK dout1_19 Vdout1_19ck139 = 0 time = 2800
.meas tran vdout1_19ck139 FIND v(dout1_19) AT=2800.1n

* CHECK dout1_20 Vdout1_20ck139 = 1.8 time = 2800
.meas tran vdout1_20ck139 FIND v(dout1_20) AT=2800.1n

* CHECK dout1_21 Vdout1_21ck139 = 1.8 time = 2800
.meas tran vdout1_21ck139 FIND v(dout1_21) AT=2800.1n

* CHECK dout1_22 Vdout1_22ck139 = 1.8 time = 2800
.meas tran vdout1_22ck139 FIND v(dout1_22) AT=2800.1n

* CHECK dout1_23 Vdout1_23ck139 = 0 time = 2800
.meas tran vdout1_23ck139 FIND v(dout1_23) AT=2800.1n

* CHECK dout1_24 Vdout1_24ck139 = 0 time = 2800
.meas tran vdout1_24ck139 FIND v(dout1_24) AT=2800.1n

* CHECK dout1_25 Vdout1_25ck139 = 1.8 time = 2800
.meas tran vdout1_25ck139 FIND v(dout1_25) AT=2800.1n

* CHECK dout1_26 Vdout1_26ck139 = 0 time = 2800
.meas tran vdout1_26ck139 FIND v(dout1_26) AT=2800.1n

* CHECK dout1_27 Vdout1_27ck139 = 1.8 time = 2800
.meas tran vdout1_27ck139 FIND v(dout1_27) AT=2800.1n

* CHECK dout1_28 Vdout1_28ck139 = 0 time = 2800
.meas tran vdout1_28ck139 FIND v(dout1_28) AT=2800.1n

* CHECK dout1_29 Vdout1_29ck139 = 1.8 time = 2800
.meas tran vdout1_29ck139 FIND v(dout1_29) AT=2800.1n

* CHECK dout1_30 Vdout1_30ck139 = 0 time = 2800
.meas tran vdout1_30ck139 FIND v(dout1_30) AT=2800.1n

* CHECK dout1_31 Vdout1_31ck139 = 1.8 time = 2800
.meas tran vdout1_31ck139 FIND v(dout1_31) AT=2800.1n

* CHECK dout2_0 Vdout2_0ck139 = 0 time = 2800
.meas tran vdout2_0ck139 FIND v(dout2_0) AT=2800.1n

* CHECK dout2_1 Vdout2_1ck139 = 0 time = 2800
.meas tran vdout2_1ck139 FIND v(dout2_1) AT=2800.1n

* CHECK dout2_2 Vdout2_2ck139 = 1.8 time = 2800
.meas tran vdout2_2ck139 FIND v(dout2_2) AT=2800.1n

* CHECK dout2_3 Vdout2_3ck139 = 0 time = 2800
.meas tran vdout2_3ck139 FIND v(dout2_3) AT=2800.1n

* CHECK dout2_4 Vdout2_4ck139 = 0 time = 2800
.meas tran vdout2_4ck139 FIND v(dout2_4) AT=2800.1n

* CHECK dout2_5 Vdout2_5ck139 = 1.8 time = 2800
.meas tran vdout2_5ck139 FIND v(dout2_5) AT=2800.1n

* CHECK dout2_6 Vdout2_6ck139 = 1.8 time = 2800
.meas tran vdout2_6ck139 FIND v(dout2_6) AT=2800.1n

* CHECK dout2_7 Vdout2_7ck139 = 0 time = 2800
.meas tran vdout2_7ck139 FIND v(dout2_7) AT=2800.1n

* CHECK dout2_8 Vdout2_8ck139 = 0 time = 2800
.meas tran vdout2_8ck139 FIND v(dout2_8) AT=2800.1n

* CHECK dout2_9 Vdout2_9ck139 = 0 time = 2800
.meas tran vdout2_9ck139 FIND v(dout2_9) AT=2800.1n

* CHECK dout2_10 Vdout2_10ck139 = 1.8 time = 2800
.meas tran vdout2_10ck139 FIND v(dout2_10) AT=2800.1n

* CHECK dout2_11 Vdout2_11ck139 = 1.8 time = 2800
.meas tran vdout2_11ck139 FIND v(dout2_11) AT=2800.1n

* CHECK dout2_12 Vdout2_12ck139 = 1.8 time = 2800
.meas tran vdout2_12ck139 FIND v(dout2_12) AT=2800.1n

* CHECK dout2_13 Vdout2_13ck139 = 1.8 time = 2800
.meas tran vdout2_13ck139 FIND v(dout2_13) AT=2800.1n

* CHECK dout2_14 Vdout2_14ck139 = 0 time = 2800
.meas tran vdout2_14ck139 FIND v(dout2_14) AT=2800.1n

* CHECK dout2_15 Vdout2_15ck139 = 1.8 time = 2800
.meas tran vdout2_15ck139 FIND v(dout2_15) AT=2800.1n

* CHECK dout2_16 Vdout2_16ck139 = 0 time = 2800
.meas tran vdout2_16ck139 FIND v(dout2_16) AT=2800.1n

* CHECK dout2_17 Vdout2_17ck139 = 0 time = 2800
.meas tran vdout2_17ck139 FIND v(dout2_17) AT=2800.1n

* CHECK dout2_18 Vdout2_18ck139 = 0 time = 2800
.meas tran vdout2_18ck139 FIND v(dout2_18) AT=2800.1n

* CHECK dout2_19 Vdout2_19ck139 = 0 time = 2800
.meas tran vdout2_19ck139 FIND v(dout2_19) AT=2800.1n

* CHECK dout2_20 Vdout2_20ck139 = 1.8 time = 2800
.meas tran vdout2_20ck139 FIND v(dout2_20) AT=2800.1n

* CHECK dout2_21 Vdout2_21ck139 = 1.8 time = 2800
.meas tran vdout2_21ck139 FIND v(dout2_21) AT=2800.1n

* CHECK dout2_22 Vdout2_22ck139 = 1.8 time = 2800
.meas tran vdout2_22ck139 FIND v(dout2_22) AT=2800.1n

* CHECK dout2_23 Vdout2_23ck139 = 0 time = 2800
.meas tran vdout2_23ck139 FIND v(dout2_23) AT=2800.1n

* CHECK dout2_24 Vdout2_24ck139 = 0 time = 2800
.meas tran vdout2_24ck139 FIND v(dout2_24) AT=2800.1n

* CHECK dout2_25 Vdout2_25ck139 = 1.8 time = 2800
.meas tran vdout2_25ck139 FIND v(dout2_25) AT=2800.1n

* CHECK dout2_26 Vdout2_26ck139 = 0 time = 2800
.meas tran vdout2_26ck139 FIND v(dout2_26) AT=2800.1n

* CHECK dout2_27 Vdout2_27ck139 = 1.8 time = 2800
.meas tran vdout2_27ck139 FIND v(dout2_27) AT=2800.1n

* CHECK dout2_28 Vdout2_28ck139 = 0 time = 2800
.meas tran vdout2_28ck139 FIND v(dout2_28) AT=2800.1n

* CHECK dout2_29 Vdout2_29ck139 = 1.8 time = 2800
.meas tran vdout2_29ck139 FIND v(dout2_29) AT=2800.1n

* CHECK dout2_30 Vdout2_30ck139 = 0 time = 2800
.meas tran vdout2_30ck139 FIND v(dout2_30) AT=2800.1n

* CHECK dout2_31 Vdout2_31ck139 = 1.8 time = 2800
.meas tran vdout2_31ck139 FIND v(dout2_31) AT=2800.1n

* CHECK dout1_0 Vdout1_0ck140 = 1.8 time = 2820
.meas tran vdout1_0ck140 FIND v(dout1_0) AT=2820.1n

* CHECK dout1_1 Vdout1_1ck140 = 0 time = 2820
.meas tran vdout1_1ck140 FIND v(dout1_1) AT=2820.1n

* CHECK dout1_2 Vdout1_2ck140 = 0 time = 2820
.meas tran vdout1_2ck140 FIND v(dout1_2) AT=2820.1n

* CHECK dout1_3 Vdout1_3ck140 = 0 time = 2820
.meas tran vdout1_3ck140 FIND v(dout1_3) AT=2820.1n

* CHECK dout1_4 Vdout1_4ck140 = 1.8 time = 2820
.meas tran vdout1_4ck140 FIND v(dout1_4) AT=2820.1n

* CHECK dout1_5 Vdout1_5ck140 = 1.8 time = 2820
.meas tran vdout1_5ck140 FIND v(dout1_5) AT=2820.1n

* CHECK dout1_6 Vdout1_6ck140 = 1.8 time = 2820
.meas tran vdout1_6ck140 FIND v(dout1_6) AT=2820.1n

* CHECK dout1_7 Vdout1_7ck140 = 0 time = 2820
.meas tran vdout1_7ck140 FIND v(dout1_7) AT=2820.1n

* CHECK dout1_8 Vdout1_8ck140 = 0 time = 2820
.meas tran vdout1_8ck140 FIND v(dout1_8) AT=2820.1n

* CHECK dout1_9 Vdout1_9ck140 = 0 time = 2820
.meas tran vdout1_9ck140 FIND v(dout1_9) AT=2820.1n

* CHECK dout1_10 Vdout1_10ck140 = 1.8 time = 2820
.meas tran vdout1_10ck140 FIND v(dout1_10) AT=2820.1n

* CHECK dout1_11 Vdout1_11ck140 = 0 time = 2820
.meas tran vdout1_11ck140 FIND v(dout1_11) AT=2820.1n

* CHECK dout1_12 Vdout1_12ck140 = 1.8 time = 2820
.meas tran vdout1_12ck140 FIND v(dout1_12) AT=2820.1n

* CHECK dout1_13 Vdout1_13ck140 = 0 time = 2820
.meas tran vdout1_13ck140 FIND v(dout1_13) AT=2820.1n

* CHECK dout1_14 Vdout1_14ck140 = 1.8 time = 2820
.meas tran vdout1_14ck140 FIND v(dout1_14) AT=2820.1n

* CHECK dout1_15 Vdout1_15ck140 = 0 time = 2820
.meas tran vdout1_15ck140 FIND v(dout1_15) AT=2820.1n

* CHECK dout1_16 Vdout1_16ck140 = 0 time = 2820
.meas tran vdout1_16ck140 FIND v(dout1_16) AT=2820.1n

* CHECK dout1_17 Vdout1_17ck140 = 1.8 time = 2820
.meas tran vdout1_17ck140 FIND v(dout1_17) AT=2820.1n

* CHECK dout1_18 Vdout1_18ck140 = 1.8 time = 2820
.meas tran vdout1_18ck140 FIND v(dout1_18) AT=2820.1n

* CHECK dout1_19 Vdout1_19ck140 = 1.8 time = 2820
.meas tran vdout1_19ck140 FIND v(dout1_19) AT=2820.1n

* CHECK dout1_20 Vdout1_20ck140 = 0 time = 2820
.meas tran vdout1_20ck140 FIND v(dout1_20) AT=2820.1n

* CHECK dout1_21 Vdout1_21ck140 = 1.8 time = 2820
.meas tran vdout1_21ck140 FIND v(dout1_21) AT=2820.1n

* CHECK dout1_22 Vdout1_22ck140 = 0 time = 2820
.meas tran vdout1_22ck140 FIND v(dout1_22) AT=2820.1n

* CHECK dout1_23 Vdout1_23ck140 = 1.8 time = 2820
.meas tran vdout1_23ck140 FIND v(dout1_23) AT=2820.1n

* CHECK dout1_24 Vdout1_24ck140 = 1.8 time = 2820
.meas tran vdout1_24ck140 FIND v(dout1_24) AT=2820.1n

* CHECK dout1_25 Vdout1_25ck140 = 0 time = 2820
.meas tran vdout1_25ck140 FIND v(dout1_25) AT=2820.1n

* CHECK dout1_26 Vdout1_26ck140 = 0 time = 2820
.meas tran vdout1_26ck140 FIND v(dout1_26) AT=2820.1n

* CHECK dout1_27 Vdout1_27ck140 = 0 time = 2820
.meas tran vdout1_27ck140 FIND v(dout1_27) AT=2820.1n

* CHECK dout1_28 Vdout1_28ck140 = 0 time = 2820
.meas tran vdout1_28ck140 FIND v(dout1_28) AT=2820.1n

* CHECK dout1_29 Vdout1_29ck140 = 1.8 time = 2820
.meas tran vdout1_29ck140 FIND v(dout1_29) AT=2820.1n

* CHECK dout1_30 Vdout1_30ck140 = 1.8 time = 2820
.meas tran vdout1_30ck140 FIND v(dout1_30) AT=2820.1n

* CHECK dout1_31 Vdout1_31ck140 = 0 time = 2820
.meas tran vdout1_31ck140 FIND v(dout1_31) AT=2820.1n

* CHECK dout2_0 Vdout2_0ck140 = 0 time = 2820
.meas tran vdout2_0ck140 FIND v(dout2_0) AT=2820.1n

* CHECK dout2_1 Vdout2_1ck140 = 0 time = 2820
.meas tran vdout2_1ck140 FIND v(dout2_1) AT=2820.1n

* CHECK dout2_2 Vdout2_2ck140 = 1.8 time = 2820
.meas tran vdout2_2ck140 FIND v(dout2_2) AT=2820.1n

* CHECK dout2_3 Vdout2_3ck140 = 0 time = 2820
.meas tran vdout2_3ck140 FIND v(dout2_3) AT=2820.1n

* CHECK dout2_4 Vdout2_4ck140 = 0 time = 2820
.meas tran vdout2_4ck140 FIND v(dout2_4) AT=2820.1n

* CHECK dout2_5 Vdout2_5ck140 = 1.8 time = 2820
.meas tran vdout2_5ck140 FIND v(dout2_5) AT=2820.1n

* CHECK dout2_6 Vdout2_6ck140 = 1.8 time = 2820
.meas tran vdout2_6ck140 FIND v(dout2_6) AT=2820.1n

* CHECK dout2_7 Vdout2_7ck140 = 0 time = 2820
.meas tran vdout2_7ck140 FIND v(dout2_7) AT=2820.1n

* CHECK dout2_8 Vdout2_8ck140 = 0 time = 2820
.meas tran vdout2_8ck140 FIND v(dout2_8) AT=2820.1n

* CHECK dout2_9 Vdout2_9ck140 = 0 time = 2820
.meas tran vdout2_9ck140 FIND v(dout2_9) AT=2820.1n

* CHECK dout2_10 Vdout2_10ck140 = 1.8 time = 2820
.meas tran vdout2_10ck140 FIND v(dout2_10) AT=2820.1n

* CHECK dout2_11 Vdout2_11ck140 = 1.8 time = 2820
.meas tran vdout2_11ck140 FIND v(dout2_11) AT=2820.1n

* CHECK dout2_12 Vdout2_12ck140 = 1.8 time = 2820
.meas tran vdout2_12ck140 FIND v(dout2_12) AT=2820.1n

* CHECK dout2_13 Vdout2_13ck140 = 1.8 time = 2820
.meas tran vdout2_13ck140 FIND v(dout2_13) AT=2820.1n

* CHECK dout2_14 Vdout2_14ck140 = 0 time = 2820
.meas tran vdout2_14ck140 FIND v(dout2_14) AT=2820.1n

* CHECK dout2_15 Vdout2_15ck140 = 1.8 time = 2820
.meas tran vdout2_15ck140 FIND v(dout2_15) AT=2820.1n

* CHECK dout2_16 Vdout2_16ck140 = 0 time = 2820
.meas tran vdout2_16ck140 FIND v(dout2_16) AT=2820.1n

* CHECK dout2_17 Vdout2_17ck140 = 0 time = 2820
.meas tran vdout2_17ck140 FIND v(dout2_17) AT=2820.1n

* CHECK dout2_18 Vdout2_18ck140 = 0 time = 2820
.meas tran vdout2_18ck140 FIND v(dout2_18) AT=2820.1n

* CHECK dout2_19 Vdout2_19ck140 = 0 time = 2820
.meas tran vdout2_19ck140 FIND v(dout2_19) AT=2820.1n

* CHECK dout2_20 Vdout2_20ck140 = 1.8 time = 2820
.meas tran vdout2_20ck140 FIND v(dout2_20) AT=2820.1n

* CHECK dout2_21 Vdout2_21ck140 = 1.8 time = 2820
.meas tran vdout2_21ck140 FIND v(dout2_21) AT=2820.1n

* CHECK dout2_22 Vdout2_22ck140 = 1.8 time = 2820
.meas tran vdout2_22ck140 FIND v(dout2_22) AT=2820.1n

* CHECK dout2_23 Vdout2_23ck140 = 0 time = 2820
.meas tran vdout2_23ck140 FIND v(dout2_23) AT=2820.1n

* CHECK dout2_24 Vdout2_24ck140 = 0 time = 2820
.meas tran vdout2_24ck140 FIND v(dout2_24) AT=2820.1n

* CHECK dout2_25 Vdout2_25ck140 = 1.8 time = 2820
.meas tran vdout2_25ck140 FIND v(dout2_25) AT=2820.1n

* CHECK dout2_26 Vdout2_26ck140 = 0 time = 2820
.meas tran vdout2_26ck140 FIND v(dout2_26) AT=2820.1n

* CHECK dout2_27 Vdout2_27ck140 = 1.8 time = 2820
.meas tran vdout2_27ck140 FIND v(dout2_27) AT=2820.1n

* CHECK dout2_28 Vdout2_28ck140 = 0 time = 2820
.meas tran vdout2_28ck140 FIND v(dout2_28) AT=2820.1n

* CHECK dout2_29 Vdout2_29ck140 = 1.8 time = 2820
.meas tran vdout2_29ck140 FIND v(dout2_29) AT=2820.1n

* CHECK dout2_30 Vdout2_30ck140 = 0 time = 2820
.meas tran vdout2_30ck140 FIND v(dout2_30) AT=2820.1n

* CHECK dout2_31 Vdout2_31ck140 = 1.8 time = 2820
.meas tran vdout2_31ck140 FIND v(dout2_31) AT=2820.1n

* CHECK dout1_0 Vdout1_0ck141 = 1.8 time = 2840
.meas tran vdout1_0ck141 FIND v(dout1_0) AT=2840.1n

* CHECK dout1_1 Vdout1_1ck141 = 1.8 time = 2840
.meas tran vdout1_1ck141 FIND v(dout1_1) AT=2840.1n

* CHECK dout1_2 Vdout1_2ck141 = 1.8 time = 2840
.meas tran vdout1_2ck141 FIND v(dout1_2) AT=2840.1n

* CHECK dout1_3 Vdout1_3ck141 = 0 time = 2840
.meas tran vdout1_3ck141 FIND v(dout1_3) AT=2840.1n

* CHECK dout1_4 Vdout1_4ck141 = 1.8 time = 2840
.meas tran vdout1_4ck141 FIND v(dout1_4) AT=2840.1n

* CHECK dout1_5 Vdout1_5ck141 = 1.8 time = 2840
.meas tran vdout1_5ck141 FIND v(dout1_5) AT=2840.1n

* CHECK dout1_6 Vdout1_6ck141 = 0 time = 2840
.meas tran vdout1_6ck141 FIND v(dout1_6) AT=2840.1n

* CHECK dout1_7 Vdout1_7ck141 = 1.8 time = 2840
.meas tran vdout1_7ck141 FIND v(dout1_7) AT=2840.1n

* CHECK dout1_8 Vdout1_8ck141 = 1.8 time = 2840
.meas tran vdout1_8ck141 FIND v(dout1_8) AT=2840.1n

* CHECK dout1_9 Vdout1_9ck141 = 1.8 time = 2840
.meas tran vdout1_9ck141 FIND v(dout1_9) AT=2840.1n

* CHECK dout1_10 Vdout1_10ck141 = 1.8 time = 2840
.meas tran vdout1_10ck141 FIND v(dout1_10) AT=2840.1n

* CHECK dout1_11 Vdout1_11ck141 = 0 time = 2840
.meas tran vdout1_11ck141 FIND v(dout1_11) AT=2840.1n

* CHECK dout1_12 Vdout1_12ck141 = 0 time = 2840
.meas tran vdout1_12ck141 FIND v(dout1_12) AT=2840.1n

* CHECK dout1_13 Vdout1_13ck141 = 0 time = 2840
.meas tran vdout1_13ck141 FIND v(dout1_13) AT=2840.1n

* CHECK dout1_14 Vdout1_14ck141 = 0 time = 2840
.meas tran vdout1_14ck141 FIND v(dout1_14) AT=2840.1n

* CHECK dout1_15 Vdout1_15ck141 = 1.8 time = 2840
.meas tran vdout1_15ck141 FIND v(dout1_15) AT=2840.1n

* CHECK dout1_16 Vdout1_16ck141 = 0 time = 2840
.meas tran vdout1_16ck141 FIND v(dout1_16) AT=2840.1n

* CHECK dout1_17 Vdout1_17ck141 = 1.8 time = 2840
.meas tran vdout1_17ck141 FIND v(dout1_17) AT=2840.1n

* CHECK dout1_18 Vdout1_18ck141 = 0 time = 2840
.meas tran vdout1_18ck141 FIND v(dout1_18) AT=2840.1n

* CHECK dout1_19 Vdout1_19ck141 = 0 time = 2840
.meas tran vdout1_19ck141 FIND v(dout1_19) AT=2840.1n

* CHECK dout1_20 Vdout1_20ck141 = 1.8 time = 2840
.meas tran vdout1_20ck141 FIND v(dout1_20) AT=2840.1n

* CHECK dout1_21 Vdout1_21ck141 = 1.8 time = 2840
.meas tran vdout1_21ck141 FIND v(dout1_21) AT=2840.1n

* CHECK dout1_22 Vdout1_22ck141 = 1.8 time = 2840
.meas tran vdout1_22ck141 FIND v(dout1_22) AT=2840.1n

* CHECK dout1_23 Vdout1_23ck141 = 0 time = 2840
.meas tran vdout1_23ck141 FIND v(dout1_23) AT=2840.1n

* CHECK dout1_24 Vdout1_24ck141 = 0 time = 2840
.meas tran vdout1_24ck141 FIND v(dout1_24) AT=2840.1n

* CHECK dout1_25 Vdout1_25ck141 = 0 time = 2840
.meas tran vdout1_25ck141 FIND v(dout1_25) AT=2840.1n

* CHECK dout1_26 Vdout1_26ck141 = 0 time = 2840
.meas tran vdout1_26ck141 FIND v(dout1_26) AT=2840.1n

* CHECK dout1_27 Vdout1_27ck141 = 0 time = 2840
.meas tran vdout1_27ck141 FIND v(dout1_27) AT=2840.1n

* CHECK dout1_28 Vdout1_28ck141 = 0 time = 2840
.meas tran vdout1_28ck141 FIND v(dout1_28) AT=2840.1n

* CHECK dout1_29 Vdout1_29ck141 = 1.8 time = 2840
.meas tran vdout1_29ck141 FIND v(dout1_29) AT=2840.1n

* CHECK dout1_30 Vdout1_30ck141 = 1.8 time = 2840
.meas tran vdout1_30ck141 FIND v(dout1_30) AT=2840.1n

* CHECK dout1_31 Vdout1_31ck141 = 1.8 time = 2840
.meas tran vdout1_31ck141 FIND v(dout1_31) AT=2840.1n

* CHECK dout2_0 Vdout2_0ck141 = 1.8 time = 2840
.meas tran vdout2_0ck141 FIND v(dout2_0) AT=2840.1n

* CHECK dout2_1 Vdout2_1ck141 = 1.8 time = 2840
.meas tran vdout2_1ck141 FIND v(dout2_1) AT=2840.1n

* CHECK dout2_2 Vdout2_2ck141 = 1.8 time = 2840
.meas tran vdout2_2ck141 FIND v(dout2_2) AT=2840.1n

* CHECK dout2_3 Vdout2_3ck141 = 0 time = 2840
.meas tran vdout2_3ck141 FIND v(dout2_3) AT=2840.1n

* CHECK dout2_4 Vdout2_4ck141 = 1.8 time = 2840
.meas tran vdout2_4ck141 FIND v(dout2_4) AT=2840.1n

* CHECK dout2_5 Vdout2_5ck141 = 1.8 time = 2840
.meas tran vdout2_5ck141 FIND v(dout2_5) AT=2840.1n

* CHECK dout2_6 Vdout2_6ck141 = 0 time = 2840
.meas tran vdout2_6ck141 FIND v(dout2_6) AT=2840.1n

* CHECK dout2_7 Vdout2_7ck141 = 1.8 time = 2840
.meas tran vdout2_7ck141 FIND v(dout2_7) AT=2840.1n

* CHECK dout2_8 Vdout2_8ck141 = 1.8 time = 2840
.meas tran vdout2_8ck141 FIND v(dout2_8) AT=2840.1n

* CHECK dout2_9 Vdout2_9ck141 = 1.8 time = 2840
.meas tran vdout2_9ck141 FIND v(dout2_9) AT=2840.1n

* CHECK dout2_10 Vdout2_10ck141 = 1.8 time = 2840
.meas tran vdout2_10ck141 FIND v(dout2_10) AT=2840.1n

* CHECK dout2_11 Vdout2_11ck141 = 0 time = 2840
.meas tran vdout2_11ck141 FIND v(dout2_11) AT=2840.1n

* CHECK dout2_12 Vdout2_12ck141 = 0 time = 2840
.meas tran vdout2_12ck141 FIND v(dout2_12) AT=2840.1n

* CHECK dout2_13 Vdout2_13ck141 = 0 time = 2840
.meas tran vdout2_13ck141 FIND v(dout2_13) AT=2840.1n

* CHECK dout2_14 Vdout2_14ck141 = 0 time = 2840
.meas tran vdout2_14ck141 FIND v(dout2_14) AT=2840.1n

* CHECK dout2_15 Vdout2_15ck141 = 1.8 time = 2840
.meas tran vdout2_15ck141 FIND v(dout2_15) AT=2840.1n

* CHECK dout2_16 Vdout2_16ck141 = 0 time = 2840
.meas tran vdout2_16ck141 FIND v(dout2_16) AT=2840.1n

* CHECK dout2_17 Vdout2_17ck141 = 1.8 time = 2840
.meas tran vdout2_17ck141 FIND v(dout2_17) AT=2840.1n

* CHECK dout2_18 Vdout2_18ck141 = 0 time = 2840
.meas tran vdout2_18ck141 FIND v(dout2_18) AT=2840.1n

* CHECK dout2_19 Vdout2_19ck141 = 0 time = 2840
.meas tran vdout2_19ck141 FIND v(dout2_19) AT=2840.1n

* CHECK dout2_20 Vdout2_20ck141 = 1.8 time = 2840
.meas tran vdout2_20ck141 FIND v(dout2_20) AT=2840.1n

* CHECK dout2_21 Vdout2_21ck141 = 1.8 time = 2840
.meas tran vdout2_21ck141 FIND v(dout2_21) AT=2840.1n

* CHECK dout2_22 Vdout2_22ck141 = 1.8 time = 2840
.meas tran vdout2_22ck141 FIND v(dout2_22) AT=2840.1n

* CHECK dout2_23 Vdout2_23ck141 = 0 time = 2840
.meas tran vdout2_23ck141 FIND v(dout2_23) AT=2840.1n

* CHECK dout2_24 Vdout2_24ck141 = 0 time = 2840
.meas tran vdout2_24ck141 FIND v(dout2_24) AT=2840.1n

* CHECK dout2_25 Vdout2_25ck141 = 0 time = 2840
.meas tran vdout2_25ck141 FIND v(dout2_25) AT=2840.1n

* CHECK dout2_26 Vdout2_26ck141 = 0 time = 2840
.meas tran vdout2_26ck141 FIND v(dout2_26) AT=2840.1n

* CHECK dout2_27 Vdout2_27ck141 = 0 time = 2840
.meas tran vdout2_27ck141 FIND v(dout2_27) AT=2840.1n

* CHECK dout2_28 Vdout2_28ck141 = 0 time = 2840
.meas tran vdout2_28ck141 FIND v(dout2_28) AT=2840.1n

* CHECK dout2_29 Vdout2_29ck141 = 1.8 time = 2840
.meas tran vdout2_29ck141 FIND v(dout2_29) AT=2840.1n

* CHECK dout2_30 Vdout2_30ck141 = 1.8 time = 2840
.meas tran vdout2_30ck141 FIND v(dout2_30) AT=2840.1n

* CHECK dout2_31 Vdout2_31ck141 = 1.8 time = 2840
.meas tran vdout2_31ck141 FIND v(dout2_31) AT=2840.1n

* CHECK dout1_0 Vdout1_0ck142 = 1.8 time = 2860
.meas tran vdout1_0ck142 FIND v(dout1_0) AT=2860.1n

* CHECK dout1_1 Vdout1_1ck142 = 1.8 time = 2860
.meas tran vdout1_1ck142 FIND v(dout1_1) AT=2860.1n

* CHECK dout1_2 Vdout1_2ck142 = 1.8 time = 2860
.meas tran vdout1_2ck142 FIND v(dout1_2) AT=2860.1n

* CHECK dout1_3 Vdout1_3ck142 = 0 time = 2860
.meas tran vdout1_3ck142 FIND v(dout1_3) AT=2860.1n

* CHECK dout1_4 Vdout1_4ck142 = 1.8 time = 2860
.meas tran vdout1_4ck142 FIND v(dout1_4) AT=2860.1n

* CHECK dout1_5 Vdout1_5ck142 = 1.8 time = 2860
.meas tran vdout1_5ck142 FIND v(dout1_5) AT=2860.1n

* CHECK dout1_6 Vdout1_6ck142 = 0 time = 2860
.meas tran vdout1_6ck142 FIND v(dout1_6) AT=2860.1n

* CHECK dout1_7 Vdout1_7ck142 = 1.8 time = 2860
.meas tran vdout1_7ck142 FIND v(dout1_7) AT=2860.1n

* CHECK dout1_8 Vdout1_8ck142 = 1.8 time = 2860
.meas tran vdout1_8ck142 FIND v(dout1_8) AT=2860.1n

* CHECK dout1_9 Vdout1_9ck142 = 1.8 time = 2860
.meas tran vdout1_9ck142 FIND v(dout1_9) AT=2860.1n

* CHECK dout1_10 Vdout1_10ck142 = 1.8 time = 2860
.meas tran vdout1_10ck142 FIND v(dout1_10) AT=2860.1n

* CHECK dout1_11 Vdout1_11ck142 = 0 time = 2860
.meas tran vdout1_11ck142 FIND v(dout1_11) AT=2860.1n

* CHECK dout1_12 Vdout1_12ck142 = 0 time = 2860
.meas tran vdout1_12ck142 FIND v(dout1_12) AT=2860.1n

* CHECK dout1_13 Vdout1_13ck142 = 0 time = 2860
.meas tran vdout1_13ck142 FIND v(dout1_13) AT=2860.1n

* CHECK dout1_14 Vdout1_14ck142 = 0 time = 2860
.meas tran vdout1_14ck142 FIND v(dout1_14) AT=2860.1n

* CHECK dout1_15 Vdout1_15ck142 = 1.8 time = 2860
.meas tran vdout1_15ck142 FIND v(dout1_15) AT=2860.1n

* CHECK dout1_16 Vdout1_16ck142 = 0 time = 2860
.meas tran vdout1_16ck142 FIND v(dout1_16) AT=2860.1n

* CHECK dout1_17 Vdout1_17ck142 = 1.8 time = 2860
.meas tran vdout1_17ck142 FIND v(dout1_17) AT=2860.1n

* CHECK dout1_18 Vdout1_18ck142 = 0 time = 2860
.meas tran vdout1_18ck142 FIND v(dout1_18) AT=2860.1n

* CHECK dout1_19 Vdout1_19ck142 = 0 time = 2860
.meas tran vdout1_19ck142 FIND v(dout1_19) AT=2860.1n

* CHECK dout1_20 Vdout1_20ck142 = 1.8 time = 2860
.meas tran vdout1_20ck142 FIND v(dout1_20) AT=2860.1n

* CHECK dout1_21 Vdout1_21ck142 = 1.8 time = 2860
.meas tran vdout1_21ck142 FIND v(dout1_21) AT=2860.1n

* CHECK dout1_22 Vdout1_22ck142 = 1.8 time = 2860
.meas tran vdout1_22ck142 FIND v(dout1_22) AT=2860.1n

* CHECK dout1_23 Vdout1_23ck142 = 0 time = 2860
.meas tran vdout1_23ck142 FIND v(dout1_23) AT=2860.1n

* CHECK dout1_24 Vdout1_24ck142 = 0 time = 2860
.meas tran vdout1_24ck142 FIND v(dout1_24) AT=2860.1n

* CHECK dout1_25 Vdout1_25ck142 = 0 time = 2860
.meas tran vdout1_25ck142 FIND v(dout1_25) AT=2860.1n

* CHECK dout1_26 Vdout1_26ck142 = 0 time = 2860
.meas tran vdout1_26ck142 FIND v(dout1_26) AT=2860.1n

* CHECK dout1_27 Vdout1_27ck142 = 0 time = 2860
.meas tran vdout1_27ck142 FIND v(dout1_27) AT=2860.1n

* CHECK dout1_28 Vdout1_28ck142 = 0 time = 2860
.meas tran vdout1_28ck142 FIND v(dout1_28) AT=2860.1n

* CHECK dout1_29 Vdout1_29ck142 = 1.8 time = 2860
.meas tran vdout1_29ck142 FIND v(dout1_29) AT=2860.1n

* CHECK dout1_30 Vdout1_30ck142 = 1.8 time = 2860
.meas tran vdout1_30ck142 FIND v(dout1_30) AT=2860.1n

* CHECK dout1_31 Vdout1_31ck142 = 1.8 time = 2860
.meas tran vdout1_31ck142 FIND v(dout1_31) AT=2860.1n

* CHECK dout1_0 Vdout1_0ck143 = 1.8 time = 2880
.meas tran vdout1_0ck143 FIND v(dout1_0) AT=2880.1n

* CHECK dout1_1 Vdout1_1ck143 = 1.8 time = 2880
.meas tran vdout1_1ck143 FIND v(dout1_1) AT=2880.1n

* CHECK dout1_2 Vdout1_2ck143 = 1.8 time = 2880
.meas tran vdout1_2ck143 FIND v(dout1_2) AT=2880.1n

* CHECK dout1_3 Vdout1_3ck143 = 0 time = 2880
.meas tran vdout1_3ck143 FIND v(dout1_3) AT=2880.1n

* CHECK dout1_4 Vdout1_4ck143 = 1.8 time = 2880
.meas tran vdout1_4ck143 FIND v(dout1_4) AT=2880.1n

* CHECK dout1_5 Vdout1_5ck143 = 1.8 time = 2880
.meas tran vdout1_5ck143 FIND v(dout1_5) AT=2880.1n

* CHECK dout1_6 Vdout1_6ck143 = 0 time = 2880
.meas tran vdout1_6ck143 FIND v(dout1_6) AT=2880.1n

* CHECK dout1_7 Vdout1_7ck143 = 1.8 time = 2880
.meas tran vdout1_7ck143 FIND v(dout1_7) AT=2880.1n

* CHECK dout1_8 Vdout1_8ck143 = 1.8 time = 2880
.meas tran vdout1_8ck143 FIND v(dout1_8) AT=2880.1n

* CHECK dout1_9 Vdout1_9ck143 = 1.8 time = 2880
.meas tran vdout1_9ck143 FIND v(dout1_9) AT=2880.1n

* CHECK dout1_10 Vdout1_10ck143 = 1.8 time = 2880
.meas tran vdout1_10ck143 FIND v(dout1_10) AT=2880.1n

* CHECK dout1_11 Vdout1_11ck143 = 0 time = 2880
.meas tran vdout1_11ck143 FIND v(dout1_11) AT=2880.1n

* CHECK dout1_12 Vdout1_12ck143 = 0 time = 2880
.meas tran vdout1_12ck143 FIND v(dout1_12) AT=2880.1n

* CHECK dout1_13 Vdout1_13ck143 = 0 time = 2880
.meas tran vdout1_13ck143 FIND v(dout1_13) AT=2880.1n

* CHECK dout1_14 Vdout1_14ck143 = 0 time = 2880
.meas tran vdout1_14ck143 FIND v(dout1_14) AT=2880.1n

* CHECK dout1_15 Vdout1_15ck143 = 1.8 time = 2880
.meas tran vdout1_15ck143 FIND v(dout1_15) AT=2880.1n

* CHECK dout1_16 Vdout1_16ck143 = 0 time = 2880
.meas tran vdout1_16ck143 FIND v(dout1_16) AT=2880.1n

* CHECK dout1_17 Vdout1_17ck143 = 1.8 time = 2880
.meas tran vdout1_17ck143 FIND v(dout1_17) AT=2880.1n

* CHECK dout1_18 Vdout1_18ck143 = 0 time = 2880
.meas tran vdout1_18ck143 FIND v(dout1_18) AT=2880.1n

* CHECK dout1_19 Vdout1_19ck143 = 0 time = 2880
.meas tran vdout1_19ck143 FIND v(dout1_19) AT=2880.1n

* CHECK dout1_20 Vdout1_20ck143 = 1.8 time = 2880
.meas tran vdout1_20ck143 FIND v(dout1_20) AT=2880.1n

* CHECK dout1_21 Vdout1_21ck143 = 1.8 time = 2880
.meas tran vdout1_21ck143 FIND v(dout1_21) AT=2880.1n

* CHECK dout1_22 Vdout1_22ck143 = 1.8 time = 2880
.meas tran vdout1_22ck143 FIND v(dout1_22) AT=2880.1n

* CHECK dout1_23 Vdout1_23ck143 = 0 time = 2880
.meas tran vdout1_23ck143 FIND v(dout1_23) AT=2880.1n

* CHECK dout1_24 Vdout1_24ck143 = 0 time = 2880
.meas tran vdout1_24ck143 FIND v(dout1_24) AT=2880.1n

* CHECK dout1_25 Vdout1_25ck143 = 0 time = 2880
.meas tran vdout1_25ck143 FIND v(dout1_25) AT=2880.1n

* CHECK dout1_26 Vdout1_26ck143 = 0 time = 2880
.meas tran vdout1_26ck143 FIND v(dout1_26) AT=2880.1n

* CHECK dout1_27 Vdout1_27ck143 = 0 time = 2880
.meas tran vdout1_27ck143 FIND v(dout1_27) AT=2880.1n

* CHECK dout1_28 Vdout1_28ck143 = 0 time = 2880
.meas tran vdout1_28ck143 FIND v(dout1_28) AT=2880.1n

* CHECK dout1_29 Vdout1_29ck143 = 1.8 time = 2880
.meas tran vdout1_29ck143 FIND v(dout1_29) AT=2880.1n

* CHECK dout1_30 Vdout1_30ck143 = 1.8 time = 2880
.meas tran vdout1_30ck143 FIND v(dout1_30) AT=2880.1n

* CHECK dout1_31 Vdout1_31ck143 = 1.8 time = 2880
.meas tran vdout1_31ck143 FIND v(dout1_31) AT=2880.1n

* CHECK dout2_0 Vdout2_0ck143 = 0 time = 2880
.meas tran vdout2_0ck143 FIND v(dout2_0) AT=2880.1n

* CHECK dout2_1 Vdout2_1ck143 = 0 time = 2880
.meas tran vdout2_1ck143 FIND v(dout2_1) AT=2880.1n

* CHECK dout2_2 Vdout2_2ck143 = 1.8 time = 2880
.meas tran vdout2_2ck143 FIND v(dout2_2) AT=2880.1n

* CHECK dout2_3 Vdout2_3ck143 = 0 time = 2880
.meas tran vdout2_3ck143 FIND v(dout2_3) AT=2880.1n

* CHECK dout2_4 Vdout2_4ck143 = 0 time = 2880
.meas tran vdout2_4ck143 FIND v(dout2_4) AT=2880.1n

* CHECK dout2_5 Vdout2_5ck143 = 1.8 time = 2880
.meas tran vdout2_5ck143 FIND v(dout2_5) AT=2880.1n

* CHECK dout2_6 Vdout2_6ck143 = 1.8 time = 2880
.meas tran vdout2_6ck143 FIND v(dout2_6) AT=2880.1n

* CHECK dout2_7 Vdout2_7ck143 = 0 time = 2880
.meas tran vdout2_7ck143 FIND v(dout2_7) AT=2880.1n

* CHECK dout2_8 Vdout2_8ck143 = 0 time = 2880
.meas tran vdout2_8ck143 FIND v(dout2_8) AT=2880.1n

* CHECK dout2_9 Vdout2_9ck143 = 0 time = 2880
.meas tran vdout2_9ck143 FIND v(dout2_9) AT=2880.1n

* CHECK dout2_10 Vdout2_10ck143 = 1.8 time = 2880
.meas tran vdout2_10ck143 FIND v(dout2_10) AT=2880.1n

* CHECK dout2_11 Vdout2_11ck143 = 1.8 time = 2880
.meas tran vdout2_11ck143 FIND v(dout2_11) AT=2880.1n

* CHECK dout2_12 Vdout2_12ck143 = 1.8 time = 2880
.meas tran vdout2_12ck143 FIND v(dout2_12) AT=2880.1n

* CHECK dout2_13 Vdout2_13ck143 = 1.8 time = 2880
.meas tran vdout2_13ck143 FIND v(dout2_13) AT=2880.1n

* CHECK dout2_14 Vdout2_14ck143 = 0 time = 2880
.meas tran vdout2_14ck143 FIND v(dout2_14) AT=2880.1n

* CHECK dout2_15 Vdout2_15ck143 = 1.8 time = 2880
.meas tran vdout2_15ck143 FIND v(dout2_15) AT=2880.1n

* CHECK dout2_16 Vdout2_16ck143 = 0 time = 2880
.meas tran vdout2_16ck143 FIND v(dout2_16) AT=2880.1n

* CHECK dout2_17 Vdout2_17ck143 = 0 time = 2880
.meas tran vdout2_17ck143 FIND v(dout2_17) AT=2880.1n

* CHECK dout2_18 Vdout2_18ck143 = 0 time = 2880
.meas tran vdout2_18ck143 FIND v(dout2_18) AT=2880.1n

* CHECK dout2_19 Vdout2_19ck143 = 0 time = 2880
.meas tran vdout2_19ck143 FIND v(dout2_19) AT=2880.1n

* CHECK dout2_20 Vdout2_20ck143 = 1.8 time = 2880
.meas tran vdout2_20ck143 FIND v(dout2_20) AT=2880.1n

* CHECK dout2_21 Vdout2_21ck143 = 1.8 time = 2880
.meas tran vdout2_21ck143 FIND v(dout2_21) AT=2880.1n

* CHECK dout2_22 Vdout2_22ck143 = 1.8 time = 2880
.meas tran vdout2_22ck143 FIND v(dout2_22) AT=2880.1n

* CHECK dout2_23 Vdout2_23ck143 = 0 time = 2880
.meas tran vdout2_23ck143 FIND v(dout2_23) AT=2880.1n

* CHECK dout2_24 Vdout2_24ck143 = 0 time = 2880
.meas tran vdout2_24ck143 FIND v(dout2_24) AT=2880.1n

* CHECK dout2_25 Vdout2_25ck143 = 1.8 time = 2880
.meas tran vdout2_25ck143 FIND v(dout2_25) AT=2880.1n

* CHECK dout2_26 Vdout2_26ck143 = 0 time = 2880
.meas tran vdout2_26ck143 FIND v(dout2_26) AT=2880.1n

* CHECK dout2_27 Vdout2_27ck143 = 1.8 time = 2880
.meas tran vdout2_27ck143 FIND v(dout2_27) AT=2880.1n

* CHECK dout2_28 Vdout2_28ck143 = 0 time = 2880
.meas tran vdout2_28ck143 FIND v(dout2_28) AT=2880.1n

* CHECK dout2_29 Vdout2_29ck143 = 1.8 time = 2880
.meas tran vdout2_29ck143 FIND v(dout2_29) AT=2880.1n

* CHECK dout2_30 Vdout2_30ck143 = 0 time = 2880
.meas tran vdout2_30ck143 FIND v(dout2_30) AT=2880.1n

* CHECK dout2_31 Vdout2_31ck143 = 1.8 time = 2880
.meas tran vdout2_31ck143 FIND v(dout2_31) AT=2880.1n

* CHECK dout1_0 Vdout1_0ck144 = 0 time = 2900
.meas tran vdout1_0ck144 FIND v(dout1_0) AT=2900.1n

* CHECK dout1_1 Vdout1_1ck144 = 0 time = 2900
.meas tran vdout1_1ck144 FIND v(dout1_1) AT=2900.1n

* CHECK dout1_2 Vdout1_2ck144 = 1.8 time = 2900
.meas tran vdout1_2ck144 FIND v(dout1_2) AT=2900.1n

* CHECK dout1_3 Vdout1_3ck144 = 0 time = 2900
.meas tran vdout1_3ck144 FIND v(dout1_3) AT=2900.1n

* CHECK dout1_4 Vdout1_4ck144 = 0 time = 2900
.meas tran vdout1_4ck144 FIND v(dout1_4) AT=2900.1n

* CHECK dout1_5 Vdout1_5ck144 = 1.8 time = 2900
.meas tran vdout1_5ck144 FIND v(dout1_5) AT=2900.1n

* CHECK dout1_6 Vdout1_6ck144 = 1.8 time = 2900
.meas tran vdout1_6ck144 FIND v(dout1_6) AT=2900.1n

* CHECK dout1_7 Vdout1_7ck144 = 0 time = 2900
.meas tran vdout1_7ck144 FIND v(dout1_7) AT=2900.1n

* CHECK dout1_8 Vdout1_8ck144 = 0 time = 2900
.meas tran vdout1_8ck144 FIND v(dout1_8) AT=2900.1n

* CHECK dout1_9 Vdout1_9ck144 = 0 time = 2900
.meas tran vdout1_9ck144 FIND v(dout1_9) AT=2900.1n

* CHECK dout1_10 Vdout1_10ck144 = 1.8 time = 2900
.meas tran vdout1_10ck144 FIND v(dout1_10) AT=2900.1n

* CHECK dout1_11 Vdout1_11ck144 = 1.8 time = 2900
.meas tran vdout1_11ck144 FIND v(dout1_11) AT=2900.1n

* CHECK dout1_12 Vdout1_12ck144 = 1.8 time = 2900
.meas tran vdout1_12ck144 FIND v(dout1_12) AT=2900.1n

* CHECK dout1_13 Vdout1_13ck144 = 1.8 time = 2900
.meas tran vdout1_13ck144 FIND v(dout1_13) AT=2900.1n

* CHECK dout1_14 Vdout1_14ck144 = 0 time = 2900
.meas tran vdout1_14ck144 FIND v(dout1_14) AT=2900.1n

* CHECK dout1_15 Vdout1_15ck144 = 1.8 time = 2900
.meas tran vdout1_15ck144 FIND v(dout1_15) AT=2900.1n

* CHECK dout1_16 Vdout1_16ck144 = 0 time = 2900
.meas tran vdout1_16ck144 FIND v(dout1_16) AT=2900.1n

* CHECK dout1_17 Vdout1_17ck144 = 0 time = 2900
.meas tran vdout1_17ck144 FIND v(dout1_17) AT=2900.1n

* CHECK dout1_18 Vdout1_18ck144 = 0 time = 2900
.meas tran vdout1_18ck144 FIND v(dout1_18) AT=2900.1n

* CHECK dout1_19 Vdout1_19ck144 = 0 time = 2900
.meas tran vdout1_19ck144 FIND v(dout1_19) AT=2900.1n

* CHECK dout1_20 Vdout1_20ck144 = 1.8 time = 2900
.meas tran vdout1_20ck144 FIND v(dout1_20) AT=2900.1n

* CHECK dout1_21 Vdout1_21ck144 = 1.8 time = 2900
.meas tran vdout1_21ck144 FIND v(dout1_21) AT=2900.1n

* CHECK dout1_22 Vdout1_22ck144 = 1.8 time = 2900
.meas tran vdout1_22ck144 FIND v(dout1_22) AT=2900.1n

* CHECK dout1_23 Vdout1_23ck144 = 0 time = 2900
.meas tran vdout1_23ck144 FIND v(dout1_23) AT=2900.1n

* CHECK dout1_24 Vdout1_24ck144 = 0 time = 2900
.meas tran vdout1_24ck144 FIND v(dout1_24) AT=2900.1n

* CHECK dout1_25 Vdout1_25ck144 = 1.8 time = 2900
.meas tran vdout1_25ck144 FIND v(dout1_25) AT=2900.1n

* CHECK dout1_26 Vdout1_26ck144 = 0 time = 2900
.meas tran vdout1_26ck144 FIND v(dout1_26) AT=2900.1n

* CHECK dout1_27 Vdout1_27ck144 = 1.8 time = 2900
.meas tran vdout1_27ck144 FIND v(dout1_27) AT=2900.1n

* CHECK dout1_28 Vdout1_28ck144 = 0 time = 2900
.meas tran vdout1_28ck144 FIND v(dout1_28) AT=2900.1n

* CHECK dout1_29 Vdout1_29ck144 = 1.8 time = 2900
.meas tran vdout1_29ck144 FIND v(dout1_29) AT=2900.1n

* CHECK dout1_30 Vdout1_30ck144 = 0 time = 2900
.meas tran vdout1_30ck144 FIND v(dout1_30) AT=2900.1n

* CHECK dout1_31 Vdout1_31ck144 = 1.8 time = 2900
.meas tran vdout1_31ck144 FIND v(dout1_31) AT=2900.1n

* CHECK dout1_0 Vdout1_0ck145 = 0 time = 2920
.meas tran vdout1_0ck145 FIND v(dout1_0) AT=2920.1n

* CHECK dout1_1 Vdout1_1ck145 = 0 time = 2920
.meas tran vdout1_1ck145 FIND v(dout1_1) AT=2920.1n

* CHECK dout1_2 Vdout1_2ck145 = 1.8 time = 2920
.meas tran vdout1_2ck145 FIND v(dout1_2) AT=2920.1n

* CHECK dout1_3 Vdout1_3ck145 = 0 time = 2920
.meas tran vdout1_3ck145 FIND v(dout1_3) AT=2920.1n

* CHECK dout1_4 Vdout1_4ck145 = 0 time = 2920
.meas tran vdout1_4ck145 FIND v(dout1_4) AT=2920.1n

* CHECK dout1_5 Vdout1_5ck145 = 1.8 time = 2920
.meas tran vdout1_5ck145 FIND v(dout1_5) AT=2920.1n

* CHECK dout1_6 Vdout1_6ck145 = 1.8 time = 2920
.meas tran vdout1_6ck145 FIND v(dout1_6) AT=2920.1n

* CHECK dout1_7 Vdout1_7ck145 = 0 time = 2920
.meas tran vdout1_7ck145 FIND v(dout1_7) AT=2920.1n

* CHECK dout1_8 Vdout1_8ck145 = 0 time = 2920
.meas tran vdout1_8ck145 FIND v(dout1_8) AT=2920.1n

* CHECK dout1_9 Vdout1_9ck145 = 0 time = 2920
.meas tran vdout1_9ck145 FIND v(dout1_9) AT=2920.1n

* CHECK dout1_10 Vdout1_10ck145 = 1.8 time = 2920
.meas tran vdout1_10ck145 FIND v(dout1_10) AT=2920.1n

* CHECK dout1_11 Vdout1_11ck145 = 1.8 time = 2920
.meas tran vdout1_11ck145 FIND v(dout1_11) AT=2920.1n

* CHECK dout1_12 Vdout1_12ck145 = 1.8 time = 2920
.meas tran vdout1_12ck145 FIND v(dout1_12) AT=2920.1n

* CHECK dout1_13 Vdout1_13ck145 = 1.8 time = 2920
.meas tran vdout1_13ck145 FIND v(dout1_13) AT=2920.1n

* CHECK dout1_14 Vdout1_14ck145 = 0 time = 2920
.meas tran vdout1_14ck145 FIND v(dout1_14) AT=2920.1n

* CHECK dout1_15 Vdout1_15ck145 = 1.8 time = 2920
.meas tran vdout1_15ck145 FIND v(dout1_15) AT=2920.1n

* CHECK dout1_16 Vdout1_16ck145 = 0 time = 2920
.meas tran vdout1_16ck145 FIND v(dout1_16) AT=2920.1n

* CHECK dout1_17 Vdout1_17ck145 = 0 time = 2920
.meas tran vdout1_17ck145 FIND v(dout1_17) AT=2920.1n

* CHECK dout1_18 Vdout1_18ck145 = 0 time = 2920
.meas tran vdout1_18ck145 FIND v(dout1_18) AT=2920.1n

* CHECK dout1_19 Vdout1_19ck145 = 0 time = 2920
.meas tran vdout1_19ck145 FIND v(dout1_19) AT=2920.1n

* CHECK dout1_20 Vdout1_20ck145 = 1.8 time = 2920
.meas tran vdout1_20ck145 FIND v(dout1_20) AT=2920.1n

* CHECK dout1_21 Vdout1_21ck145 = 1.8 time = 2920
.meas tran vdout1_21ck145 FIND v(dout1_21) AT=2920.1n

* CHECK dout1_22 Vdout1_22ck145 = 1.8 time = 2920
.meas tran vdout1_22ck145 FIND v(dout1_22) AT=2920.1n

* CHECK dout1_23 Vdout1_23ck145 = 0 time = 2920
.meas tran vdout1_23ck145 FIND v(dout1_23) AT=2920.1n

* CHECK dout1_24 Vdout1_24ck145 = 0 time = 2920
.meas tran vdout1_24ck145 FIND v(dout1_24) AT=2920.1n

* CHECK dout1_25 Vdout1_25ck145 = 1.8 time = 2920
.meas tran vdout1_25ck145 FIND v(dout1_25) AT=2920.1n

* CHECK dout1_26 Vdout1_26ck145 = 0 time = 2920
.meas tran vdout1_26ck145 FIND v(dout1_26) AT=2920.1n

* CHECK dout1_27 Vdout1_27ck145 = 1.8 time = 2920
.meas tran vdout1_27ck145 FIND v(dout1_27) AT=2920.1n

* CHECK dout1_28 Vdout1_28ck145 = 0 time = 2920
.meas tran vdout1_28ck145 FIND v(dout1_28) AT=2920.1n

* CHECK dout1_29 Vdout1_29ck145 = 1.8 time = 2920
.meas tran vdout1_29ck145 FIND v(dout1_29) AT=2920.1n

* CHECK dout1_30 Vdout1_30ck145 = 0 time = 2920
.meas tran vdout1_30ck145 FIND v(dout1_30) AT=2920.1n

* CHECK dout1_31 Vdout1_31ck145 = 1.8 time = 2920
.meas tran vdout1_31ck145 FIND v(dout1_31) AT=2920.1n

* CHECK dout2_0 Vdout2_0ck145 = 1.8 time = 2920
.meas tran vdout2_0ck145 FIND v(dout2_0) AT=2920.1n

* CHECK dout2_1 Vdout2_1ck145 = 1.8 time = 2920
.meas tran vdout2_1ck145 FIND v(dout2_1) AT=2920.1n

* CHECK dout2_2 Vdout2_2ck145 = 1.8 time = 2920
.meas tran vdout2_2ck145 FIND v(dout2_2) AT=2920.1n

* CHECK dout2_3 Vdout2_3ck145 = 0 time = 2920
.meas tran vdout2_3ck145 FIND v(dout2_3) AT=2920.1n

* CHECK dout2_4 Vdout2_4ck145 = 1.8 time = 2920
.meas tran vdout2_4ck145 FIND v(dout2_4) AT=2920.1n

* CHECK dout2_5 Vdout2_5ck145 = 1.8 time = 2920
.meas tran vdout2_5ck145 FIND v(dout2_5) AT=2920.1n

* CHECK dout2_6 Vdout2_6ck145 = 0 time = 2920
.meas tran vdout2_6ck145 FIND v(dout2_6) AT=2920.1n

* CHECK dout2_7 Vdout2_7ck145 = 1.8 time = 2920
.meas tran vdout2_7ck145 FIND v(dout2_7) AT=2920.1n

* CHECK dout2_8 Vdout2_8ck145 = 1.8 time = 2920
.meas tran vdout2_8ck145 FIND v(dout2_8) AT=2920.1n

* CHECK dout2_9 Vdout2_9ck145 = 1.8 time = 2920
.meas tran vdout2_9ck145 FIND v(dout2_9) AT=2920.1n

* CHECK dout2_10 Vdout2_10ck145 = 1.8 time = 2920
.meas tran vdout2_10ck145 FIND v(dout2_10) AT=2920.1n

* CHECK dout2_11 Vdout2_11ck145 = 0 time = 2920
.meas tran vdout2_11ck145 FIND v(dout2_11) AT=2920.1n

* CHECK dout2_12 Vdout2_12ck145 = 0 time = 2920
.meas tran vdout2_12ck145 FIND v(dout2_12) AT=2920.1n

* CHECK dout2_13 Vdout2_13ck145 = 0 time = 2920
.meas tran vdout2_13ck145 FIND v(dout2_13) AT=2920.1n

* CHECK dout2_14 Vdout2_14ck145 = 0 time = 2920
.meas tran vdout2_14ck145 FIND v(dout2_14) AT=2920.1n

* CHECK dout2_15 Vdout2_15ck145 = 1.8 time = 2920
.meas tran vdout2_15ck145 FIND v(dout2_15) AT=2920.1n

* CHECK dout2_16 Vdout2_16ck145 = 0 time = 2920
.meas tran vdout2_16ck145 FIND v(dout2_16) AT=2920.1n

* CHECK dout2_17 Vdout2_17ck145 = 1.8 time = 2920
.meas tran vdout2_17ck145 FIND v(dout2_17) AT=2920.1n

* CHECK dout2_18 Vdout2_18ck145 = 0 time = 2920
.meas tran vdout2_18ck145 FIND v(dout2_18) AT=2920.1n

* CHECK dout2_19 Vdout2_19ck145 = 0 time = 2920
.meas tran vdout2_19ck145 FIND v(dout2_19) AT=2920.1n

* CHECK dout2_20 Vdout2_20ck145 = 1.8 time = 2920
.meas tran vdout2_20ck145 FIND v(dout2_20) AT=2920.1n

* CHECK dout2_21 Vdout2_21ck145 = 1.8 time = 2920
.meas tran vdout2_21ck145 FIND v(dout2_21) AT=2920.1n

* CHECK dout2_22 Vdout2_22ck145 = 1.8 time = 2920
.meas tran vdout2_22ck145 FIND v(dout2_22) AT=2920.1n

* CHECK dout2_23 Vdout2_23ck145 = 0 time = 2920
.meas tran vdout2_23ck145 FIND v(dout2_23) AT=2920.1n

* CHECK dout2_24 Vdout2_24ck145 = 0 time = 2920
.meas tran vdout2_24ck145 FIND v(dout2_24) AT=2920.1n

* CHECK dout2_25 Vdout2_25ck145 = 0 time = 2920
.meas tran vdout2_25ck145 FIND v(dout2_25) AT=2920.1n

* CHECK dout2_26 Vdout2_26ck145 = 0 time = 2920
.meas tran vdout2_26ck145 FIND v(dout2_26) AT=2920.1n

* CHECK dout2_27 Vdout2_27ck145 = 0 time = 2920
.meas tran vdout2_27ck145 FIND v(dout2_27) AT=2920.1n

* CHECK dout2_28 Vdout2_28ck145 = 0 time = 2920
.meas tran vdout2_28ck145 FIND v(dout2_28) AT=2920.1n

* CHECK dout2_29 Vdout2_29ck145 = 1.8 time = 2920
.meas tran vdout2_29ck145 FIND v(dout2_29) AT=2920.1n

* CHECK dout2_30 Vdout2_30ck145 = 1.8 time = 2920
.meas tran vdout2_30ck145 FIND v(dout2_30) AT=2920.1n

* CHECK dout2_31 Vdout2_31ck145 = 1.8 time = 2920
.meas tran vdout2_31ck145 FIND v(dout2_31) AT=2920.1n

* CHECK dout1_0 Vdout1_0ck146 = 1.8 time = 2940
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=2940.1n

* CHECK dout1_1 Vdout1_1ck146 = 1.8 time = 2940
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=2940.1n

* CHECK dout1_2 Vdout1_2ck146 = 1.8 time = 2940
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=2940.1n

* CHECK dout1_3 Vdout1_3ck146 = 0 time = 2940
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=2940.1n

* CHECK dout1_4 Vdout1_4ck146 = 1.8 time = 2940
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=2940.1n

* CHECK dout1_5 Vdout1_5ck146 = 1.8 time = 2940
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=2940.1n

* CHECK dout1_6 Vdout1_6ck146 = 0 time = 2940
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=2940.1n

* CHECK dout1_7 Vdout1_7ck146 = 1.8 time = 2940
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=2940.1n

* CHECK dout1_8 Vdout1_8ck146 = 1.8 time = 2940
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=2940.1n

* CHECK dout1_9 Vdout1_9ck146 = 1.8 time = 2940
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=2940.1n

* CHECK dout1_10 Vdout1_10ck146 = 1.8 time = 2940
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=2940.1n

* CHECK dout1_11 Vdout1_11ck146 = 0 time = 2940
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=2940.1n

* CHECK dout1_12 Vdout1_12ck146 = 0 time = 2940
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=2940.1n

* CHECK dout1_13 Vdout1_13ck146 = 0 time = 2940
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=2940.1n

* CHECK dout1_14 Vdout1_14ck146 = 0 time = 2940
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=2940.1n

* CHECK dout1_15 Vdout1_15ck146 = 1.8 time = 2940
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=2940.1n

* CHECK dout1_16 Vdout1_16ck146 = 0 time = 2940
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=2940.1n

* CHECK dout1_17 Vdout1_17ck146 = 1.8 time = 2940
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=2940.1n

* CHECK dout1_18 Vdout1_18ck146 = 0 time = 2940
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=2940.1n

* CHECK dout1_19 Vdout1_19ck146 = 0 time = 2940
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=2940.1n

* CHECK dout1_20 Vdout1_20ck146 = 1.8 time = 2940
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=2940.1n

* CHECK dout1_21 Vdout1_21ck146 = 1.8 time = 2940
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=2940.1n

* CHECK dout1_22 Vdout1_22ck146 = 1.8 time = 2940
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=2940.1n

* CHECK dout1_23 Vdout1_23ck146 = 0 time = 2940
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=2940.1n

* CHECK dout1_24 Vdout1_24ck146 = 0 time = 2940
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=2940.1n

* CHECK dout1_25 Vdout1_25ck146 = 0 time = 2940
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=2940.1n

* CHECK dout1_26 Vdout1_26ck146 = 0 time = 2940
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=2940.1n

* CHECK dout1_27 Vdout1_27ck146 = 0 time = 2940
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=2940.1n

* CHECK dout1_28 Vdout1_28ck146 = 0 time = 2940
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=2940.1n

* CHECK dout1_29 Vdout1_29ck146 = 1.8 time = 2940
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=2940.1n

* CHECK dout1_30 Vdout1_30ck146 = 1.8 time = 2940
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=2940.1n

* CHECK dout1_31 Vdout1_31ck146 = 1.8 time = 2940
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=2940.1n

* CHECK dout2_0 Vdout2_0ck146 = 0 time = 2940
.meas tran vdout2_0ck146 FIND v(dout2_0) AT=2940.1n

* CHECK dout2_1 Vdout2_1ck146 = 0 time = 2940
.meas tran vdout2_1ck146 FIND v(dout2_1) AT=2940.1n

* CHECK dout2_2 Vdout2_2ck146 = 1.8 time = 2940
.meas tran vdout2_2ck146 FIND v(dout2_2) AT=2940.1n

* CHECK dout2_3 Vdout2_3ck146 = 0 time = 2940
.meas tran vdout2_3ck146 FIND v(dout2_3) AT=2940.1n

* CHECK dout2_4 Vdout2_4ck146 = 0 time = 2940
.meas tran vdout2_4ck146 FIND v(dout2_4) AT=2940.1n

* CHECK dout2_5 Vdout2_5ck146 = 1.8 time = 2940
.meas tran vdout2_5ck146 FIND v(dout2_5) AT=2940.1n

* CHECK dout2_6 Vdout2_6ck146 = 1.8 time = 2940
.meas tran vdout2_6ck146 FIND v(dout2_6) AT=2940.1n

* CHECK dout2_7 Vdout2_7ck146 = 0 time = 2940
.meas tran vdout2_7ck146 FIND v(dout2_7) AT=2940.1n

* CHECK dout2_8 Vdout2_8ck146 = 0 time = 2940
.meas tran vdout2_8ck146 FIND v(dout2_8) AT=2940.1n

* CHECK dout2_9 Vdout2_9ck146 = 0 time = 2940
.meas tran vdout2_9ck146 FIND v(dout2_9) AT=2940.1n

* CHECK dout2_10 Vdout2_10ck146 = 1.8 time = 2940
.meas tran vdout2_10ck146 FIND v(dout2_10) AT=2940.1n

* CHECK dout2_11 Vdout2_11ck146 = 1.8 time = 2940
.meas tran vdout2_11ck146 FIND v(dout2_11) AT=2940.1n

* CHECK dout2_12 Vdout2_12ck146 = 1.8 time = 2940
.meas tran vdout2_12ck146 FIND v(dout2_12) AT=2940.1n

* CHECK dout2_13 Vdout2_13ck146 = 1.8 time = 2940
.meas tran vdout2_13ck146 FIND v(dout2_13) AT=2940.1n

* CHECK dout2_14 Vdout2_14ck146 = 0 time = 2940
.meas tran vdout2_14ck146 FIND v(dout2_14) AT=2940.1n

* CHECK dout2_15 Vdout2_15ck146 = 1.8 time = 2940
.meas tran vdout2_15ck146 FIND v(dout2_15) AT=2940.1n

* CHECK dout2_16 Vdout2_16ck146 = 0 time = 2940
.meas tran vdout2_16ck146 FIND v(dout2_16) AT=2940.1n

* CHECK dout2_17 Vdout2_17ck146 = 0 time = 2940
.meas tran vdout2_17ck146 FIND v(dout2_17) AT=2940.1n

* CHECK dout2_18 Vdout2_18ck146 = 0 time = 2940
.meas tran vdout2_18ck146 FIND v(dout2_18) AT=2940.1n

* CHECK dout2_19 Vdout2_19ck146 = 0 time = 2940
.meas tran vdout2_19ck146 FIND v(dout2_19) AT=2940.1n

* CHECK dout2_20 Vdout2_20ck146 = 1.8 time = 2940
.meas tran vdout2_20ck146 FIND v(dout2_20) AT=2940.1n

* CHECK dout2_21 Vdout2_21ck146 = 1.8 time = 2940
.meas tran vdout2_21ck146 FIND v(dout2_21) AT=2940.1n

* CHECK dout2_22 Vdout2_22ck146 = 1.8 time = 2940
.meas tran vdout2_22ck146 FIND v(dout2_22) AT=2940.1n

* CHECK dout2_23 Vdout2_23ck146 = 0 time = 2940
.meas tran vdout2_23ck146 FIND v(dout2_23) AT=2940.1n

* CHECK dout2_24 Vdout2_24ck146 = 0 time = 2940
.meas tran vdout2_24ck146 FIND v(dout2_24) AT=2940.1n

* CHECK dout2_25 Vdout2_25ck146 = 1.8 time = 2940
.meas tran vdout2_25ck146 FIND v(dout2_25) AT=2940.1n

* CHECK dout2_26 Vdout2_26ck146 = 0 time = 2940
.meas tran vdout2_26ck146 FIND v(dout2_26) AT=2940.1n

* CHECK dout2_27 Vdout2_27ck146 = 1.8 time = 2940
.meas tran vdout2_27ck146 FIND v(dout2_27) AT=2940.1n

* CHECK dout2_28 Vdout2_28ck146 = 0 time = 2940
.meas tran vdout2_28ck146 FIND v(dout2_28) AT=2940.1n

* CHECK dout2_29 Vdout2_29ck146 = 1.8 time = 2940
.meas tran vdout2_29ck146 FIND v(dout2_29) AT=2940.1n

* CHECK dout2_30 Vdout2_30ck146 = 0 time = 2940
.meas tran vdout2_30ck146 FIND v(dout2_30) AT=2940.1n

* CHECK dout2_31 Vdout2_31ck146 = 1.8 time = 2940
.meas tran vdout2_31ck146 FIND v(dout2_31) AT=2940.1n

* CHECK dout1_0 Vdout1_0ck147 = 0 time = 2960
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=2960.1n

* CHECK dout1_1 Vdout1_1ck147 = 1.8 time = 2960
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=2960.1n

* CHECK dout1_2 Vdout1_2ck147 = 0 time = 2960
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=2960.1n

* CHECK dout1_3 Vdout1_3ck147 = 1.8 time = 2960
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=2960.1n

* CHECK dout1_4 Vdout1_4ck147 = 0 time = 2960
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=2960.1n

* CHECK dout1_5 Vdout1_5ck147 = 0 time = 2960
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=2960.1n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 2960
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=2960.1n

* CHECK dout1_7 Vdout1_7ck147 = 1.8 time = 2960
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=2960.1n

* CHECK dout1_8 Vdout1_8ck147 = 1.8 time = 2960
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=2960.1n

* CHECK dout1_9 Vdout1_9ck147 = 0 time = 2960
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=2960.1n

* CHECK dout1_10 Vdout1_10ck147 = 1.8 time = 2960
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=2960.1n

* CHECK dout1_11 Vdout1_11ck147 = 0 time = 2960
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=2960.1n

* CHECK dout1_12 Vdout1_12ck147 = 0 time = 2960
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=2960.1n

* CHECK dout1_13 Vdout1_13ck147 = 0 time = 2960
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=2960.1n

* CHECK dout1_14 Vdout1_14ck147 = 0 time = 2960
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=2960.1n

* CHECK dout1_15 Vdout1_15ck147 = 1.8 time = 2960
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=2960.1n

* CHECK dout1_16 Vdout1_16ck147 = 1.8 time = 2960
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=2960.1n

* CHECK dout1_17 Vdout1_17ck147 = 0 time = 2960
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=2960.1n

* CHECK dout1_18 Vdout1_18ck147 = 1.8 time = 2960
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=2960.1n

* CHECK dout1_19 Vdout1_19ck147 = 1.8 time = 2960
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=2960.1n

* CHECK dout1_20 Vdout1_20ck147 = 0 time = 2960
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=2960.1n

* CHECK dout1_21 Vdout1_21ck147 = 0 time = 2960
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=2960.1n

* CHECK dout1_22 Vdout1_22ck147 = 1.8 time = 2960
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=2960.1n

* CHECK dout1_23 Vdout1_23ck147 = 1.8 time = 2960
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=2960.1n

* CHECK dout1_24 Vdout1_24ck147 = 1.8 time = 2960
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=2960.1n

* CHECK dout1_25 Vdout1_25ck147 = 0 time = 2960
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=2960.1n

* CHECK dout1_26 Vdout1_26ck147 = 0 time = 2960
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=2960.1n

* CHECK dout1_27 Vdout1_27ck147 = 0 time = 2960
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=2960.1n

* CHECK dout1_28 Vdout1_28ck147 = 0 time = 2960
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=2960.1n

* CHECK dout1_29 Vdout1_29ck147 = 0 time = 2960
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=2960.1n

* CHECK dout1_30 Vdout1_30ck147 = 0 time = 2960
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=2960.1n

* CHECK dout1_31 Vdout1_31ck147 = 1.8 time = 2960
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=2960.1n

* CHECK dout2_0 Vdout2_0ck147 = 1.8 time = 2960
.meas tran vdout2_0ck147 FIND v(dout2_0) AT=2960.1n

* CHECK dout2_1 Vdout2_1ck147 = 1.8 time = 2960
.meas tran vdout2_1ck147 FIND v(dout2_1) AT=2960.1n

* CHECK dout2_2 Vdout2_2ck147 = 1.8 time = 2960
.meas tran vdout2_2ck147 FIND v(dout2_2) AT=2960.1n

* CHECK dout2_3 Vdout2_3ck147 = 0 time = 2960
.meas tran vdout2_3ck147 FIND v(dout2_3) AT=2960.1n

* CHECK dout2_4 Vdout2_4ck147 = 1.8 time = 2960
.meas tran vdout2_4ck147 FIND v(dout2_4) AT=2960.1n

* CHECK dout2_5 Vdout2_5ck147 = 1.8 time = 2960
.meas tran vdout2_5ck147 FIND v(dout2_5) AT=2960.1n

* CHECK dout2_6 Vdout2_6ck147 = 0 time = 2960
.meas tran vdout2_6ck147 FIND v(dout2_6) AT=2960.1n

* CHECK dout2_7 Vdout2_7ck147 = 1.8 time = 2960
.meas tran vdout2_7ck147 FIND v(dout2_7) AT=2960.1n

* CHECK dout2_8 Vdout2_8ck147 = 1.8 time = 2960
.meas tran vdout2_8ck147 FIND v(dout2_8) AT=2960.1n

* CHECK dout2_9 Vdout2_9ck147 = 1.8 time = 2960
.meas tran vdout2_9ck147 FIND v(dout2_9) AT=2960.1n

* CHECK dout2_10 Vdout2_10ck147 = 1.8 time = 2960
.meas tran vdout2_10ck147 FIND v(dout2_10) AT=2960.1n

* CHECK dout2_11 Vdout2_11ck147 = 0 time = 2960
.meas tran vdout2_11ck147 FIND v(dout2_11) AT=2960.1n

* CHECK dout2_12 Vdout2_12ck147 = 0 time = 2960
.meas tran vdout2_12ck147 FIND v(dout2_12) AT=2960.1n

* CHECK dout2_13 Vdout2_13ck147 = 0 time = 2960
.meas tran vdout2_13ck147 FIND v(dout2_13) AT=2960.1n

* CHECK dout2_14 Vdout2_14ck147 = 0 time = 2960
.meas tran vdout2_14ck147 FIND v(dout2_14) AT=2960.1n

* CHECK dout2_15 Vdout2_15ck147 = 1.8 time = 2960
.meas tran vdout2_15ck147 FIND v(dout2_15) AT=2960.1n

* CHECK dout2_16 Vdout2_16ck147 = 0 time = 2960
.meas tran vdout2_16ck147 FIND v(dout2_16) AT=2960.1n

* CHECK dout2_17 Vdout2_17ck147 = 1.8 time = 2960
.meas tran vdout2_17ck147 FIND v(dout2_17) AT=2960.1n

* CHECK dout2_18 Vdout2_18ck147 = 0 time = 2960
.meas tran vdout2_18ck147 FIND v(dout2_18) AT=2960.1n

* CHECK dout2_19 Vdout2_19ck147 = 0 time = 2960
.meas tran vdout2_19ck147 FIND v(dout2_19) AT=2960.1n

* CHECK dout2_20 Vdout2_20ck147 = 1.8 time = 2960
.meas tran vdout2_20ck147 FIND v(dout2_20) AT=2960.1n

* CHECK dout2_21 Vdout2_21ck147 = 1.8 time = 2960
.meas tran vdout2_21ck147 FIND v(dout2_21) AT=2960.1n

* CHECK dout2_22 Vdout2_22ck147 = 1.8 time = 2960
.meas tran vdout2_22ck147 FIND v(dout2_22) AT=2960.1n

* CHECK dout2_23 Vdout2_23ck147 = 0 time = 2960
.meas tran vdout2_23ck147 FIND v(dout2_23) AT=2960.1n

* CHECK dout2_24 Vdout2_24ck147 = 0 time = 2960
.meas tran vdout2_24ck147 FIND v(dout2_24) AT=2960.1n

* CHECK dout2_25 Vdout2_25ck147 = 0 time = 2960
.meas tran vdout2_25ck147 FIND v(dout2_25) AT=2960.1n

* CHECK dout2_26 Vdout2_26ck147 = 0 time = 2960
.meas tran vdout2_26ck147 FIND v(dout2_26) AT=2960.1n

* CHECK dout2_27 Vdout2_27ck147 = 0 time = 2960
.meas tran vdout2_27ck147 FIND v(dout2_27) AT=2960.1n

* CHECK dout2_28 Vdout2_28ck147 = 0 time = 2960
.meas tran vdout2_28ck147 FIND v(dout2_28) AT=2960.1n

* CHECK dout2_29 Vdout2_29ck147 = 1.8 time = 2960
.meas tran vdout2_29ck147 FIND v(dout2_29) AT=2960.1n

* CHECK dout2_30 Vdout2_30ck147 = 1.8 time = 2960
.meas tran vdout2_30ck147 FIND v(dout2_30) AT=2960.1n

* CHECK dout2_31 Vdout2_31ck147 = 1.8 time = 2960
.meas tran vdout2_31ck147 FIND v(dout2_31) AT=2960.1n

* CHECK dout1_0 Vdout1_0ck148 = 1.8 time = 2980
.meas tran vdout1_0ck148 FIND v(dout1_0) AT=2980.1n

* CHECK dout1_1 Vdout1_1ck148 = 1.8 time = 2980
.meas tran vdout1_1ck148 FIND v(dout1_1) AT=2980.1n

* CHECK dout1_2 Vdout1_2ck148 = 1.8 time = 2980
.meas tran vdout1_2ck148 FIND v(dout1_2) AT=2980.1n

* CHECK dout1_3 Vdout1_3ck148 = 0 time = 2980
.meas tran vdout1_3ck148 FIND v(dout1_3) AT=2980.1n

* CHECK dout1_4 Vdout1_4ck148 = 1.8 time = 2980
.meas tran vdout1_4ck148 FIND v(dout1_4) AT=2980.1n

* CHECK dout1_5 Vdout1_5ck148 = 1.8 time = 2980
.meas tran vdout1_5ck148 FIND v(dout1_5) AT=2980.1n

* CHECK dout1_6 Vdout1_6ck148 = 0 time = 2980
.meas tran vdout1_6ck148 FIND v(dout1_6) AT=2980.1n

* CHECK dout1_7 Vdout1_7ck148 = 1.8 time = 2980
.meas tran vdout1_7ck148 FIND v(dout1_7) AT=2980.1n

* CHECK dout1_8 Vdout1_8ck148 = 1.8 time = 2980
.meas tran vdout1_8ck148 FIND v(dout1_8) AT=2980.1n

* CHECK dout1_9 Vdout1_9ck148 = 1.8 time = 2980
.meas tran vdout1_9ck148 FIND v(dout1_9) AT=2980.1n

* CHECK dout1_10 Vdout1_10ck148 = 1.8 time = 2980
.meas tran vdout1_10ck148 FIND v(dout1_10) AT=2980.1n

* CHECK dout1_11 Vdout1_11ck148 = 0 time = 2980
.meas tran vdout1_11ck148 FIND v(dout1_11) AT=2980.1n

* CHECK dout1_12 Vdout1_12ck148 = 0 time = 2980
.meas tran vdout1_12ck148 FIND v(dout1_12) AT=2980.1n

* CHECK dout1_13 Vdout1_13ck148 = 0 time = 2980
.meas tran vdout1_13ck148 FIND v(dout1_13) AT=2980.1n

* CHECK dout1_14 Vdout1_14ck148 = 0 time = 2980
.meas tran vdout1_14ck148 FIND v(dout1_14) AT=2980.1n

* CHECK dout1_15 Vdout1_15ck148 = 1.8 time = 2980
.meas tran vdout1_15ck148 FIND v(dout1_15) AT=2980.1n

* CHECK dout1_16 Vdout1_16ck148 = 0 time = 2980
.meas tran vdout1_16ck148 FIND v(dout1_16) AT=2980.1n

* CHECK dout1_17 Vdout1_17ck148 = 1.8 time = 2980
.meas tran vdout1_17ck148 FIND v(dout1_17) AT=2980.1n

* CHECK dout1_18 Vdout1_18ck148 = 0 time = 2980
.meas tran vdout1_18ck148 FIND v(dout1_18) AT=2980.1n

* CHECK dout1_19 Vdout1_19ck148 = 0 time = 2980
.meas tran vdout1_19ck148 FIND v(dout1_19) AT=2980.1n

* CHECK dout1_20 Vdout1_20ck148 = 1.8 time = 2980
.meas tran vdout1_20ck148 FIND v(dout1_20) AT=2980.1n

* CHECK dout1_21 Vdout1_21ck148 = 1.8 time = 2980
.meas tran vdout1_21ck148 FIND v(dout1_21) AT=2980.1n

* CHECK dout1_22 Vdout1_22ck148 = 1.8 time = 2980
.meas tran vdout1_22ck148 FIND v(dout1_22) AT=2980.1n

* CHECK dout1_23 Vdout1_23ck148 = 0 time = 2980
.meas tran vdout1_23ck148 FIND v(dout1_23) AT=2980.1n

* CHECK dout1_24 Vdout1_24ck148 = 0 time = 2980
.meas tran vdout1_24ck148 FIND v(dout1_24) AT=2980.1n

* CHECK dout1_25 Vdout1_25ck148 = 0 time = 2980
.meas tran vdout1_25ck148 FIND v(dout1_25) AT=2980.1n

* CHECK dout1_26 Vdout1_26ck148 = 0 time = 2980
.meas tran vdout1_26ck148 FIND v(dout1_26) AT=2980.1n

* CHECK dout1_27 Vdout1_27ck148 = 0 time = 2980
.meas tran vdout1_27ck148 FIND v(dout1_27) AT=2980.1n

* CHECK dout1_28 Vdout1_28ck148 = 0 time = 2980
.meas tran vdout1_28ck148 FIND v(dout1_28) AT=2980.1n

* CHECK dout1_29 Vdout1_29ck148 = 1.8 time = 2980
.meas tran vdout1_29ck148 FIND v(dout1_29) AT=2980.1n

* CHECK dout1_30 Vdout1_30ck148 = 1.8 time = 2980
.meas tran vdout1_30ck148 FIND v(dout1_30) AT=2980.1n

* CHECK dout1_31 Vdout1_31ck148 = 1.8 time = 2980
.meas tran vdout1_31ck148 FIND v(dout1_31) AT=2980.1n

* CHECK dout2_0 Vdout2_0ck148 = 0 time = 2980
.meas tran vdout2_0ck148 FIND v(dout2_0) AT=2980.1n

* CHECK dout2_1 Vdout2_1ck148 = 1.8 time = 2980
.meas tran vdout2_1ck148 FIND v(dout2_1) AT=2980.1n

* CHECK dout2_2 Vdout2_2ck148 = 0 time = 2980
.meas tran vdout2_2ck148 FIND v(dout2_2) AT=2980.1n

* CHECK dout2_3 Vdout2_3ck148 = 1.8 time = 2980
.meas tran vdout2_3ck148 FIND v(dout2_3) AT=2980.1n

* CHECK dout2_4 Vdout2_4ck148 = 0 time = 2980
.meas tran vdout2_4ck148 FIND v(dout2_4) AT=2980.1n

* CHECK dout2_5 Vdout2_5ck148 = 0 time = 2980
.meas tran vdout2_5ck148 FIND v(dout2_5) AT=2980.1n

* CHECK dout2_6 Vdout2_6ck148 = 0 time = 2980
.meas tran vdout2_6ck148 FIND v(dout2_6) AT=2980.1n

* CHECK dout2_7 Vdout2_7ck148 = 1.8 time = 2980
.meas tran vdout2_7ck148 FIND v(dout2_7) AT=2980.1n

* CHECK dout2_8 Vdout2_8ck148 = 1.8 time = 2980
.meas tran vdout2_8ck148 FIND v(dout2_8) AT=2980.1n

* CHECK dout2_9 Vdout2_9ck148 = 0 time = 2980
.meas tran vdout2_9ck148 FIND v(dout2_9) AT=2980.1n

* CHECK dout2_10 Vdout2_10ck148 = 1.8 time = 2980
.meas tran vdout2_10ck148 FIND v(dout2_10) AT=2980.1n

* CHECK dout2_11 Vdout2_11ck148 = 0 time = 2980
.meas tran vdout2_11ck148 FIND v(dout2_11) AT=2980.1n

* CHECK dout2_12 Vdout2_12ck148 = 0 time = 2980
.meas tran vdout2_12ck148 FIND v(dout2_12) AT=2980.1n

* CHECK dout2_13 Vdout2_13ck148 = 0 time = 2980
.meas tran vdout2_13ck148 FIND v(dout2_13) AT=2980.1n

* CHECK dout2_14 Vdout2_14ck148 = 0 time = 2980
.meas tran vdout2_14ck148 FIND v(dout2_14) AT=2980.1n

* CHECK dout2_15 Vdout2_15ck148 = 1.8 time = 2980
.meas tran vdout2_15ck148 FIND v(dout2_15) AT=2980.1n

* CHECK dout2_16 Vdout2_16ck148 = 1.8 time = 2980
.meas tran vdout2_16ck148 FIND v(dout2_16) AT=2980.1n

* CHECK dout2_17 Vdout2_17ck148 = 0 time = 2980
.meas tran vdout2_17ck148 FIND v(dout2_17) AT=2980.1n

* CHECK dout2_18 Vdout2_18ck148 = 1.8 time = 2980
.meas tran vdout2_18ck148 FIND v(dout2_18) AT=2980.1n

* CHECK dout2_19 Vdout2_19ck148 = 1.8 time = 2980
.meas tran vdout2_19ck148 FIND v(dout2_19) AT=2980.1n

* CHECK dout2_20 Vdout2_20ck148 = 0 time = 2980
.meas tran vdout2_20ck148 FIND v(dout2_20) AT=2980.1n

* CHECK dout2_21 Vdout2_21ck148 = 0 time = 2980
.meas tran vdout2_21ck148 FIND v(dout2_21) AT=2980.1n

* CHECK dout2_22 Vdout2_22ck148 = 1.8 time = 2980
.meas tran vdout2_22ck148 FIND v(dout2_22) AT=2980.1n

* CHECK dout2_23 Vdout2_23ck148 = 1.8 time = 2980
.meas tran vdout2_23ck148 FIND v(dout2_23) AT=2980.1n

* CHECK dout2_24 Vdout2_24ck148 = 1.8 time = 2980
.meas tran vdout2_24ck148 FIND v(dout2_24) AT=2980.1n

* CHECK dout2_25 Vdout2_25ck148 = 0 time = 2980
.meas tran vdout2_25ck148 FIND v(dout2_25) AT=2980.1n

* CHECK dout2_26 Vdout2_26ck148 = 0 time = 2980
.meas tran vdout2_26ck148 FIND v(dout2_26) AT=2980.1n

* CHECK dout2_27 Vdout2_27ck148 = 0 time = 2980
.meas tran vdout2_27ck148 FIND v(dout2_27) AT=2980.1n

* CHECK dout2_28 Vdout2_28ck148 = 0 time = 2980
.meas tran vdout2_28ck148 FIND v(dout2_28) AT=2980.1n

* CHECK dout2_29 Vdout2_29ck148 = 0 time = 2980
.meas tran vdout2_29ck148 FIND v(dout2_29) AT=2980.1n

* CHECK dout2_30 Vdout2_30ck148 = 0 time = 2980
.meas tran vdout2_30ck148 FIND v(dout2_30) AT=2980.1n

* CHECK dout2_31 Vdout2_31ck148 = 1.8 time = 2980
.meas tran vdout2_31ck148 FIND v(dout2_31) AT=2980.1n

* CHECK dout1_0 Vdout1_0ck149 = 1.8 time = 3000
.meas tran vdout1_0ck149 FIND v(dout1_0) AT=3000.1n

* CHECK dout1_1 Vdout1_1ck149 = 1.8 time = 3000
.meas tran vdout1_1ck149 FIND v(dout1_1) AT=3000.1n

* CHECK dout1_2 Vdout1_2ck149 = 0 time = 3000
.meas tran vdout1_2ck149 FIND v(dout1_2) AT=3000.1n

* CHECK dout1_3 Vdout1_3ck149 = 0 time = 3000
.meas tran vdout1_3ck149 FIND v(dout1_3) AT=3000.1n

* CHECK dout1_4 Vdout1_4ck149 = 0 time = 3000
.meas tran vdout1_4ck149 FIND v(dout1_4) AT=3000.1n

* CHECK dout1_5 Vdout1_5ck149 = 0 time = 3000
.meas tran vdout1_5ck149 FIND v(dout1_5) AT=3000.1n

* CHECK dout1_6 Vdout1_6ck149 = 0 time = 3000
.meas tran vdout1_6ck149 FIND v(dout1_6) AT=3000.1n

* CHECK dout1_7 Vdout1_7ck149 = 0 time = 3000
.meas tran vdout1_7ck149 FIND v(dout1_7) AT=3000.1n

* CHECK dout1_8 Vdout1_8ck149 = 0 time = 3000
.meas tran vdout1_8ck149 FIND v(dout1_8) AT=3000.1n

* CHECK dout1_9 Vdout1_9ck149 = 0 time = 3000
.meas tran vdout1_9ck149 FIND v(dout1_9) AT=3000.1n

* CHECK dout1_10 Vdout1_10ck149 = 0 time = 3000
.meas tran vdout1_10ck149 FIND v(dout1_10) AT=3000.1n

* CHECK dout1_11 Vdout1_11ck149 = 1.8 time = 3000
.meas tran vdout1_11ck149 FIND v(dout1_11) AT=3000.1n

* CHECK dout1_12 Vdout1_12ck149 = 0 time = 3000
.meas tran vdout1_12ck149 FIND v(dout1_12) AT=3000.1n

* CHECK dout1_13 Vdout1_13ck149 = 0 time = 3000
.meas tran vdout1_13ck149 FIND v(dout1_13) AT=3000.1n

* CHECK dout1_14 Vdout1_14ck149 = 1.8 time = 3000
.meas tran vdout1_14ck149 FIND v(dout1_14) AT=3000.1n

* CHECK dout1_15 Vdout1_15ck149 = 1.8 time = 3000
.meas tran vdout1_15ck149 FIND v(dout1_15) AT=3000.1n

* CHECK dout1_16 Vdout1_16ck149 = 0 time = 3000
.meas tran vdout1_16ck149 FIND v(dout1_16) AT=3000.1n

* CHECK dout1_17 Vdout1_17ck149 = 1.8 time = 3000
.meas tran vdout1_17ck149 FIND v(dout1_17) AT=3000.1n

* CHECK dout1_18 Vdout1_18ck149 = 0 time = 3000
.meas tran vdout1_18ck149 FIND v(dout1_18) AT=3000.1n

* CHECK dout1_19 Vdout1_19ck149 = 0 time = 3000
.meas tran vdout1_19ck149 FIND v(dout1_19) AT=3000.1n

* CHECK dout1_20 Vdout1_20ck149 = 1.8 time = 3000
.meas tran vdout1_20ck149 FIND v(dout1_20) AT=3000.1n

* CHECK dout1_21 Vdout1_21ck149 = 0 time = 3000
.meas tran vdout1_21ck149 FIND v(dout1_21) AT=3000.1n

* CHECK dout1_22 Vdout1_22ck149 = 1.8 time = 3000
.meas tran vdout1_22ck149 FIND v(dout1_22) AT=3000.1n

* CHECK dout1_23 Vdout1_23ck149 = 0 time = 3000
.meas tran vdout1_23ck149 FIND v(dout1_23) AT=3000.1n

* CHECK dout1_24 Vdout1_24ck149 = 1.8 time = 3000
.meas tran vdout1_24ck149 FIND v(dout1_24) AT=3000.1n

* CHECK dout1_25 Vdout1_25ck149 = 1.8 time = 3000
.meas tran vdout1_25ck149 FIND v(dout1_25) AT=3000.1n

* CHECK dout1_26 Vdout1_26ck149 = 1.8 time = 3000
.meas tran vdout1_26ck149 FIND v(dout1_26) AT=3000.1n

* CHECK dout1_27 Vdout1_27ck149 = 0 time = 3000
.meas tran vdout1_27ck149 FIND v(dout1_27) AT=3000.1n

* CHECK dout1_28 Vdout1_28ck149 = 0 time = 3000
.meas tran vdout1_28ck149 FIND v(dout1_28) AT=3000.1n

* CHECK dout1_29 Vdout1_29ck149 = 0 time = 3000
.meas tran vdout1_29ck149 FIND v(dout1_29) AT=3000.1n

* CHECK dout1_30 Vdout1_30ck149 = 1.8 time = 3000
.meas tran vdout1_30ck149 FIND v(dout1_30) AT=3000.1n

* CHECK dout1_31 Vdout1_31ck149 = 0 time = 3000
.meas tran vdout1_31ck149 FIND v(dout1_31) AT=3000.1n

* CHECK dout2_0 Vdout2_0ck149 = 1.8 time = 3000
.meas tran vdout2_0ck149 FIND v(dout2_0) AT=3000.1n

* CHECK dout2_1 Vdout2_1ck149 = 1.8 time = 3000
.meas tran vdout2_1ck149 FIND v(dout2_1) AT=3000.1n

* CHECK dout2_2 Vdout2_2ck149 = 0 time = 3000
.meas tran vdout2_2ck149 FIND v(dout2_2) AT=3000.1n

* CHECK dout2_3 Vdout2_3ck149 = 0 time = 3000
.meas tran vdout2_3ck149 FIND v(dout2_3) AT=3000.1n

* CHECK dout2_4 Vdout2_4ck149 = 0 time = 3000
.meas tran vdout2_4ck149 FIND v(dout2_4) AT=3000.1n

* CHECK dout2_5 Vdout2_5ck149 = 0 time = 3000
.meas tran vdout2_5ck149 FIND v(dout2_5) AT=3000.1n

* CHECK dout2_6 Vdout2_6ck149 = 0 time = 3000
.meas tran vdout2_6ck149 FIND v(dout2_6) AT=3000.1n

* CHECK dout2_7 Vdout2_7ck149 = 0 time = 3000
.meas tran vdout2_7ck149 FIND v(dout2_7) AT=3000.1n

* CHECK dout2_8 Vdout2_8ck149 = 0 time = 3000
.meas tran vdout2_8ck149 FIND v(dout2_8) AT=3000.1n

* CHECK dout2_9 Vdout2_9ck149 = 0 time = 3000
.meas tran vdout2_9ck149 FIND v(dout2_9) AT=3000.1n

* CHECK dout2_10 Vdout2_10ck149 = 0 time = 3000
.meas tran vdout2_10ck149 FIND v(dout2_10) AT=3000.1n

* CHECK dout2_11 Vdout2_11ck149 = 1.8 time = 3000
.meas tran vdout2_11ck149 FIND v(dout2_11) AT=3000.1n

* CHECK dout2_12 Vdout2_12ck149 = 0 time = 3000
.meas tran vdout2_12ck149 FIND v(dout2_12) AT=3000.1n

* CHECK dout2_13 Vdout2_13ck149 = 0 time = 3000
.meas tran vdout2_13ck149 FIND v(dout2_13) AT=3000.1n

* CHECK dout2_14 Vdout2_14ck149 = 1.8 time = 3000
.meas tran vdout2_14ck149 FIND v(dout2_14) AT=3000.1n

* CHECK dout2_15 Vdout2_15ck149 = 1.8 time = 3000
.meas tran vdout2_15ck149 FIND v(dout2_15) AT=3000.1n

* CHECK dout2_16 Vdout2_16ck149 = 0 time = 3000
.meas tran vdout2_16ck149 FIND v(dout2_16) AT=3000.1n

* CHECK dout2_17 Vdout2_17ck149 = 1.8 time = 3000
.meas tran vdout2_17ck149 FIND v(dout2_17) AT=3000.1n

* CHECK dout2_18 Vdout2_18ck149 = 0 time = 3000
.meas tran vdout2_18ck149 FIND v(dout2_18) AT=3000.1n

* CHECK dout2_19 Vdout2_19ck149 = 0 time = 3000
.meas tran vdout2_19ck149 FIND v(dout2_19) AT=3000.1n

* CHECK dout2_20 Vdout2_20ck149 = 1.8 time = 3000
.meas tran vdout2_20ck149 FIND v(dout2_20) AT=3000.1n

* CHECK dout2_21 Vdout2_21ck149 = 0 time = 3000
.meas tran vdout2_21ck149 FIND v(dout2_21) AT=3000.1n

* CHECK dout2_22 Vdout2_22ck149 = 1.8 time = 3000
.meas tran vdout2_22ck149 FIND v(dout2_22) AT=3000.1n

* CHECK dout2_23 Vdout2_23ck149 = 0 time = 3000
.meas tran vdout2_23ck149 FIND v(dout2_23) AT=3000.1n

* CHECK dout2_24 Vdout2_24ck149 = 1.8 time = 3000
.meas tran vdout2_24ck149 FIND v(dout2_24) AT=3000.1n

* CHECK dout2_25 Vdout2_25ck149 = 1.8 time = 3000
.meas tran vdout2_25ck149 FIND v(dout2_25) AT=3000.1n

* CHECK dout2_26 Vdout2_26ck149 = 1.8 time = 3000
.meas tran vdout2_26ck149 FIND v(dout2_26) AT=3000.1n

* CHECK dout2_27 Vdout2_27ck149 = 0 time = 3000
.meas tran vdout2_27ck149 FIND v(dout2_27) AT=3000.1n

* CHECK dout2_28 Vdout2_28ck149 = 0 time = 3000
.meas tran vdout2_28ck149 FIND v(dout2_28) AT=3000.1n

* CHECK dout2_29 Vdout2_29ck149 = 0 time = 3000
.meas tran vdout2_29ck149 FIND v(dout2_29) AT=3000.1n

* CHECK dout2_30 Vdout2_30ck149 = 1.8 time = 3000
.meas tran vdout2_30ck149 FIND v(dout2_30) AT=3000.1n

* CHECK dout2_31 Vdout2_31ck149 = 0 time = 3000
.meas tran vdout2_31ck149 FIND v(dout2_31) AT=3000.1n

* CHECK dout2_0 Vdout2_0ck150 = 1.8 time = 3020
.meas tran vdout2_0ck150 FIND v(dout2_0) AT=3020.1n

* CHECK dout2_1 Vdout2_1ck150 = 1.8 time = 3020
.meas tran vdout2_1ck150 FIND v(dout2_1) AT=3020.1n

* CHECK dout2_2 Vdout2_2ck150 = 1.8 time = 3020
.meas tran vdout2_2ck150 FIND v(dout2_2) AT=3020.1n

* CHECK dout2_3 Vdout2_3ck150 = 0 time = 3020
.meas tran vdout2_3ck150 FIND v(dout2_3) AT=3020.1n

* CHECK dout2_4 Vdout2_4ck150 = 1.8 time = 3020
.meas tran vdout2_4ck150 FIND v(dout2_4) AT=3020.1n

* CHECK dout2_5 Vdout2_5ck150 = 1.8 time = 3020
.meas tran vdout2_5ck150 FIND v(dout2_5) AT=3020.1n

* CHECK dout2_6 Vdout2_6ck150 = 0 time = 3020
.meas tran vdout2_6ck150 FIND v(dout2_6) AT=3020.1n

* CHECK dout2_7 Vdout2_7ck150 = 1.8 time = 3020
.meas tran vdout2_7ck150 FIND v(dout2_7) AT=3020.1n

* CHECK dout2_8 Vdout2_8ck150 = 1.8 time = 3020
.meas tran vdout2_8ck150 FIND v(dout2_8) AT=3020.1n

* CHECK dout2_9 Vdout2_9ck150 = 1.8 time = 3020
.meas tran vdout2_9ck150 FIND v(dout2_9) AT=3020.1n

* CHECK dout2_10 Vdout2_10ck150 = 1.8 time = 3020
.meas tran vdout2_10ck150 FIND v(dout2_10) AT=3020.1n

* CHECK dout2_11 Vdout2_11ck150 = 0 time = 3020
.meas tran vdout2_11ck150 FIND v(dout2_11) AT=3020.1n

* CHECK dout2_12 Vdout2_12ck150 = 0 time = 3020
.meas tran vdout2_12ck150 FIND v(dout2_12) AT=3020.1n

* CHECK dout2_13 Vdout2_13ck150 = 0 time = 3020
.meas tran vdout2_13ck150 FIND v(dout2_13) AT=3020.1n

* CHECK dout2_14 Vdout2_14ck150 = 0 time = 3020
.meas tran vdout2_14ck150 FIND v(dout2_14) AT=3020.1n

* CHECK dout2_15 Vdout2_15ck150 = 1.8 time = 3020
.meas tran vdout2_15ck150 FIND v(dout2_15) AT=3020.1n

* CHECK dout2_16 Vdout2_16ck150 = 0 time = 3020
.meas tran vdout2_16ck150 FIND v(dout2_16) AT=3020.1n

* CHECK dout2_17 Vdout2_17ck150 = 1.8 time = 3020
.meas tran vdout2_17ck150 FIND v(dout2_17) AT=3020.1n

* CHECK dout2_18 Vdout2_18ck150 = 0 time = 3020
.meas tran vdout2_18ck150 FIND v(dout2_18) AT=3020.1n

* CHECK dout2_19 Vdout2_19ck150 = 0 time = 3020
.meas tran vdout2_19ck150 FIND v(dout2_19) AT=3020.1n

* CHECK dout2_20 Vdout2_20ck150 = 1.8 time = 3020
.meas tran vdout2_20ck150 FIND v(dout2_20) AT=3020.1n

* CHECK dout2_21 Vdout2_21ck150 = 1.8 time = 3020
.meas tran vdout2_21ck150 FIND v(dout2_21) AT=3020.1n

* CHECK dout2_22 Vdout2_22ck150 = 1.8 time = 3020
.meas tran vdout2_22ck150 FIND v(dout2_22) AT=3020.1n

* CHECK dout2_23 Vdout2_23ck150 = 0 time = 3020
.meas tran vdout2_23ck150 FIND v(dout2_23) AT=3020.1n

* CHECK dout2_24 Vdout2_24ck150 = 0 time = 3020
.meas tran vdout2_24ck150 FIND v(dout2_24) AT=3020.1n

* CHECK dout2_25 Vdout2_25ck150 = 0 time = 3020
.meas tran vdout2_25ck150 FIND v(dout2_25) AT=3020.1n

* CHECK dout2_26 Vdout2_26ck150 = 0 time = 3020
.meas tran vdout2_26ck150 FIND v(dout2_26) AT=3020.1n

* CHECK dout2_27 Vdout2_27ck150 = 0 time = 3020
.meas tran vdout2_27ck150 FIND v(dout2_27) AT=3020.1n

* CHECK dout2_28 Vdout2_28ck150 = 0 time = 3020
.meas tran vdout2_28ck150 FIND v(dout2_28) AT=3020.1n

* CHECK dout2_29 Vdout2_29ck150 = 1.8 time = 3020
.meas tran vdout2_29ck150 FIND v(dout2_29) AT=3020.1n

* CHECK dout2_30 Vdout2_30ck150 = 1.8 time = 3020
.meas tran vdout2_30ck150 FIND v(dout2_30) AT=3020.1n

* CHECK dout2_31 Vdout2_31ck150 = 1.8 time = 3020
.meas tran vdout2_31ck150 FIND v(dout2_31) AT=3020.1n

* CHECK dout1_0 Vdout1_0ck151 = 1.8 time = 3040
.meas tran vdout1_0ck151 FIND v(dout1_0) AT=3040.1n

* CHECK dout1_1 Vdout1_1ck151 = 1.8 time = 3040
.meas tran vdout1_1ck151 FIND v(dout1_1) AT=3040.1n

* CHECK dout1_2 Vdout1_2ck151 = 0 time = 3040
.meas tran vdout1_2ck151 FIND v(dout1_2) AT=3040.1n

* CHECK dout1_3 Vdout1_3ck151 = 0 time = 3040
.meas tran vdout1_3ck151 FIND v(dout1_3) AT=3040.1n

* CHECK dout1_4 Vdout1_4ck151 = 0 time = 3040
.meas tran vdout1_4ck151 FIND v(dout1_4) AT=3040.1n

* CHECK dout1_5 Vdout1_5ck151 = 0 time = 3040
.meas tran vdout1_5ck151 FIND v(dout1_5) AT=3040.1n

* CHECK dout1_6 Vdout1_6ck151 = 0 time = 3040
.meas tran vdout1_6ck151 FIND v(dout1_6) AT=3040.1n

* CHECK dout1_7 Vdout1_7ck151 = 0 time = 3040
.meas tran vdout1_7ck151 FIND v(dout1_7) AT=3040.1n

* CHECK dout1_8 Vdout1_8ck151 = 0 time = 3040
.meas tran vdout1_8ck151 FIND v(dout1_8) AT=3040.1n

* CHECK dout1_9 Vdout1_9ck151 = 0 time = 3040
.meas tran vdout1_9ck151 FIND v(dout1_9) AT=3040.1n

* CHECK dout1_10 Vdout1_10ck151 = 0 time = 3040
.meas tran vdout1_10ck151 FIND v(dout1_10) AT=3040.1n

* CHECK dout1_11 Vdout1_11ck151 = 1.8 time = 3040
.meas tran vdout1_11ck151 FIND v(dout1_11) AT=3040.1n

* CHECK dout1_12 Vdout1_12ck151 = 0 time = 3040
.meas tran vdout1_12ck151 FIND v(dout1_12) AT=3040.1n

* CHECK dout1_13 Vdout1_13ck151 = 0 time = 3040
.meas tran vdout1_13ck151 FIND v(dout1_13) AT=3040.1n

* CHECK dout1_14 Vdout1_14ck151 = 1.8 time = 3040
.meas tran vdout1_14ck151 FIND v(dout1_14) AT=3040.1n

* CHECK dout1_15 Vdout1_15ck151 = 1.8 time = 3040
.meas tran vdout1_15ck151 FIND v(dout1_15) AT=3040.1n

* CHECK dout1_16 Vdout1_16ck151 = 0 time = 3040
.meas tran vdout1_16ck151 FIND v(dout1_16) AT=3040.1n

* CHECK dout1_17 Vdout1_17ck151 = 1.8 time = 3040
.meas tran vdout1_17ck151 FIND v(dout1_17) AT=3040.1n

* CHECK dout1_18 Vdout1_18ck151 = 0 time = 3040
.meas tran vdout1_18ck151 FIND v(dout1_18) AT=3040.1n

* CHECK dout1_19 Vdout1_19ck151 = 0 time = 3040
.meas tran vdout1_19ck151 FIND v(dout1_19) AT=3040.1n

* CHECK dout1_20 Vdout1_20ck151 = 1.8 time = 3040
.meas tran vdout1_20ck151 FIND v(dout1_20) AT=3040.1n

* CHECK dout1_21 Vdout1_21ck151 = 0 time = 3040
.meas tran vdout1_21ck151 FIND v(dout1_21) AT=3040.1n

* CHECK dout1_22 Vdout1_22ck151 = 1.8 time = 3040
.meas tran vdout1_22ck151 FIND v(dout1_22) AT=3040.1n

* CHECK dout1_23 Vdout1_23ck151 = 0 time = 3040
.meas tran vdout1_23ck151 FIND v(dout1_23) AT=3040.1n

* CHECK dout1_24 Vdout1_24ck151 = 1.8 time = 3040
.meas tran vdout1_24ck151 FIND v(dout1_24) AT=3040.1n

* CHECK dout1_25 Vdout1_25ck151 = 1.8 time = 3040
.meas tran vdout1_25ck151 FIND v(dout1_25) AT=3040.1n

* CHECK dout1_26 Vdout1_26ck151 = 1.8 time = 3040
.meas tran vdout1_26ck151 FIND v(dout1_26) AT=3040.1n

* CHECK dout1_27 Vdout1_27ck151 = 0 time = 3040
.meas tran vdout1_27ck151 FIND v(dout1_27) AT=3040.1n

* CHECK dout1_28 Vdout1_28ck151 = 0 time = 3040
.meas tran vdout1_28ck151 FIND v(dout1_28) AT=3040.1n

* CHECK dout1_29 Vdout1_29ck151 = 0 time = 3040
.meas tran vdout1_29ck151 FIND v(dout1_29) AT=3040.1n

* CHECK dout1_30 Vdout1_30ck151 = 1.8 time = 3040
.meas tran vdout1_30ck151 FIND v(dout1_30) AT=3040.1n

* CHECK dout1_31 Vdout1_31ck151 = 0 time = 3040
.meas tran vdout1_31ck151 FIND v(dout1_31) AT=3040.1n

* CHECK dout2_0 Vdout2_0ck151 = 1.8 time = 3040
.meas tran vdout2_0ck151 FIND v(dout2_0) AT=3040.1n

* CHECK dout2_1 Vdout2_1ck151 = 0 time = 3040
.meas tran vdout2_1ck151 FIND v(dout2_1) AT=3040.1n

* CHECK dout2_2 Vdout2_2ck151 = 1.8 time = 3040
.meas tran vdout2_2ck151 FIND v(dout2_2) AT=3040.1n

* CHECK dout2_3 Vdout2_3ck151 = 1.8 time = 3040
.meas tran vdout2_3ck151 FIND v(dout2_3) AT=3040.1n

* CHECK dout2_4 Vdout2_4ck151 = 1.8 time = 3040
.meas tran vdout2_4ck151 FIND v(dout2_4) AT=3040.1n

* CHECK dout2_5 Vdout2_5ck151 = 1.8 time = 3040
.meas tran vdout2_5ck151 FIND v(dout2_5) AT=3040.1n

* CHECK dout2_6 Vdout2_6ck151 = 0 time = 3040
.meas tran vdout2_6ck151 FIND v(dout2_6) AT=3040.1n

* CHECK dout2_7 Vdout2_7ck151 = 1.8 time = 3040
.meas tran vdout2_7ck151 FIND v(dout2_7) AT=3040.1n

* CHECK dout2_8 Vdout2_8ck151 = 1.8 time = 3040
.meas tran vdout2_8ck151 FIND v(dout2_8) AT=3040.1n

* CHECK dout2_9 Vdout2_9ck151 = 1.8 time = 3040
.meas tran vdout2_9ck151 FIND v(dout2_9) AT=3040.1n

* CHECK dout2_10 Vdout2_10ck151 = 0 time = 3040
.meas tran vdout2_10ck151 FIND v(dout2_10) AT=3040.1n

* CHECK dout2_11 Vdout2_11ck151 = 0 time = 3040
.meas tran vdout2_11ck151 FIND v(dout2_11) AT=3040.1n

* CHECK dout2_12 Vdout2_12ck151 = 0 time = 3040
.meas tran vdout2_12ck151 FIND v(dout2_12) AT=3040.1n

* CHECK dout2_13 Vdout2_13ck151 = 0 time = 3040
.meas tran vdout2_13ck151 FIND v(dout2_13) AT=3040.1n

* CHECK dout2_14 Vdout2_14ck151 = 1.8 time = 3040
.meas tran vdout2_14ck151 FIND v(dout2_14) AT=3040.1n

* CHECK dout2_15 Vdout2_15ck151 = 0 time = 3040
.meas tran vdout2_15ck151 FIND v(dout2_15) AT=3040.1n

* CHECK dout2_16 Vdout2_16ck151 = 1.8 time = 3040
.meas tran vdout2_16ck151 FIND v(dout2_16) AT=3040.1n

* CHECK dout2_17 Vdout2_17ck151 = 0 time = 3040
.meas tran vdout2_17ck151 FIND v(dout2_17) AT=3040.1n

* CHECK dout2_18 Vdout2_18ck151 = 0 time = 3040
.meas tran vdout2_18ck151 FIND v(dout2_18) AT=3040.1n

* CHECK dout2_19 Vdout2_19ck151 = 1.8 time = 3040
.meas tran vdout2_19ck151 FIND v(dout2_19) AT=3040.1n

* CHECK dout2_20 Vdout2_20ck151 = 1.8 time = 3040
.meas tran vdout2_20ck151 FIND v(dout2_20) AT=3040.1n

* CHECK dout2_21 Vdout2_21ck151 = 1.8 time = 3040
.meas tran vdout2_21ck151 FIND v(dout2_21) AT=3040.1n

* CHECK dout2_22 Vdout2_22ck151 = 1.8 time = 3040
.meas tran vdout2_22ck151 FIND v(dout2_22) AT=3040.1n

* CHECK dout2_23 Vdout2_23ck151 = 1.8 time = 3040
.meas tran vdout2_23ck151 FIND v(dout2_23) AT=3040.1n

* CHECK dout2_24 Vdout2_24ck151 = 1.8 time = 3040
.meas tran vdout2_24ck151 FIND v(dout2_24) AT=3040.1n

* CHECK dout2_25 Vdout2_25ck151 = 0 time = 3040
.meas tran vdout2_25ck151 FIND v(dout2_25) AT=3040.1n

* CHECK dout2_26 Vdout2_26ck151 = 0 time = 3040
.meas tran vdout2_26ck151 FIND v(dout2_26) AT=3040.1n

* CHECK dout2_27 Vdout2_27ck151 = 1.8 time = 3040
.meas tran vdout2_27ck151 FIND v(dout2_27) AT=3040.1n

* CHECK dout2_28 Vdout2_28ck151 = 1.8 time = 3040
.meas tran vdout2_28ck151 FIND v(dout2_28) AT=3040.1n

* CHECK dout2_29 Vdout2_29ck151 = 1.8 time = 3040
.meas tran vdout2_29ck151 FIND v(dout2_29) AT=3040.1n

* CHECK dout2_30 Vdout2_30ck151 = 0 time = 3040
.meas tran vdout2_30ck151 FIND v(dout2_30) AT=3040.1n

* CHECK dout2_31 Vdout2_31ck151 = 1.8 time = 3040
.meas tran vdout2_31ck151 FIND v(dout2_31) AT=3040.1n

* CHECK dout2_0 Vdout2_0ck152 = 1.8 time = 3060
.meas tran vdout2_0ck152 FIND v(dout2_0) AT=3060.1n

* CHECK dout2_1 Vdout2_1ck152 = 1.8 time = 3060
.meas tran vdout2_1ck152 FIND v(dout2_1) AT=3060.1n

* CHECK dout2_2 Vdout2_2ck152 = 1.8 time = 3060
.meas tran vdout2_2ck152 FIND v(dout2_2) AT=3060.1n

* CHECK dout2_3 Vdout2_3ck152 = 0 time = 3060
.meas tran vdout2_3ck152 FIND v(dout2_3) AT=3060.1n

* CHECK dout2_4 Vdout2_4ck152 = 1.8 time = 3060
.meas tran vdout2_4ck152 FIND v(dout2_4) AT=3060.1n

* CHECK dout2_5 Vdout2_5ck152 = 1.8 time = 3060
.meas tran vdout2_5ck152 FIND v(dout2_5) AT=3060.1n

* CHECK dout2_6 Vdout2_6ck152 = 0 time = 3060
.meas tran vdout2_6ck152 FIND v(dout2_6) AT=3060.1n

* CHECK dout2_7 Vdout2_7ck152 = 1.8 time = 3060
.meas tran vdout2_7ck152 FIND v(dout2_7) AT=3060.1n

* CHECK dout2_8 Vdout2_8ck152 = 1.8 time = 3060
.meas tran vdout2_8ck152 FIND v(dout2_8) AT=3060.1n

* CHECK dout2_9 Vdout2_9ck152 = 1.8 time = 3060
.meas tran vdout2_9ck152 FIND v(dout2_9) AT=3060.1n

* CHECK dout2_10 Vdout2_10ck152 = 1.8 time = 3060
.meas tran vdout2_10ck152 FIND v(dout2_10) AT=3060.1n

* CHECK dout2_11 Vdout2_11ck152 = 0 time = 3060
.meas tran vdout2_11ck152 FIND v(dout2_11) AT=3060.1n

* CHECK dout2_12 Vdout2_12ck152 = 0 time = 3060
.meas tran vdout2_12ck152 FIND v(dout2_12) AT=3060.1n

* CHECK dout2_13 Vdout2_13ck152 = 0 time = 3060
.meas tran vdout2_13ck152 FIND v(dout2_13) AT=3060.1n

* CHECK dout2_14 Vdout2_14ck152 = 0 time = 3060
.meas tran vdout2_14ck152 FIND v(dout2_14) AT=3060.1n

* CHECK dout2_15 Vdout2_15ck152 = 1.8 time = 3060
.meas tran vdout2_15ck152 FIND v(dout2_15) AT=3060.1n

* CHECK dout2_16 Vdout2_16ck152 = 0 time = 3060
.meas tran vdout2_16ck152 FIND v(dout2_16) AT=3060.1n

* CHECK dout2_17 Vdout2_17ck152 = 1.8 time = 3060
.meas tran vdout2_17ck152 FIND v(dout2_17) AT=3060.1n

* CHECK dout2_18 Vdout2_18ck152 = 0 time = 3060
.meas tran vdout2_18ck152 FIND v(dout2_18) AT=3060.1n

* CHECK dout2_19 Vdout2_19ck152 = 0 time = 3060
.meas tran vdout2_19ck152 FIND v(dout2_19) AT=3060.1n

* CHECK dout2_20 Vdout2_20ck152 = 1.8 time = 3060
.meas tran vdout2_20ck152 FIND v(dout2_20) AT=3060.1n

* CHECK dout2_21 Vdout2_21ck152 = 1.8 time = 3060
.meas tran vdout2_21ck152 FIND v(dout2_21) AT=3060.1n

* CHECK dout2_22 Vdout2_22ck152 = 1.8 time = 3060
.meas tran vdout2_22ck152 FIND v(dout2_22) AT=3060.1n

* CHECK dout2_23 Vdout2_23ck152 = 0 time = 3060
.meas tran vdout2_23ck152 FIND v(dout2_23) AT=3060.1n

* CHECK dout2_24 Vdout2_24ck152 = 0 time = 3060
.meas tran vdout2_24ck152 FIND v(dout2_24) AT=3060.1n

* CHECK dout2_25 Vdout2_25ck152 = 0 time = 3060
.meas tran vdout2_25ck152 FIND v(dout2_25) AT=3060.1n

* CHECK dout2_26 Vdout2_26ck152 = 0 time = 3060
.meas tran vdout2_26ck152 FIND v(dout2_26) AT=3060.1n

* CHECK dout2_27 Vdout2_27ck152 = 0 time = 3060
.meas tran vdout2_27ck152 FIND v(dout2_27) AT=3060.1n

* CHECK dout2_28 Vdout2_28ck152 = 0 time = 3060
.meas tran vdout2_28ck152 FIND v(dout2_28) AT=3060.1n

* CHECK dout2_29 Vdout2_29ck152 = 1.8 time = 3060
.meas tran vdout2_29ck152 FIND v(dout2_29) AT=3060.1n

* CHECK dout2_30 Vdout2_30ck152 = 1.8 time = 3060
.meas tran vdout2_30ck152 FIND v(dout2_30) AT=3060.1n

* CHECK dout2_31 Vdout2_31ck152 = 1.8 time = 3060
.meas tran vdout2_31ck152 FIND v(dout2_31) AT=3060.1n

* CHECK dout1_0 Vdout1_0ck153 = 1.8 time = 3080
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=3080.1n

* CHECK dout1_1 Vdout1_1ck153 = 1.8 time = 3080
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=3080.1n

* CHECK dout1_2 Vdout1_2ck153 = 1.8 time = 3080
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=3080.1n

* CHECK dout1_3 Vdout1_3ck153 = 0 time = 3080
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=3080.1n

* CHECK dout1_4 Vdout1_4ck153 = 1.8 time = 3080
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=3080.1n

* CHECK dout1_5 Vdout1_5ck153 = 1.8 time = 3080
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=3080.1n

* CHECK dout1_6 Vdout1_6ck153 = 0 time = 3080
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=3080.1n

* CHECK dout1_7 Vdout1_7ck153 = 1.8 time = 3080
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=3080.1n

* CHECK dout1_8 Vdout1_8ck153 = 1.8 time = 3080
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=3080.1n

* CHECK dout1_9 Vdout1_9ck153 = 1.8 time = 3080
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=3080.1n

* CHECK dout1_10 Vdout1_10ck153 = 1.8 time = 3080
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=3080.1n

* CHECK dout1_11 Vdout1_11ck153 = 0 time = 3080
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=3080.1n

* CHECK dout1_12 Vdout1_12ck153 = 0 time = 3080
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=3080.1n

* CHECK dout1_13 Vdout1_13ck153 = 0 time = 3080
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=3080.1n

* CHECK dout1_14 Vdout1_14ck153 = 0 time = 3080
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=3080.1n

* CHECK dout1_15 Vdout1_15ck153 = 1.8 time = 3080
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=3080.1n

* CHECK dout1_16 Vdout1_16ck153 = 0 time = 3080
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=3080.1n

* CHECK dout1_17 Vdout1_17ck153 = 1.8 time = 3080
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=3080.1n

* CHECK dout1_18 Vdout1_18ck153 = 0 time = 3080
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=3080.1n

* CHECK dout1_19 Vdout1_19ck153 = 0 time = 3080
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=3080.1n

* CHECK dout1_20 Vdout1_20ck153 = 1.8 time = 3080
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=3080.1n

* CHECK dout1_21 Vdout1_21ck153 = 1.8 time = 3080
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=3080.1n

* CHECK dout1_22 Vdout1_22ck153 = 1.8 time = 3080
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=3080.1n

* CHECK dout1_23 Vdout1_23ck153 = 0 time = 3080
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=3080.1n

* CHECK dout1_24 Vdout1_24ck153 = 0 time = 3080
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=3080.1n

* CHECK dout1_25 Vdout1_25ck153 = 0 time = 3080
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=3080.1n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 3080
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=3080.1n

* CHECK dout1_27 Vdout1_27ck153 = 0 time = 3080
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=3080.1n

* CHECK dout1_28 Vdout1_28ck153 = 0 time = 3080
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=3080.1n

* CHECK dout1_29 Vdout1_29ck153 = 1.8 time = 3080
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=3080.1n

* CHECK dout1_30 Vdout1_30ck153 = 1.8 time = 3080
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=3080.1n

* CHECK dout1_31 Vdout1_31ck153 = 1.8 time = 3080
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=3080.1n

* CHECK dout2_0 Vdout2_0ck153 = 1.8 time = 3080
.meas tran vdout2_0ck153 FIND v(dout2_0) AT=3080.1n

* CHECK dout2_1 Vdout2_1ck153 = 0 time = 3080
.meas tran vdout2_1ck153 FIND v(dout2_1) AT=3080.1n

* CHECK dout2_2 Vdout2_2ck153 = 1.8 time = 3080
.meas tran vdout2_2ck153 FIND v(dout2_2) AT=3080.1n

* CHECK dout2_3 Vdout2_3ck153 = 1.8 time = 3080
.meas tran vdout2_3ck153 FIND v(dout2_3) AT=3080.1n

* CHECK dout2_4 Vdout2_4ck153 = 1.8 time = 3080
.meas tran vdout2_4ck153 FIND v(dout2_4) AT=3080.1n

* CHECK dout2_5 Vdout2_5ck153 = 1.8 time = 3080
.meas tran vdout2_5ck153 FIND v(dout2_5) AT=3080.1n

* CHECK dout2_6 Vdout2_6ck153 = 0 time = 3080
.meas tran vdout2_6ck153 FIND v(dout2_6) AT=3080.1n

* CHECK dout2_7 Vdout2_7ck153 = 1.8 time = 3080
.meas tran vdout2_7ck153 FIND v(dout2_7) AT=3080.1n

* CHECK dout2_8 Vdout2_8ck153 = 1.8 time = 3080
.meas tran vdout2_8ck153 FIND v(dout2_8) AT=3080.1n

* CHECK dout2_9 Vdout2_9ck153 = 1.8 time = 3080
.meas tran vdout2_9ck153 FIND v(dout2_9) AT=3080.1n

* CHECK dout2_10 Vdout2_10ck153 = 0 time = 3080
.meas tran vdout2_10ck153 FIND v(dout2_10) AT=3080.1n

* CHECK dout2_11 Vdout2_11ck153 = 0 time = 3080
.meas tran vdout2_11ck153 FIND v(dout2_11) AT=3080.1n

* CHECK dout2_12 Vdout2_12ck153 = 0 time = 3080
.meas tran vdout2_12ck153 FIND v(dout2_12) AT=3080.1n

* CHECK dout2_13 Vdout2_13ck153 = 0 time = 3080
.meas tran vdout2_13ck153 FIND v(dout2_13) AT=3080.1n

* CHECK dout2_14 Vdout2_14ck153 = 1.8 time = 3080
.meas tran vdout2_14ck153 FIND v(dout2_14) AT=3080.1n

* CHECK dout2_15 Vdout2_15ck153 = 0 time = 3080
.meas tran vdout2_15ck153 FIND v(dout2_15) AT=3080.1n

* CHECK dout2_16 Vdout2_16ck153 = 1.8 time = 3080
.meas tran vdout2_16ck153 FIND v(dout2_16) AT=3080.1n

* CHECK dout2_17 Vdout2_17ck153 = 0 time = 3080
.meas tran vdout2_17ck153 FIND v(dout2_17) AT=3080.1n

* CHECK dout2_18 Vdout2_18ck153 = 0 time = 3080
.meas tran vdout2_18ck153 FIND v(dout2_18) AT=3080.1n

* CHECK dout2_19 Vdout2_19ck153 = 1.8 time = 3080
.meas tran vdout2_19ck153 FIND v(dout2_19) AT=3080.1n

* CHECK dout2_20 Vdout2_20ck153 = 1.8 time = 3080
.meas tran vdout2_20ck153 FIND v(dout2_20) AT=3080.1n

* CHECK dout2_21 Vdout2_21ck153 = 1.8 time = 3080
.meas tran vdout2_21ck153 FIND v(dout2_21) AT=3080.1n

* CHECK dout2_22 Vdout2_22ck153 = 1.8 time = 3080
.meas tran vdout2_22ck153 FIND v(dout2_22) AT=3080.1n

* CHECK dout2_23 Vdout2_23ck153 = 1.8 time = 3080
.meas tran vdout2_23ck153 FIND v(dout2_23) AT=3080.1n

* CHECK dout2_24 Vdout2_24ck153 = 1.8 time = 3080
.meas tran vdout2_24ck153 FIND v(dout2_24) AT=3080.1n

* CHECK dout2_25 Vdout2_25ck153 = 0 time = 3080
.meas tran vdout2_25ck153 FIND v(dout2_25) AT=3080.1n

* CHECK dout2_26 Vdout2_26ck153 = 0 time = 3080
.meas tran vdout2_26ck153 FIND v(dout2_26) AT=3080.1n

* CHECK dout2_27 Vdout2_27ck153 = 1.8 time = 3080
.meas tran vdout2_27ck153 FIND v(dout2_27) AT=3080.1n

* CHECK dout2_28 Vdout2_28ck153 = 1.8 time = 3080
.meas tran vdout2_28ck153 FIND v(dout2_28) AT=3080.1n

* CHECK dout2_29 Vdout2_29ck153 = 1.8 time = 3080
.meas tran vdout2_29ck153 FIND v(dout2_29) AT=3080.1n

* CHECK dout2_30 Vdout2_30ck153 = 0 time = 3080
.meas tran vdout2_30ck153 FIND v(dout2_30) AT=3080.1n

* CHECK dout2_31 Vdout2_31ck153 = 1.8 time = 3080
.meas tran vdout2_31ck153 FIND v(dout2_31) AT=3080.1n

* CHECK dout1_0 Vdout1_0ck154 = 0 time = 3100
.meas tran vdout1_0ck154 FIND v(dout1_0) AT=3100.1n

* CHECK dout1_1 Vdout1_1ck154 = 1.8 time = 3100
.meas tran vdout1_1ck154 FIND v(dout1_1) AT=3100.1n

* CHECK dout1_2 Vdout1_2ck154 = 0 time = 3100
.meas tran vdout1_2ck154 FIND v(dout1_2) AT=3100.1n

* CHECK dout1_3 Vdout1_3ck154 = 1.8 time = 3100
.meas tran vdout1_3ck154 FIND v(dout1_3) AT=3100.1n

* CHECK dout1_4 Vdout1_4ck154 = 0 time = 3100
.meas tran vdout1_4ck154 FIND v(dout1_4) AT=3100.1n

* CHECK dout1_5 Vdout1_5ck154 = 0 time = 3100
.meas tran vdout1_5ck154 FIND v(dout1_5) AT=3100.1n

* CHECK dout1_6 Vdout1_6ck154 = 1.8 time = 3100
.meas tran vdout1_6ck154 FIND v(dout1_6) AT=3100.1n

* CHECK dout1_7 Vdout1_7ck154 = 0 time = 3100
.meas tran vdout1_7ck154 FIND v(dout1_7) AT=3100.1n

* CHECK dout1_8 Vdout1_8ck154 = 0 time = 3100
.meas tran vdout1_8ck154 FIND v(dout1_8) AT=3100.1n

* CHECK dout1_9 Vdout1_9ck154 = 1.8 time = 3100
.meas tran vdout1_9ck154 FIND v(dout1_9) AT=3100.1n

* CHECK dout1_10 Vdout1_10ck154 = 0 time = 3100
.meas tran vdout1_10ck154 FIND v(dout1_10) AT=3100.1n

* CHECK dout1_11 Vdout1_11ck154 = 1.8 time = 3100
.meas tran vdout1_11ck154 FIND v(dout1_11) AT=3100.1n

* CHECK dout1_12 Vdout1_12ck154 = 0 time = 3100
.meas tran vdout1_12ck154 FIND v(dout1_12) AT=3100.1n

* CHECK dout1_13 Vdout1_13ck154 = 0 time = 3100
.meas tran vdout1_13ck154 FIND v(dout1_13) AT=3100.1n

* CHECK dout1_14 Vdout1_14ck154 = 1.8 time = 3100
.meas tran vdout1_14ck154 FIND v(dout1_14) AT=3100.1n

* CHECK dout1_15 Vdout1_15ck154 = 0 time = 3100
.meas tran vdout1_15ck154 FIND v(dout1_15) AT=3100.1n

* CHECK dout1_16 Vdout1_16ck154 = 1.8 time = 3100
.meas tran vdout1_16ck154 FIND v(dout1_16) AT=3100.1n

* CHECK dout1_17 Vdout1_17ck154 = 0 time = 3100
.meas tran vdout1_17ck154 FIND v(dout1_17) AT=3100.1n

* CHECK dout1_18 Vdout1_18ck154 = 0 time = 3100
.meas tran vdout1_18ck154 FIND v(dout1_18) AT=3100.1n

* CHECK dout1_19 Vdout1_19ck154 = 1.8 time = 3100
.meas tran vdout1_19ck154 FIND v(dout1_19) AT=3100.1n

* CHECK dout1_20 Vdout1_20ck154 = 0 time = 3100
.meas tran vdout1_20ck154 FIND v(dout1_20) AT=3100.1n

* CHECK dout1_21 Vdout1_21ck154 = 0 time = 3100
.meas tran vdout1_21ck154 FIND v(dout1_21) AT=3100.1n

* CHECK dout1_22 Vdout1_22ck154 = 1.8 time = 3100
.meas tran vdout1_22ck154 FIND v(dout1_22) AT=3100.1n

* CHECK dout1_23 Vdout1_23ck154 = 1.8 time = 3100
.meas tran vdout1_23ck154 FIND v(dout1_23) AT=3100.1n

* CHECK dout1_24 Vdout1_24ck154 = 0 time = 3100
.meas tran vdout1_24ck154 FIND v(dout1_24) AT=3100.1n

* CHECK dout1_25 Vdout1_25ck154 = 1.8 time = 3100
.meas tran vdout1_25ck154 FIND v(dout1_25) AT=3100.1n

* CHECK dout1_26 Vdout1_26ck154 = 0 time = 3100
.meas tran vdout1_26ck154 FIND v(dout1_26) AT=3100.1n

* CHECK dout1_27 Vdout1_27ck154 = 0 time = 3100
.meas tran vdout1_27ck154 FIND v(dout1_27) AT=3100.1n

* CHECK dout1_28 Vdout1_28ck154 = 0 time = 3100
.meas tran vdout1_28ck154 FIND v(dout1_28) AT=3100.1n

* CHECK dout1_29 Vdout1_29ck154 = 0 time = 3100
.meas tran vdout1_29ck154 FIND v(dout1_29) AT=3100.1n

* CHECK dout1_30 Vdout1_30ck154 = 1.8 time = 3100
.meas tran vdout1_30ck154 FIND v(dout1_30) AT=3100.1n

* CHECK dout1_31 Vdout1_31ck154 = 1.8 time = 3100
.meas tran vdout1_31ck154 FIND v(dout1_31) AT=3100.1n

* CHECK dout2_0 Vdout2_0ck154 = 0 time = 3100
.meas tran vdout2_0ck154 FIND v(dout2_0) AT=3100.1n

* CHECK dout2_1 Vdout2_1ck154 = 1.8 time = 3100
.meas tran vdout2_1ck154 FIND v(dout2_1) AT=3100.1n

* CHECK dout2_2 Vdout2_2ck154 = 0 time = 3100
.meas tran vdout2_2ck154 FIND v(dout2_2) AT=3100.1n

* CHECK dout2_3 Vdout2_3ck154 = 1.8 time = 3100
.meas tran vdout2_3ck154 FIND v(dout2_3) AT=3100.1n

* CHECK dout2_4 Vdout2_4ck154 = 0 time = 3100
.meas tran vdout2_4ck154 FIND v(dout2_4) AT=3100.1n

* CHECK dout2_5 Vdout2_5ck154 = 0 time = 3100
.meas tran vdout2_5ck154 FIND v(dout2_5) AT=3100.1n

* CHECK dout2_6 Vdout2_6ck154 = 1.8 time = 3100
.meas tran vdout2_6ck154 FIND v(dout2_6) AT=3100.1n

* CHECK dout2_7 Vdout2_7ck154 = 0 time = 3100
.meas tran vdout2_7ck154 FIND v(dout2_7) AT=3100.1n

* CHECK dout2_8 Vdout2_8ck154 = 0 time = 3100
.meas tran vdout2_8ck154 FIND v(dout2_8) AT=3100.1n

* CHECK dout2_9 Vdout2_9ck154 = 1.8 time = 3100
.meas tran vdout2_9ck154 FIND v(dout2_9) AT=3100.1n

* CHECK dout2_10 Vdout2_10ck154 = 0 time = 3100
.meas tran vdout2_10ck154 FIND v(dout2_10) AT=3100.1n

* CHECK dout2_11 Vdout2_11ck154 = 1.8 time = 3100
.meas tran vdout2_11ck154 FIND v(dout2_11) AT=3100.1n

* CHECK dout2_12 Vdout2_12ck154 = 0 time = 3100
.meas tran vdout2_12ck154 FIND v(dout2_12) AT=3100.1n

* CHECK dout2_13 Vdout2_13ck154 = 0 time = 3100
.meas tran vdout2_13ck154 FIND v(dout2_13) AT=3100.1n

* CHECK dout2_14 Vdout2_14ck154 = 1.8 time = 3100
.meas tran vdout2_14ck154 FIND v(dout2_14) AT=3100.1n

* CHECK dout2_15 Vdout2_15ck154 = 0 time = 3100
.meas tran vdout2_15ck154 FIND v(dout2_15) AT=3100.1n

* CHECK dout2_16 Vdout2_16ck154 = 1.8 time = 3100
.meas tran vdout2_16ck154 FIND v(dout2_16) AT=3100.1n

* CHECK dout2_17 Vdout2_17ck154 = 0 time = 3100
.meas tran vdout2_17ck154 FIND v(dout2_17) AT=3100.1n

* CHECK dout2_18 Vdout2_18ck154 = 0 time = 3100
.meas tran vdout2_18ck154 FIND v(dout2_18) AT=3100.1n

* CHECK dout2_19 Vdout2_19ck154 = 1.8 time = 3100
.meas tran vdout2_19ck154 FIND v(dout2_19) AT=3100.1n

* CHECK dout2_20 Vdout2_20ck154 = 0 time = 3100
.meas tran vdout2_20ck154 FIND v(dout2_20) AT=3100.1n

* CHECK dout2_21 Vdout2_21ck154 = 0 time = 3100
.meas tran vdout2_21ck154 FIND v(dout2_21) AT=3100.1n

* CHECK dout2_22 Vdout2_22ck154 = 1.8 time = 3100
.meas tran vdout2_22ck154 FIND v(dout2_22) AT=3100.1n

* CHECK dout2_23 Vdout2_23ck154 = 1.8 time = 3100
.meas tran vdout2_23ck154 FIND v(dout2_23) AT=3100.1n

* CHECK dout2_24 Vdout2_24ck154 = 0 time = 3100
.meas tran vdout2_24ck154 FIND v(dout2_24) AT=3100.1n

* CHECK dout2_25 Vdout2_25ck154 = 1.8 time = 3100
.meas tran vdout2_25ck154 FIND v(dout2_25) AT=3100.1n

* CHECK dout2_26 Vdout2_26ck154 = 0 time = 3100
.meas tran vdout2_26ck154 FIND v(dout2_26) AT=3100.1n

* CHECK dout2_27 Vdout2_27ck154 = 0 time = 3100
.meas tran vdout2_27ck154 FIND v(dout2_27) AT=3100.1n

* CHECK dout2_28 Vdout2_28ck154 = 0 time = 3100
.meas tran vdout2_28ck154 FIND v(dout2_28) AT=3100.1n

* CHECK dout2_29 Vdout2_29ck154 = 0 time = 3100
.meas tran vdout2_29ck154 FIND v(dout2_29) AT=3100.1n

* CHECK dout2_30 Vdout2_30ck154 = 1.8 time = 3100
.meas tran vdout2_30ck154 FIND v(dout2_30) AT=3100.1n

* CHECK dout2_31 Vdout2_31ck154 = 1.8 time = 3100
.meas tran vdout2_31ck154 FIND v(dout2_31) AT=3100.1n

* CHECK dout1_0 Vdout1_0ck155 = 0 time = 3120
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=3120.1n

* CHECK dout1_1 Vdout1_1ck155 = 1.8 time = 3120
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=3120.1n

* CHECK dout1_2 Vdout1_2ck155 = 0 time = 3120
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=3120.1n

* CHECK dout1_3 Vdout1_3ck155 = 1.8 time = 3120
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=3120.1n

* CHECK dout1_4 Vdout1_4ck155 = 0 time = 3120
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=3120.1n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 3120
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=3120.1n

* CHECK dout1_6 Vdout1_6ck155 = 1.8 time = 3120
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=3120.1n

* CHECK dout1_7 Vdout1_7ck155 = 0 time = 3120
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=3120.1n

* CHECK dout1_8 Vdout1_8ck155 = 0 time = 3120
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=3120.1n

* CHECK dout1_9 Vdout1_9ck155 = 1.8 time = 3120
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=3120.1n

* CHECK dout1_10 Vdout1_10ck155 = 0 time = 3120
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=3120.1n

* CHECK dout1_11 Vdout1_11ck155 = 1.8 time = 3120
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=3120.1n

* CHECK dout1_12 Vdout1_12ck155 = 0 time = 3120
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=3120.1n

* CHECK dout1_13 Vdout1_13ck155 = 0 time = 3120
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=3120.1n

* CHECK dout1_14 Vdout1_14ck155 = 1.8 time = 3120
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=3120.1n

* CHECK dout1_15 Vdout1_15ck155 = 0 time = 3120
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=3120.1n

* CHECK dout1_16 Vdout1_16ck155 = 1.8 time = 3120
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=3120.1n

* CHECK dout1_17 Vdout1_17ck155 = 0 time = 3120
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=3120.1n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 3120
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=3120.1n

* CHECK dout1_19 Vdout1_19ck155 = 1.8 time = 3120
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=3120.1n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 3120
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=3120.1n

* CHECK dout1_21 Vdout1_21ck155 = 0 time = 3120
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=3120.1n

* CHECK dout1_22 Vdout1_22ck155 = 1.8 time = 3120
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=3120.1n

* CHECK dout1_23 Vdout1_23ck155 = 1.8 time = 3120
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=3120.1n

* CHECK dout1_24 Vdout1_24ck155 = 0 time = 3120
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=3120.1n

* CHECK dout1_25 Vdout1_25ck155 = 1.8 time = 3120
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=3120.1n

* CHECK dout1_26 Vdout1_26ck155 = 0 time = 3120
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=3120.1n

* CHECK dout1_27 Vdout1_27ck155 = 0 time = 3120
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=3120.1n

* CHECK dout1_28 Vdout1_28ck155 = 0 time = 3120
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=3120.1n

* CHECK dout1_29 Vdout1_29ck155 = 0 time = 3120
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=3120.1n

* CHECK dout1_30 Vdout1_30ck155 = 1.8 time = 3120
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=3120.1n

* CHECK dout1_31 Vdout1_31ck155 = 1.8 time = 3120
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=3120.1n

* CHECK dout2_0 Vdout2_0ck155 = 1.8 time = 3120
.meas tran vdout2_0ck155 FIND v(dout2_0) AT=3120.1n

* CHECK dout2_1 Vdout2_1ck155 = 1.8 time = 3120
.meas tran vdout2_1ck155 FIND v(dout2_1) AT=3120.1n

* CHECK dout2_2 Vdout2_2ck155 = 1.8 time = 3120
.meas tran vdout2_2ck155 FIND v(dout2_2) AT=3120.1n

* CHECK dout2_3 Vdout2_3ck155 = 0 time = 3120
.meas tran vdout2_3ck155 FIND v(dout2_3) AT=3120.1n

* CHECK dout2_4 Vdout2_4ck155 = 1.8 time = 3120
.meas tran vdout2_4ck155 FIND v(dout2_4) AT=3120.1n

* CHECK dout2_5 Vdout2_5ck155 = 1.8 time = 3120
.meas tran vdout2_5ck155 FIND v(dout2_5) AT=3120.1n

* CHECK dout2_6 Vdout2_6ck155 = 0 time = 3120
.meas tran vdout2_6ck155 FIND v(dout2_6) AT=3120.1n

* CHECK dout2_7 Vdout2_7ck155 = 1.8 time = 3120
.meas tran vdout2_7ck155 FIND v(dout2_7) AT=3120.1n

* CHECK dout2_8 Vdout2_8ck155 = 1.8 time = 3120
.meas tran vdout2_8ck155 FIND v(dout2_8) AT=3120.1n

* CHECK dout2_9 Vdout2_9ck155 = 1.8 time = 3120
.meas tran vdout2_9ck155 FIND v(dout2_9) AT=3120.1n

* CHECK dout2_10 Vdout2_10ck155 = 1.8 time = 3120
.meas tran vdout2_10ck155 FIND v(dout2_10) AT=3120.1n

* CHECK dout2_11 Vdout2_11ck155 = 0 time = 3120
.meas tran vdout2_11ck155 FIND v(dout2_11) AT=3120.1n

* CHECK dout2_12 Vdout2_12ck155 = 0 time = 3120
.meas tran vdout2_12ck155 FIND v(dout2_12) AT=3120.1n

* CHECK dout2_13 Vdout2_13ck155 = 0 time = 3120
.meas tran vdout2_13ck155 FIND v(dout2_13) AT=3120.1n

* CHECK dout2_14 Vdout2_14ck155 = 0 time = 3120
.meas tran vdout2_14ck155 FIND v(dout2_14) AT=3120.1n

* CHECK dout2_15 Vdout2_15ck155 = 1.8 time = 3120
.meas tran vdout2_15ck155 FIND v(dout2_15) AT=3120.1n

* CHECK dout2_16 Vdout2_16ck155 = 0 time = 3120
.meas tran vdout2_16ck155 FIND v(dout2_16) AT=3120.1n

* CHECK dout2_17 Vdout2_17ck155 = 1.8 time = 3120
.meas tran vdout2_17ck155 FIND v(dout2_17) AT=3120.1n

* CHECK dout2_18 Vdout2_18ck155 = 0 time = 3120
.meas tran vdout2_18ck155 FIND v(dout2_18) AT=3120.1n

* CHECK dout2_19 Vdout2_19ck155 = 0 time = 3120
.meas tran vdout2_19ck155 FIND v(dout2_19) AT=3120.1n

* CHECK dout2_20 Vdout2_20ck155 = 1.8 time = 3120
.meas tran vdout2_20ck155 FIND v(dout2_20) AT=3120.1n

* CHECK dout2_21 Vdout2_21ck155 = 1.8 time = 3120
.meas tran vdout2_21ck155 FIND v(dout2_21) AT=3120.1n

* CHECK dout2_22 Vdout2_22ck155 = 1.8 time = 3120
.meas tran vdout2_22ck155 FIND v(dout2_22) AT=3120.1n

* CHECK dout2_23 Vdout2_23ck155 = 0 time = 3120
.meas tran vdout2_23ck155 FIND v(dout2_23) AT=3120.1n

* CHECK dout2_24 Vdout2_24ck155 = 0 time = 3120
.meas tran vdout2_24ck155 FIND v(dout2_24) AT=3120.1n

* CHECK dout2_25 Vdout2_25ck155 = 0 time = 3120
.meas tran vdout2_25ck155 FIND v(dout2_25) AT=3120.1n

* CHECK dout2_26 Vdout2_26ck155 = 0 time = 3120
.meas tran vdout2_26ck155 FIND v(dout2_26) AT=3120.1n

* CHECK dout2_27 Vdout2_27ck155 = 0 time = 3120
.meas tran vdout2_27ck155 FIND v(dout2_27) AT=3120.1n

* CHECK dout2_28 Vdout2_28ck155 = 0 time = 3120
.meas tran vdout2_28ck155 FIND v(dout2_28) AT=3120.1n

* CHECK dout2_29 Vdout2_29ck155 = 1.8 time = 3120
.meas tran vdout2_29ck155 FIND v(dout2_29) AT=3120.1n

* CHECK dout2_30 Vdout2_30ck155 = 1.8 time = 3120
.meas tran vdout2_30ck155 FIND v(dout2_30) AT=3120.1n

* CHECK dout2_31 Vdout2_31ck155 = 1.8 time = 3120
.meas tran vdout2_31ck155 FIND v(dout2_31) AT=3120.1n

* CHECK dout1_0 Vdout1_0ck156 = 0 time = 3140
.meas tran vdout1_0ck156 FIND v(dout1_0) AT=3140.1n

* CHECK dout1_1 Vdout1_1ck156 = 0 time = 3140
.meas tran vdout1_1ck156 FIND v(dout1_1) AT=3140.1n

* CHECK dout1_2 Vdout1_2ck156 = 0 time = 3140
.meas tran vdout1_2ck156 FIND v(dout1_2) AT=3140.1n

* CHECK dout1_3 Vdout1_3ck156 = 1.8 time = 3140
.meas tran vdout1_3ck156 FIND v(dout1_3) AT=3140.1n

* CHECK dout1_4 Vdout1_4ck156 = 0 time = 3140
.meas tran vdout1_4ck156 FIND v(dout1_4) AT=3140.1n

* CHECK dout1_5 Vdout1_5ck156 = 1.8 time = 3140
.meas tran vdout1_5ck156 FIND v(dout1_5) AT=3140.1n

* CHECK dout1_6 Vdout1_6ck156 = 1.8 time = 3140
.meas tran vdout1_6ck156 FIND v(dout1_6) AT=3140.1n

* CHECK dout1_7 Vdout1_7ck156 = 1.8 time = 3140
.meas tran vdout1_7ck156 FIND v(dout1_7) AT=3140.1n

* CHECK dout1_8 Vdout1_8ck156 = 0 time = 3140
.meas tran vdout1_8ck156 FIND v(dout1_8) AT=3140.1n

* CHECK dout1_9 Vdout1_9ck156 = 0 time = 3140
.meas tran vdout1_9ck156 FIND v(dout1_9) AT=3140.1n

* CHECK dout1_10 Vdout1_10ck156 = 1.8 time = 3140
.meas tran vdout1_10ck156 FIND v(dout1_10) AT=3140.1n

* CHECK dout1_11 Vdout1_11ck156 = 1.8 time = 3140
.meas tran vdout1_11ck156 FIND v(dout1_11) AT=3140.1n

* CHECK dout1_12 Vdout1_12ck156 = 1.8 time = 3140
.meas tran vdout1_12ck156 FIND v(dout1_12) AT=3140.1n

* CHECK dout1_13 Vdout1_13ck156 = 0 time = 3140
.meas tran vdout1_13ck156 FIND v(dout1_13) AT=3140.1n

* CHECK dout1_14 Vdout1_14ck156 = 0 time = 3140
.meas tran vdout1_14ck156 FIND v(dout1_14) AT=3140.1n

* CHECK dout1_15 Vdout1_15ck156 = 1.8 time = 3140
.meas tran vdout1_15ck156 FIND v(dout1_15) AT=3140.1n

* CHECK dout1_16 Vdout1_16ck156 = 0 time = 3140
.meas tran vdout1_16ck156 FIND v(dout1_16) AT=3140.1n

* CHECK dout1_17 Vdout1_17ck156 = 0 time = 3140
.meas tran vdout1_17ck156 FIND v(dout1_17) AT=3140.1n

* CHECK dout1_18 Vdout1_18ck156 = 0 time = 3140
.meas tran vdout1_18ck156 FIND v(dout1_18) AT=3140.1n

* CHECK dout1_19 Vdout1_19ck156 = 1.8 time = 3140
.meas tran vdout1_19ck156 FIND v(dout1_19) AT=3140.1n

* CHECK dout1_20 Vdout1_20ck156 = 1.8 time = 3140
.meas tran vdout1_20ck156 FIND v(dout1_20) AT=3140.1n

* CHECK dout1_21 Vdout1_21ck156 = 1.8 time = 3140
.meas tran vdout1_21ck156 FIND v(dout1_21) AT=3140.1n

* CHECK dout1_22 Vdout1_22ck156 = 1.8 time = 3140
.meas tran vdout1_22ck156 FIND v(dout1_22) AT=3140.1n

* CHECK dout1_23 Vdout1_23ck156 = 1.8 time = 3140
.meas tran vdout1_23ck156 FIND v(dout1_23) AT=3140.1n

* CHECK dout1_24 Vdout1_24ck156 = 0 time = 3140
.meas tran vdout1_24ck156 FIND v(dout1_24) AT=3140.1n

* CHECK dout1_25 Vdout1_25ck156 = 1.8 time = 3140
.meas tran vdout1_25ck156 FIND v(dout1_25) AT=3140.1n

* CHECK dout1_26 Vdout1_26ck156 = 1.8 time = 3140
.meas tran vdout1_26ck156 FIND v(dout1_26) AT=3140.1n

* CHECK dout1_27 Vdout1_27ck156 = 1.8 time = 3140
.meas tran vdout1_27ck156 FIND v(dout1_27) AT=3140.1n

* CHECK dout1_28 Vdout1_28ck156 = 1.8 time = 3140
.meas tran vdout1_28ck156 FIND v(dout1_28) AT=3140.1n

* CHECK dout1_29 Vdout1_29ck156 = 0 time = 3140
.meas tran vdout1_29ck156 FIND v(dout1_29) AT=3140.1n

* CHECK dout1_30 Vdout1_30ck156 = 0 time = 3140
.meas tran vdout1_30ck156 FIND v(dout1_30) AT=3140.1n

* CHECK dout1_31 Vdout1_31ck156 = 1.8 time = 3140
.meas tran vdout1_31ck156 FIND v(dout1_31) AT=3140.1n

* CHECK dout1_0 Vdout1_0ck157 = 0 time = 3160
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=3160.1n

* CHECK dout1_1 Vdout1_1ck157 = 1.8 time = 3160
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=3160.1n

* CHECK dout1_2 Vdout1_2ck157 = 0 time = 3160
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=3160.1n

* CHECK dout1_3 Vdout1_3ck157 = 1.8 time = 3160
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=3160.1n

* CHECK dout1_4 Vdout1_4ck157 = 0 time = 3160
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=3160.1n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 3160
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=3160.1n

* CHECK dout1_6 Vdout1_6ck157 = 1.8 time = 3160
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=3160.1n

* CHECK dout1_7 Vdout1_7ck157 = 0 time = 3160
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=3160.1n

* CHECK dout1_8 Vdout1_8ck157 = 0 time = 3160
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=3160.1n

* CHECK dout1_9 Vdout1_9ck157 = 1.8 time = 3160
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=3160.1n

* CHECK dout1_10 Vdout1_10ck157 = 0 time = 3160
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=3160.1n

* CHECK dout1_11 Vdout1_11ck157 = 1.8 time = 3160
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=3160.1n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 3160
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=3160.1n

* CHECK dout1_13 Vdout1_13ck157 = 0 time = 3160
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=3160.1n

* CHECK dout1_14 Vdout1_14ck157 = 1.8 time = 3160
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=3160.1n

* CHECK dout1_15 Vdout1_15ck157 = 0 time = 3160
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=3160.1n

* CHECK dout1_16 Vdout1_16ck157 = 1.8 time = 3160
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=3160.1n

* CHECK dout1_17 Vdout1_17ck157 = 0 time = 3160
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=3160.1n

* CHECK dout1_18 Vdout1_18ck157 = 0 time = 3160
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=3160.1n

* CHECK dout1_19 Vdout1_19ck157 = 1.8 time = 3160
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=3160.1n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 3160
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=3160.1n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 3160
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=3160.1n

* CHECK dout1_22 Vdout1_22ck157 = 1.8 time = 3160
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=3160.1n

* CHECK dout1_23 Vdout1_23ck157 = 1.8 time = 3160
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=3160.1n

* CHECK dout1_24 Vdout1_24ck157 = 0 time = 3160
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=3160.1n

* CHECK dout1_25 Vdout1_25ck157 = 1.8 time = 3160
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=3160.1n

* CHECK dout1_26 Vdout1_26ck157 = 0 time = 3160
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=3160.1n

* CHECK dout1_27 Vdout1_27ck157 = 0 time = 3160
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=3160.1n

* CHECK dout1_28 Vdout1_28ck157 = 0 time = 3160
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=3160.1n

* CHECK dout1_29 Vdout1_29ck157 = 0 time = 3160
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=3160.1n

* CHECK dout1_30 Vdout1_30ck157 = 1.8 time = 3160
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=3160.1n

* CHECK dout1_31 Vdout1_31ck157 = 1.8 time = 3160
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=3160.1n

* CHECK dout1_0 Vdout1_0ck158 = 0 time = 3180
.meas tran vdout1_0ck158 FIND v(dout1_0) AT=3180.1n

* CHECK dout1_1 Vdout1_1ck158 = 1.8 time = 3180
.meas tran vdout1_1ck158 FIND v(dout1_1) AT=3180.1n

* CHECK dout1_2 Vdout1_2ck158 = 0 time = 3180
.meas tran vdout1_2ck158 FIND v(dout1_2) AT=3180.1n

* CHECK dout1_3 Vdout1_3ck158 = 1.8 time = 3180
.meas tran vdout1_3ck158 FIND v(dout1_3) AT=3180.1n

* CHECK dout1_4 Vdout1_4ck158 = 0 time = 3180
.meas tran vdout1_4ck158 FIND v(dout1_4) AT=3180.1n

* CHECK dout1_5 Vdout1_5ck158 = 0 time = 3180
.meas tran vdout1_5ck158 FIND v(dout1_5) AT=3180.1n

* CHECK dout1_6 Vdout1_6ck158 = 1.8 time = 3180
.meas tran vdout1_6ck158 FIND v(dout1_6) AT=3180.1n

* CHECK dout1_7 Vdout1_7ck158 = 0 time = 3180
.meas tran vdout1_7ck158 FIND v(dout1_7) AT=3180.1n

* CHECK dout1_8 Vdout1_8ck158 = 0 time = 3180
.meas tran vdout1_8ck158 FIND v(dout1_8) AT=3180.1n

* CHECK dout1_9 Vdout1_9ck158 = 1.8 time = 3180
.meas tran vdout1_9ck158 FIND v(dout1_9) AT=3180.1n

* CHECK dout1_10 Vdout1_10ck158 = 0 time = 3180
.meas tran vdout1_10ck158 FIND v(dout1_10) AT=3180.1n

* CHECK dout1_11 Vdout1_11ck158 = 1.8 time = 3180
.meas tran vdout1_11ck158 FIND v(dout1_11) AT=3180.1n

* CHECK dout1_12 Vdout1_12ck158 = 0 time = 3180
.meas tran vdout1_12ck158 FIND v(dout1_12) AT=3180.1n

* CHECK dout1_13 Vdout1_13ck158 = 0 time = 3180
.meas tran vdout1_13ck158 FIND v(dout1_13) AT=3180.1n

* CHECK dout1_14 Vdout1_14ck158 = 1.8 time = 3180
.meas tran vdout1_14ck158 FIND v(dout1_14) AT=3180.1n

* CHECK dout1_15 Vdout1_15ck158 = 0 time = 3180
.meas tran vdout1_15ck158 FIND v(dout1_15) AT=3180.1n

* CHECK dout1_16 Vdout1_16ck158 = 1.8 time = 3180
.meas tran vdout1_16ck158 FIND v(dout1_16) AT=3180.1n

* CHECK dout1_17 Vdout1_17ck158 = 0 time = 3180
.meas tran vdout1_17ck158 FIND v(dout1_17) AT=3180.1n

* CHECK dout1_18 Vdout1_18ck158 = 0 time = 3180
.meas tran vdout1_18ck158 FIND v(dout1_18) AT=3180.1n

* CHECK dout1_19 Vdout1_19ck158 = 1.8 time = 3180
.meas tran vdout1_19ck158 FIND v(dout1_19) AT=3180.1n

* CHECK dout1_20 Vdout1_20ck158 = 0 time = 3180
.meas tran vdout1_20ck158 FIND v(dout1_20) AT=3180.1n

* CHECK dout1_21 Vdout1_21ck158 = 0 time = 3180
.meas tran vdout1_21ck158 FIND v(dout1_21) AT=3180.1n

* CHECK dout1_22 Vdout1_22ck158 = 1.8 time = 3180
.meas tran vdout1_22ck158 FIND v(dout1_22) AT=3180.1n

* CHECK dout1_23 Vdout1_23ck158 = 1.8 time = 3180
.meas tran vdout1_23ck158 FIND v(dout1_23) AT=3180.1n

* CHECK dout1_24 Vdout1_24ck158 = 0 time = 3180
.meas tran vdout1_24ck158 FIND v(dout1_24) AT=3180.1n

* CHECK dout1_25 Vdout1_25ck158 = 1.8 time = 3180
.meas tran vdout1_25ck158 FIND v(dout1_25) AT=3180.1n

* CHECK dout1_26 Vdout1_26ck158 = 0 time = 3180
.meas tran vdout1_26ck158 FIND v(dout1_26) AT=3180.1n

* CHECK dout1_27 Vdout1_27ck158 = 0 time = 3180
.meas tran vdout1_27ck158 FIND v(dout1_27) AT=3180.1n

* CHECK dout1_28 Vdout1_28ck158 = 0 time = 3180
.meas tran vdout1_28ck158 FIND v(dout1_28) AT=3180.1n

* CHECK dout1_29 Vdout1_29ck158 = 0 time = 3180
.meas tran vdout1_29ck158 FIND v(dout1_29) AT=3180.1n

* CHECK dout1_30 Vdout1_30ck158 = 1.8 time = 3180
.meas tran vdout1_30ck158 FIND v(dout1_30) AT=3180.1n

* CHECK dout1_31 Vdout1_31ck158 = 1.8 time = 3180
.meas tran vdout1_31ck158 FIND v(dout1_31) AT=3180.1n

* CHECK dout2_0 Vdout2_0ck158 = 0 time = 3180
.meas tran vdout2_0ck158 FIND v(dout2_0) AT=3180.1n

* CHECK dout2_1 Vdout2_1ck158 = 1.8 time = 3180
.meas tran vdout2_1ck158 FIND v(dout2_1) AT=3180.1n

* CHECK dout2_2 Vdout2_2ck158 = 0 time = 3180
.meas tran vdout2_2ck158 FIND v(dout2_2) AT=3180.1n

* CHECK dout2_3 Vdout2_3ck158 = 1.8 time = 3180
.meas tran vdout2_3ck158 FIND v(dout2_3) AT=3180.1n

* CHECK dout2_4 Vdout2_4ck158 = 0 time = 3180
.meas tran vdout2_4ck158 FIND v(dout2_4) AT=3180.1n

* CHECK dout2_5 Vdout2_5ck158 = 0 time = 3180
.meas tran vdout2_5ck158 FIND v(dout2_5) AT=3180.1n

* CHECK dout2_6 Vdout2_6ck158 = 1.8 time = 3180
.meas tran vdout2_6ck158 FIND v(dout2_6) AT=3180.1n

* CHECK dout2_7 Vdout2_7ck158 = 0 time = 3180
.meas tran vdout2_7ck158 FIND v(dout2_7) AT=3180.1n

* CHECK dout2_8 Vdout2_8ck158 = 0 time = 3180
.meas tran vdout2_8ck158 FIND v(dout2_8) AT=3180.1n

* CHECK dout2_9 Vdout2_9ck158 = 1.8 time = 3180
.meas tran vdout2_9ck158 FIND v(dout2_9) AT=3180.1n

* CHECK dout2_10 Vdout2_10ck158 = 0 time = 3180
.meas tran vdout2_10ck158 FIND v(dout2_10) AT=3180.1n

* CHECK dout2_11 Vdout2_11ck158 = 1.8 time = 3180
.meas tran vdout2_11ck158 FIND v(dout2_11) AT=3180.1n

* CHECK dout2_12 Vdout2_12ck158 = 0 time = 3180
.meas tran vdout2_12ck158 FIND v(dout2_12) AT=3180.1n

* CHECK dout2_13 Vdout2_13ck158 = 0 time = 3180
.meas tran vdout2_13ck158 FIND v(dout2_13) AT=3180.1n

* CHECK dout2_14 Vdout2_14ck158 = 1.8 time = 3180
.meas tran vdout2_14ck158 FIND v(dout2_14) AT=3180.1n

* CHECK dout2_15 Vdout2_15ck158 = 0 time = 3180
.meas tran vdout2_15ck158 FIND v(dout2_15) AT=3180.1n

* CHECK dout2_16 Vdout2_16ck158 = 1.8 time = 3180
.meas tran vdout2_16ck158 FIND v(dout2_16) AT=3180.1n

* CHECK dout2_17 Vdout2_17ck158 = 0 time = 3180
.meas tran vdout2_17ck158 FIND v(dout2_17) AT=3180.1n

* CHECK dout2_18 Vdout2_18ck158 = 0 time = 3180
.meas tran vdout2_18ck158 FIND v(dout2_18) AT=3180.1n

* CHECK dout2_19 Vdout2_19ck158 = 1.8 time = 3180
.meas tran vdout2_19ck158 FIND v(dout2_19) AT=3180.1n

* CHECK dout2_20 Vdout2_20ck158 = 0 time = 3180
.meas tran vdout2_20ck158 FIND v(dout2_20) AT=3180.1n

* CHECK dout2_21 Vdout2_21ck158 = 0 time = 3180
.meas tran vdout2_21ck158 FIND v(dout2_21) AT=3180.1n

* CHECK dout2_22 Vdout2_22ck158 = 1.8 time = 3180
.meas tran vdout2_22ck158 FIND v(dout2_22) AT=3180.1n

* CHECK dout2_23 Vdout2_23ck158 = 1.8 time = 3180
.meas tran vdout2_23ck158 FIND v(dout2_23) AT=3180.1n

* CHECK dout2_24 Vdout2_24ck158 = 0 time = 3180
.meas tran vdout2_24ck158 FIND v(dout2_24) AT=3180.1n

* CHECK dout2_25 Vdout2_25ck158 = 1.8 time = 3180
.meas tran vdout2_25ck158 FIND v(dout2_25) AT=3180.1n

* CHECK dout2_26 Vdout2_26ck158 = 0 time = 3180
.meas tran vdout2_26ck158 FIND v(dout2_26) AT=3180.1n

* CHECK dout2_27 Vdout2_27ck158 = 0 time = 3180
.meas tran vdout2_27ck158 FIND v(dout2_27) AT=3180.1n

* CHECK dout2_28 Vdout2_28ck158 = 0 time = 3180
.meas tran vdout2_28ck158 FIND v(dout2_28) AT=3180.1n

* CHECK dout2_29 Vdout2_29ck158 = 0 time = 3180
.meas tran vdout2_29ck158 FIND v(dout2_29) AT=3180.1n

* CHECK dout2_30 Vdout2_30ck158 = 1.8 time = 3180
.meas tran vdout2_30ck158 FIND v(dout2_30) AT=3180.1n

* CHECK dout2_31 Vdout2_31ck158 = 1.8 time = 3180
.meas tran vdout2_31ck158 FIND v(dout2_31) AT=3180.1n

* CHECK dout1_0 Vdout1_0ck159 = 0 time = 3200
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=3200.1n

* CHECK dout1_1 Vdout1_1ck159 = 1.8 time = 3200
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=3200.1n

* CHECK dout1_2 Vdout1_2ck159 = 0 time = 3200
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=3200.1n

* CHECK dout1_3 Vdout1_3ck159 = 1.8 time = 3200
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=3200.1n

* CHECK dout1_4 Vdout1_4ck159 = 0 time = 3200
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=3200.1n

* CHECK dout1_5 Vdout1_5ck159 = 1.8 time = 3200
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=3200.1n

* CHECK dout1_6 Vdout1_6ck159 = 0 time = 3200
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=3200.1n

* CHECK dout1_7 Vdout1_7ck159 = 1.8 time = 3200
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=3200.1n

* CHECK dout1_8 Vdout1_8ck159 = 0 time = 3200
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=3200.1n

* CHECK dout1_9 Vdout1_9ck159 = 0 time = 3200
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=3200.1n

* CHECK dout1_10 Vdout1_10ck159 = 0 time = 3200
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=3200.1n

* CHECK dout1_11 Vdout1_11ck159 = 1.8 time = 3200
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=3200.1n

* CHECK dout1_12 Vdout1_12ck159 = 1.8 time = 3200
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=3200.1n

* CHECK dout1_13 Vdout1_13ck159 = 1.8 time = 3200
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=3200.1n

* CHECK dout1_14 Vdout1_14ck159 = 0 time = 3200
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=3200.1n

* CHECK dout1_15 Vdout1_15ck159 = 1.8 time = 3200
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=3200.1n

* CHECK dout1_16 Vdout1_16ck159 = 0 time = 3200
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=3200.1n

* CHECK dout1_17 Vdout1_17ck159 = 0 time = 3200
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=3200.1n

* CHECK dout1_18 Vdout1_18ck159 = 0 time = 3200
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=3200.1n

* CHECK dout1_19 Vdout1_19ck159 = 0 time = 3200
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=3200.1n

* CHECK dout1_20 Vdout1_20ck159 = 0 time = 3200
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=3200.1n

* CHECK dout1_21 Vdout1_21ck159 = 1.8 time = 3200
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=3200.1n

* CHECK dout1_22 Vdout1_22ck159 = 1.8 time = 3200
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=3200.1n

* CHECK dout1_23 Vdout1_23ck159 = 1.8 time = 3200
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=3200.1n

* CHECK dout1_24 Vdout1_24ck159 = 0 time = 3200
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=3200.1n

* CHECK dout1_25 Vdout1_25ck159 = 0 time = 3200
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=3200.1n

* CHECK dout1_26 Vdout1_26ck159 = 1.8 time = 3200
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=3200.1n

* CHECK dout1_27 Vdout1_27ck159 = 1.8 time = 3200
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=3200.1n

* CHECK dout1_28 Vdout1_28ck159 = 1.8 time = 3200
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=3200.1n

* CHECK dout1_29 Vdout1_29ck159 = 1.8 time = 3200
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=3200.1n

* CHECK dout1_30 Vdout1_30ck159 = 1.8 time = 3200
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=3200.1n

* CHECK dout1_31 Vdout1_31ck159 = 0 time = 3200
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=3200.1n

* CHECK dout1_0 Vdout1_0ck160 = 0 time = 3220
.meas tran vdout1_0ck160 FIND v(dout1_0) AT=3220.1n

* CHECK dout1_1 Vdout1_1ck160 = 0 time = 3220
.meas tran vdout1_1ck160 FIND v(dout1_1) AT=3220.1n

* CHECK dout1_2 Vdout1_2ck160 = 0 time = 3220
.meas tran vdout1_2ck160 FIND v(dout1_2) AT=3220.1n

* CHECK dout1_3 Vdout1_3ck160 = 1.8 time = 3220
.meas tran vdout1_3ck160 FIND v(dout1_3) AT=3220.1n

* CHECK dout1_4 Vdout1_4ck160 = 0 time = 3220
.meas tran vdout1_4ck160 FIND v(dout1_4) AT=3220.1n

* CHECK dout1_5 Vdout1_5ck160 = 1.8 time = 3220
.meas tran vdout1_5ck160 FIND v(dout1_5) AT=3220.1n

* CHECK dout1_6 Vdout1_6ck160 = 1.8 time = 3220
.meas tran vdout1_6ck160 FIND v(dout1_6) AT=3220.1n

* CHECK dout1_7 Vdout1_7ck160 = 1.8 time = 3220
.meas tran vdout1_7ck160 FIND v(dout1_7) AT=3220.1n

* CHECK dout1_8 Vdout1_8ck160 = 0 time = 3220
.meas tran vdout1_8ck160 FIND v(dout1_8) AT=3220.1n

* CHECK dout1_9 Vdout1_9ck160 = 0 time = 3220
.meas tran vdout1_9ck160 FIND v(dout1_9) AT=3220.1n

* CHECK dout1_10 Vdout1_10ck160 = 1.8 time = 3220
.meas tran vdout1_10ck160 FIND v(dout1_10) AT=3220.1n

* CHECK dout1_11 Vdout1_11ck160 = 1.8 time = 3220
.meas tran vdout1_11ck160 FIND v(dout1_11) AT=3220.1n

* CHECK dout1_12 Vdout1_12ck160 = 1.8 time = 3220
.meas tran vdout1_12ck160 FIND v(dout1_12) AT=3220.1n

* CHECK dout1_13 Vdout1_13ck160 = 0 time = 3220
.meas tran vdout1_13ck160 FIND v(dout1_13) AT=3220.1n

* CHECK dout1_14 Vdout1_14ck160 = 0 time = 3220
.meas tran vdout1_14ck160 FIND v(dout1_14) AT=3220.1n

* CHECK dout1_15 Vdout1_15ck160 = 1.8 time = 3220
.meas tran vdout1_15ck160 FIND v(dout1_15) AT=3220.1n

* CHECK dout1_16 Vdout1_16ck160 = 0 time = 3220
.meas tran vdout1_16ck160 FIND v(dout1_16) AT=3220.1n

* CHECK dout1_17 Vdout1_17ck160 = 0 time = 3220
.meas tran vdout1_17ck160 FIND v(dout1_17) AT=3220.1n

* CHECK dout1_18 Vdout1_18ck160 = 0 time = 3220
.meas tran vdout1_18ck160 FIND v(dout1_18) AT=3220.1n

* CHECK dout1_19 Vdout1_19ck160 = 1.8 time = 3220
.meas tran vdout1_19ck160 FIND v(dout1_19) AT=3220.1n

* CHECK dout1_20 Vdout1_20ck160 = 1.8 time = 3220
.meas tran vdout1_20ck160 FIND v(dout1_20) AT=3220.1n

* CHECK dout1_21 Vdout1_21ck160 = 1.8 time = 3220
.meas tran vdout1_21ck160 FIND v(dout1_21) AT=3220.1n

* CHECK dout1_22 Vdout1_22ck160 = 1.8 time = 3220
.meas tran vdout1_22ck160 FIND v(dout1_22) AT=3220.1n

* CHECK dout1_23 Vdout1_23ck160 = 1.8 time = 3220
.meas tran vdout1_23ck160 FIND v(dout1_23) AT=3220.1n

* CHECK dout1_24 Vdout1_24ck160 = 0 time = 3220
.meas tran vdout1_24ck160 FIND v(dout1_24) AT=3220.1n

* CHECK dout1_25 Vdout1_25ck160 = 1.8 time = 3220
.meas tran vdout1_25ck160 FIND v(dout1_25) AT=3220.1n

* CHECK dout1_26 Vdout1_26ck160 = 1.8 time = 3220
.meas tran vdout1_26ck160 FIND v(dout1_26) AT=3220.1n

* CHECK dout1_27 Vdout1_27ck160 = 1.8 time = 3220
.meas tran vdout1_27ck160 FIND v(dout1_27) AT=3220.1n

* CHECK dout1_28 Vdout1_28ck160 = 1.8 time = 3220
.meas tran vdout1_28ck160 FIND v(dout1_28) AT=3220.1n

* CHECK dout1_29 Vdout1_29ck160 = 0 time = 3220
.meas tran vdout1_29ck160 FIND v(dout1_29) AT=3220.1n

* CHECK dout1_30 Vdout1_30ck160 = 0 time = 3220
.meas tran vdout1_30ck160 FIND v(dout1_30) AT=3220.1n

* CHECK dout1_31 Vdout1_31ck160 = 1.8 time = 3220
.meas tran vdout1_31ck160 FIND v(dout1_31) AT=3220.1n

* CHECK dout2_0 Vdout2_0ck160 = 0 time = 3220
.meas tran vdout2_0ck160 FIND v(dout2_0) AT=3220.1n

* CHECK dout2_1 Vdout2_1ck160 = 1.8 time = 3220
.meas tran vdout2_1ck160 FIND v(dout2_1) AT=3220.1n

* CHECK dout2_2 Vdout2_2ck160 = 0 time = 3220
.meas tran vdout2_2ck160 FIND v(dout2_2) AT=3220.1n

* CHECK dout2_3 Vdout2_3ck160 = 0 time = 3220
.meas tran vdout2_3ck160 FIND v(dout2_3) AT=3220.1n

* CHECK dout2_4 Vdout2_4ck160 = 0 time = 3220
.meas tran vdout2_4ck160 FIND v(dout2_4) AT=3220.1n

* CHECK dout2_5 Vdout2_5ck160 = 0 time = 3220
.meas tran vdout2_5ck160 FIND v(dout2_5) AT=3220.1n

* CHECK dout2_6 Vdout2_6ck160 = 1.8 time = 3220
.meas tran vdout2_6ck160 FIND v(dout2_6) AT=3220.1n

* CHECK dout2_7 Vdout2_7ck160 = 0 time = 3220
.meas tran vdout2_7ck160 FIND v(dout2_7) AT=3220.1n

* CHECK dout2_8 Vdout2_8ck160 = 0 time = 3220
.meas tran vdout2_8ck160 FIND v(dout2_8) AT=3220.1n

* CHECK dout2_9 Vdout2_9ck160 = 1.8 time = 3220
.meas tran vdout2_9ck160 FIND v(dout2_9) AT=3220.1n

* CHECK dout2_10 Vdout2_10ck160 = 0 time = 3220
.meas tran vdout2_10ck160 FIND v(dout2_10) AT=3220.1n

* CHECK dout2_11 Vdout2_11ck160 = 0 time = 3220
.meas tran vdout2_11ck160 FIND v(dout2_11) AT=3220.1n

* CHECK dout2_12 Vdout2_12ck160 = 0 time = 3220
.meas tran vdout2_12ck160 FIND v(dout2_12) AT=3220.1n

* CHECK dout2_13 Vdout2_13ck160 = 1.8 time = 3220
.meas tran vdout2_13ck160 FIND v(dout2_13) AT=3220.1n

* CHECK dout2_14 Vdout2_14ck160 = 0 time = 3220
.meas tran vdout2_14ck160 FIND v(dout2_14) AT=3220.1n

* CHECK dout2_15 Vdout2_15ck160 = 0 time = 3220
.meas tran vdout2_15ck160 FIND v(dout2_15) AT=3220.1n

* CHECK dout2_16 Vdout2_16ck160 = 1.8 time = 3220
.meas tran vdout2_16ck160 FIND v(dout2_16) AT=3220.1n

* CHECK dout2_17 Vdout2_17ck160 = 0 time = 3220
.meas tran vdout2_17ck160 FIND v(dout2_17) AT=3220.1n

* CHECK dout2_18 Vdout2_18ck160 = 1.8 time = 3220
.meas tran vdout2_18ck160 FIND v(dout2_18) AT=3220.1n

* CHECK dout2_19 Vdout2_19ck160 = 1.8 time = 3220
.meas tran vdout2_19ck160 FIND v(dout2_19) AT=3220.1n

* CHECK dout2_20 Vdout2_20ck160 = 1.8 time = 3220
.meas tran vdout2_20ck160 FIND v(dout2_20) AT=3220.1n

* CHECK dout2_21 Vdout2_21ck160 = 0 time = 3220
.meas tran vdout2_21ck160 FIND v(dout2_21) AT=3220.1n

* CHECK dout2_22 Vdout2_22ck160 = 0 time = 3220
.meas tran vdout2_22ck160 FIND v(dout2_22) AT=3220.1n

* CHECK dout2_23 Vdout2_23ck160 = 1.8 time = 3220
.meas tran vdout2_23ck160 FIND v(dout2_23) AT=3220.1n

* CHECK dout2_24 Vdout2_24ck160 = 0 time = 3220
.meas tran vdout2_24ck160 FIND v(dout2_24) AT=3220.1n

* CHECK dout2_25 Vdout2_25ck160 = 0 time = 3220
.meas tran vdout2_25ck160 FIND v(dout2_25) AT=3220.1n

* CHECK dout2_26 Vdout2_26ck160 = 1.8 time = 3220
.meas tran vdout2_26ck160 FIND v(dout2_26) AT=3220.1n

* CHECK dout2_27 Vdout2_27ck160 = 1.8 time = 3220
.meas tran vdout2_27ck160 FIND v(dout2_27) AT=3220.1n

* CHECK dout2_28 Vdout2_28ck160 = 0 time = 3220
.meas tran vdout2_28ck160 FIND v(dout2_28) AT=3220.1n

* CHECK dout2_29 Vdout2_29ck160 = 0 time = 3220
.meas tran vdout2_29ck160 FIND v(dout2_29) AT=3220.1n

* CHECK dout2_30 Vdout2_30ck160 = 0 time = 3220
.meas tran vdout2_30ck160 FIND v(dout2_30) AT=3220.1n

* CHECK dout2_31 Vdout2_31ck160 = 0 time = 3220
.meas tran vdout2_31ck160 FIND v(dout2_31) AT=3220.1n

* CHECK dout1_0 Vdout1_0ck161 = 1.8 time = 3240
.meas tran vdout1_0ck161 FIND v(dout1_0) AT=3240.1n

* CHECK dout1_1 Vdout1_1ck161 = 1.8 time = 3240
.meas tran vdout1_1ck161 FIND v(dout1_1) AT=3240.1n

* CHECK dout1_2 Vdout1_2ck161 = 0 time = 3240
.meas tran vdout1_2ck161 FIND v(dout1_2) AT=3240.1n

* CHECK dout1_3 Vdout1_3ck161 = 0 time = 3240
.meas tran vdout1_3ck161 FIND v(dout1_3) AT=3240.1n

* CHECK dout1_4 Vdout1_4ck161 = 0 time = 3240
.meas tran vdout1_4ck161 FIND v(dout1_4) AT=3240.1n

* CHECK dout1_5 Vdout1_5ck161 = 1.8 time = 3240
.meas tran vdout1_5ck161 FIND v(dout1_5) AT=3240.1n

* CHECK dout1_6 Vdout1_6ck161 = 1.8 time = 3240
.meas tran vdout1_6ck161 FIND v(dout1_6) AT=3240.1n

* CHECK dout1_7 Vdout1_7ck161 = 1.8 time = 3240
.meas tran vdout1_7ck161 FIND v(dout1_7) AT=3240.1n

* CHECK dout1_8 Vdout1_8ck161 = 0 time = 3240
.meas tran vdout1_8ck161 FIND v(dout1_8) AT=3240.1n

* CHECK dout1_9 Vdout1_9ck161 = 1.8 time = 3240
.meas tran vdout1_9ck161 FIND v(dout1_9) AT=3240.1n

* CHECK dout1_10 Vdout1_10ck161 = 1.8 time = 3240
.meas tran vdout1_10ck161 FIND v(dout1_10) AT=3240.1n

* CHECK dout1_11 Vdout1_11ck161 = 1.8 time = 3240
.meas tran vdout1_11ck161 FIND v(dout1_11) AT=3240.1n

* CHECK dout1_12 Vdout1_12ck161 = 1.8 time = 3240
.meas tran vdout1_12ck161 FIND v(dout1_12) AT=3240.1n

* CHECK dout1_13 Vdout1_13ck161 = 1.8 time = 3240
.meas tran vdout1_13ck161 FIND v(dout1_13) AT=3240.1n

* CHECK dout1_14 Vdout1_14ck161 = 0 time = 3240
.meas tran vdout1_14ck161 FIND v(dout1_14) AT=3240.1n

* CHECK dout1_15 Vdout1_15ck161 = 1.8 time = 3240
.meas tran vdout1_15ck161 FIND v(dout1_15) AT=3240.1n

* CHECK dout1_16 Vdout1_16ck161 = 1.8 time = 3240
.meas tran vdout1_16ck161 FIND v(dout1_16) AT=3240.1n

* CHECK dout1_17 Vdout1_17ck161 = 0 time = 3240
.meas tran vdout1_17ck161 FIND v(dout1_17) AT=3240.1n

* CHECK dout1_18 Vdout1_18ck161 = 0 time = 3240
.meas tran vdout1_18ck161 FIND v(dout1_18) AT=3240.1n

* CHECK dout1_19 Vdout1_19ck161 = 0 time = 3240
.meas tran vdout1_19ck161 FIND v(dout1_19) AT=3240.1n

* CHECK dout1_20 Vdout1_20ck161 = 1.8 time = 3240
.meas tran vdout1_20ck161 FIND v(dout1_20) AT=3240.1n

* CHECK dout1_21 Vdout1_21ck161 = 1.8 time = 3240
.meas tran vdout1_21ck161 FIND v(dout1_21) AT=3240.1n

* CHECK dout1_22 Vdout1_22ck161 = 1.8 time = 3240
.meas tran vdout1_22ck161 FIND v(dout1_22) AT=3240.1n

* CHECK dout1_23 Vdout1_23ck161 = 1.8 time = 3240
.meas tran vdout1_23ck161 FIND v(dout1_23) AT=3240.1n

* CHECK dout1_24 Vdout1_24ck161 = 0 time = 3240
.meas tran vdout1_24ck161 FIND v(dout1_24) AT=3240.1n

* CHECK dout1_25 Vdout1_25ck161 = 0 time = 3240
.meas tran vdout1_25ck161 FIND v(dout1_25) AT=3240.1n

* CHECK dout1_26 Vdout1_26ck161 = 1.8 time = 3240
.meas tran vdout1_26ck161 FIND v(dout1_26) AT=3240.1n

* CHECK dout1_27 Vdout1_27ck161 = 0 time = 3240
.meas tran vdout1_27ck161 FIND v(dout1_27) AT=3240.1n

* CHECK dout1_28 Vdout1_28ck161 = 1.8 time = 3240
.meas tran vdout1_28ck161 FIND v(dout1_28) AT=3240.1n

* CHECK dout1_29 Vdout1_29ck161 = 0 time = 3240
.meas tran vdout1_29ck161 FIND v(dout1_29) AT=3240.1n

* CHECK dout1_30 Vdout1_30ck161 = 1.8 time = 3240
.meas tran vdout1_30ck161 FIND v(dout1_30) AT=3240.1n

* CHECK dout1_31 Vdout1_31ck161 = 0 time = 3240
.meas tran vdout1_31ck161 FIND v(dout1_31) AT=3240.1n

* CHECK dout2_0 Vdout2_0ck162 = 1.8 time = 3260
.meas tran vdout2_0ck162 FIND v(dout2_0) AT=3260.1n

* CHECK dout2_1 Vdout2_1ck162 = 1.8 time = 3260
.meas tran vdout2_1ck162 FIND v(dout2_1) AT=3260.1n

* CHECK dout2_2 Vdout2_2ck162 = 0 time = 3260
.meas tran vdout2_2ck162 FIND v(dout2_2) AT=3260.1n

* CHECK dout2_3 Vdout2_3ck162 = 0 time = 3260
.meas tran vdout2_3ck162 FIND v(dout2_3) AT=3260.1n

* CHECK dout2_4 Vdout2_4ck162 = 0 time = 3260
.meas tran vdout2_4ck162 FIND v(dout2_4) AT=3260.1n

* CHECK dout2_5 Vdout2_5ck162 = 1.8 time = 3260
.meas tran vdout2_5ck162 FIND v(dout2_5) AT=3260.1n

* CHECK dout2_6 Vdout2_6ck162 = 1.8 time = 3260
.meas tran vdout2_6ck162 FIND v(dout2_6) AT=3260.1n

* CHECK dout2_7 Vdout2_7ck162 = 1.8 time = 3260
.meas tran vdout2_7ck162 FIND v(dout2_7) AT=3260.1n

* CHECK dout2_8 Vdout2_8ck162 = 0 time = 3260
.meas tran vdout2_8ck162 FIND v(dout2_8) AT=3260.1n

* CHECK dout2_9 Vdout2_9ck162 = 1.8 time = 3260
.meas tran vdout2_9ck162 FIND v(dout2_9) AT=3260.1n

* CHECK dout2_10 Vdout2_10ck162 = 1.8 time = 3260
.meas tran vdout2_10ck162 FIND v(dout2_10) AT=3260.1n

* CHECK dout2_11 Vdout2_11ck162 = 1.8 time = 3260
.meas tran vdout2_11ck162 FIND v(dout2_11) AT=3260.1n

* CHECK dout2_12 Vdout2_12ck162 = 1.8 time = 3260
.meas tran vdout2_12ck162 FIND v(dout2_12) AT=3260.1n

* CHECK dout2_13 Vdout2_13ck162 = 1.8 time = 3260
.meas tran vdout2_13ck162 FIND v(dout2_13) AT=3260.1n

* CHECK dout2_14 Vdout2_14ck162 = 0 time = 3260
.meas tran vdout2_14ck162 FIND v(dout2_14) AT=3260.1n

* CHECK dout2_15 Vdout2_15ck162 = 1.8 time = 3260
.meas tran vdout2_15ck162 FIND v(dout2_15) AT=3260.1n

* CHECK dout2_16 Vdout2_16ck162 = 1.8 time = 3260
.meas tran vdout2_16ck162 FIND v(dout2_16) AT=3260.1n

* CHECK dout2_17 Vdout2_17ck162 = 0 time = 3260
.meas tran vdout2_17ck162 FIND v(dout2_17) AT=3260.1n

* CHECK dout2_18 Vdout2_18ck162 = 0 time = 3260
.meas tran vdout2_18ck162 FIND v(dout2_18) AT=3260.1n

* CHECK dout2_19 Vdout2_19ck162 = 0 time = 3260
.meas tran vdout2_19ck162 FIND v(dout2_19) AT=3260.1n

* CHECK dout2_20 Vdout2_20ck162 = 1.8 time = 3260
.meas tran vdout2_20ck162 FIND v(dout2_20) AT=3260.1n

* CHECK dout2_21 Vdout2_21ck162 = 1.8 time = 3260
.meas tran vdout2_21ck162 FIND v(dout2_21) AT=3260.1n

* CHECK dout2_22 Vdout2_22ck162 = 1.8 time = 3260
.meas tran vdout2_22ck162 FIND v(dout2_22) AT=3260.1n

* CHECK dout2_23 Vdout2_23ck162 = 1.8 time = 3260
.meas tran vdout2_23ck162 FIND v(dout2_23) AT=3260.1n

* CHECK dout2_24 Vdout2_24ck162 = 0 time = 3260
.meas tran vdout2_24ck162 FIND v(dout2_24) AT=3260.1n

* CHECK dout2_25 Vdout2_25ck162 = 0 time = 3260
.meas tran vdout2_25ck162 FIND v(dout2_25) AT=3260.1n

* CHECK dout2_26 Vdout2_26ck162 = 1.8 time = 3260
.meas tran vdout2_26ck162 FIND v(dout2_26) AT=3260.1n

* CHECK dout2_27 Vdout2_27ck162 = 0 time = 3260
.meas tran vdout2_27ck162 FIND v(dout2_27) AT=3260.1n

* CHECK dout2_28 Vdout2_28ck162 = 1.8 time = 3260
.meas tran vdout2_28ck162 FIND v(dout2_28) AT=3260.1n

* CHECK dout2_29 Vdout2_29ck162 = 0 time = 3260
.meas tran vdout2_29ck162 FIND v(dout2_29) AT=3260.1n

* CHECK dout2_30 Vdout2_30ck162 = 1.8 time = 3260
.meas tran vdout2_30ck162 FIND v(dout2_30) AT=3260.1n

* CHECK dout2_31 Vdout2_31ck162 = 0 time = 3260
.meas tran vdout2_31ck162 FIND v(dout2_31) AT=3260.1n

* CHECK dout1_0 Vdout1_0ck163 = 0 time = 3280
.meas tran vdout1_0ck163 FIND v(dout1_0) AT=3280.1n

* CHECK dout1_1 Vdout1_1ck163 = 1.8 time = 3280
.meas tran vdout1_1ck163 FIND v(dout1_1) AT=3280.1n

* CHECK dout1_2 Vdout1_2ck163 = 0 time = 3280
.meas tran vdout1_2ck163 FIND v(dout1_2) AT=3280.1n

* CHECK dout1_3 Vdout1_3ck163 = 0 time = 3280
.meas tran vdout1_3ck163 FIND v(dout1_3) AT=3280.1n

* CHECK dout1_4 Vdout1_4ck163 = 0 time = 3280
.meas tran vdout1_4ck163 FIND v(dout1_4) AT=3280.1n

* CHECK dout1_5 Vdout1_5ck163 = 1.8 time = 3280
.meas tran vdout1_5ck163 FIND v(dout1_5) AT=3280.1n

* CHECK dout1_6 Vdout1_6ck163 = 1.8 time = 3280
.meas tran vdout1_6ck163 FIND v(dout1_6) AT=3280.1n

* CHECK dout1_7 Vdout1_7ck163 = 0 time = 3280
.meas tran vdout1_7ck163 FIND v(dout1_7) AT=3280.1n

* CHECK dout1_8 Vdout1_8ck163 = 1.8 time = 3280
.meas tran vdout1_8ck163 FIND v(dout1_8) AT=3280.1n

* CHECK dout1_9 Vdout1_9ck163 = 0 time = 3280
.meas tran vdout1_9ck163 FIND v(dout1_9) AT=3280.1n

* CHECK dout1_10 Vdout1_10ck163 = 0 time = 3280
.meas tran vdout1_10ck163 FIND v(dout1_10) AT=3280.1n

* CHECK dout1_11 Vdout1_11ck163 = 0 time = 3280
.meas tran vdout1_11ck163 FIND v(dout1_11) AT=3280.1n

* CHECK dout1_12 Vdout1_12ck163 = 1.8 time = 3280
.meas tran vdout1_12ck163 FIND v(dout1_12) AT=3280.1n

* CHECK dout1_13 Vdout1_13ck163 = 0 time = 3280
.meas tran vdout1_13ck163 FIND v(dout1_13) AT=3280.1n

* CHECK dout1_14 Vdout1_14ck163 = 1.8 time = 3280
.meas tran vdout1_14ck163 FIND v(dout1_14) AT=3280.1n

* CHECK dout1_15 Vdout1_15ck163 = 0 time = 3280
.meas tran vdout1_15ck163 FIND v(dout1_15) AT=3280.1n

* CHECK dout1_16 Vdout1_16ck163 = 1.8 time = 3280
.meas tran vdout1_16ck163 FIND v(dout1_16) AT=3280.1n

* CHECK dout1_17 Vdout1_17ck163 = 0 time = 3280
.meas tran vdout1_17ck163 FIND v(dout1_17) AT=3280.1n

* CHECK dout1_18 Vdout1_18ck163 = 0 time = 3280
.meas tran vdout1_18ck163 FIND v(dout1_18) AT=3280.1n

* CHECK dout1_19 Vdout1_19ck163 = 0 time = 3280
.meas tran vdout1_19ck163 FIND v(dout1_19) AT=3280.1n

* CHECK dout1_20 Vdout1_20ck163 = 1.8 time = 3280
.meas tran vdout1_20ck163 FIND v(dout1_20) AT=3280.1n

* CHECK dout1_21 Vdout1_21ck163 = 1.8 time = 3280
.meas tran vdout1_21ck163 FIND v(dout1_21) AT=3280.1n

* CHECK dout1_22 Vdout1_22ck163 = 0 time = 3280
.meas tran vdout1_22ck163 FIND v(dout1_22) AT=3280.1n

* CHECK dout1_23 Vdout1_23ck163 = 1.8 time = 3280
.meas tran vdout1_23ck163 FIND v(dout1_23) AT=3280.1n

* CHECK dout1_24 Vdout1_24ck163 = 1.8 time = 3280
.meas tran vdout1_24ck163 FIND v(dout1_24) AT=3280.1n

* CHECK dout1_25 Vdout1_25ck163 = 0 time = 3280
.meas tran vdout1_25ck163 FIND v(dout1_25) AT=3280.1n

* CHECK dout1_26 Vdout1_26ck163 = 0 time = 3280
.meas tran vdout1_26ck163 FIND v(dout1_26) AT=3280.1n

* CHECK dout1_27 Vdout1_27ck163 = 0 time = 3280
.meas tran vdout1_27ck163 FIND v(dout1_27) AT=3280.1n

* CHECK dout1_28 Vdout1_28ck163 = 0 time = 3280
.meas tran vdout1_28ck163 FIND v(dout1_28) AT=3280.1n

* CHECK dout1_29 Vdout1_29ck163 = 0 time = 3280
.meas tran vdout1_29ck163 FIND v(dout1_29) AT=3280.1n

* CHECK dout1_30 Vdout1_30ck163 = 0 time = 3280
.meas tran vdout1_30ck163 FIND v(dout1_30) AT=3280.1n

* CHECK dout1_31 Vdout1_31ck163 = 0 time = 3280
.meas tran vdout1_31ck163 FIND v(dout1_31) AT=3280.1n

* CHECK dout2_0 Vdout2_0ck163 = 1.8 time = 3280
.meas tran vdout2_0ck163 FIND v(dout2_0) AT=3280.1n

* CHECK dout2_1 Vdout2_1ck163 = 1.8 time = 3280
.meas tran vdout2_1ck163 FIND v(dout2_1) AT=3280.1n

* CHECK dout2_2 Vdout2_2ck163 = 1.8 time = 3280
.meas tran vdout2_2ck163 FIND v(dout2_2) AT=3280.1n

* CHECK dout2_3 Vdout2_3ck163 = 0 time = 3280
.meas tran vdout2_3ck163 FIND v(dout2_3) AT=3280.1n

* CHECK dout2_4 Vdout2_4ck163 = 1.8 time = 3280
.meas tran vdout2_4ck163 FIND v(dout2_4) AT=3280.1n

* CHECK dout2_5 Vdout2_5ck163 = 1.8 time = 3280
.meas tran vdout2_5ck163 FIND v(dout2_5) AT=3280.1n

* CHECK dout2_6 Vdout2_6ck163 = 0 time = 3280
.meas tran vdout2_6ck163 FIND v(dout2_6) AT=3280.1n

* CHECK dout2_7 Vdout2_7ck163 = 1.8 time = 3280
.meas tran vdout2_7ck163 FIND v(dout2_7) AT=3280.1n

* CHECK dout2_8 Vdout2_8ck163 = 1.8 time = 3280
.meas tran vdout2_8ck163 FIND v(dout2_8) AT=3280.1n

* CHECK dout2_9 Vdout2_9ck163 = 0 time = 3280
.meas tran vdout2_9ck163 FIND v(dout2_9) AT=3280.1n

* CHECK dout2_10 Vdout2_10ck163 = 1.8 time = 3280
.meas tran vdout2_10ck163 FIND v(dout2_10) AT=3280.1n

* CHECK dout2_11 Vdout2_11ck163 = 0 time = 3280
.meas tran vdout2_11ck163 FIND v(dout2_11) AT=3280.1n

* CHECK dout2_12 Vdout2_12ck163 = 1.8 time = 3280
.meas tran vdout2_12ck163 FIND v(dout2_12) AT=3280.1n

* CHECK dout2_13 Vdout2_13ck163 = 1.8 time = 3280
.meas tran vdout2_13ck163 FIND v(dout2_13) AT=3280.1n

* CHECK dout2_14 Vdout2_14ck163 = 1.8 time = 3280
.meas tran vdout2_14ck163 FIND v(dout2_14) AT=3280.1n

* CHECK dout2_15 Vdout2_15ck163 = 0 time = 3280
.meas tran vdout2_15ck163 FIND v(dout2_15) AT=3280.1n

* CHECK dout2_16 Vdout2_16ck163 = 0 time = 3280
.meas tran vdout2_16ck163 FIND v(dout2_16) AT=3280.1n

* CHECK dout2_17 Vdout2_17ck163 = 1.8 time = 3280
.meas tran vdout2_17ck163 FIND v(dout2_17) AT=3280.1n

* CHECK dout2_18 Vdout2_18ck163 = 0 time = 3280
.meas tran vdout2_18ck163 FIND v(dout2_18) AT=3280.1n

* CHECK dout2_19 Vdout2_19ck163 = 0 time = 3280
.meas tran vdout2_19ck163 FIND v(dout2_19) AT=3280.1n

* CHECK dout2_20 Vdout2_20ck163 = 1.8 time = 3280
.meas tran vdout2_20ck163 FIND v(dout2_20) AT=3280.1n

* CHECK dout2_21 Vdout2_21ck163 = 0 time = 3280
.meas tran vdout2_21ck163 FIND v(dout2_21) AT=3280.1n

* CHECK dout2_22 Vdout2_22ck163 = 1.8 time = 3280
.meas tran vdout2_22ck163 FIND v(dout2_22) AT=3280.1n

* CHECK dout2_23 Vdout2_23ck163 = 1.8 time = 3280
.meas tran vdout2_23ck163 FIND v(dout2_23) AT=3280.1n

* CHECK dout2_24 Vdout2_24ck163 = 1.8 time = 3280
.meas tran vdout2_24ck163 FIND v(dout2_24) AT=3280.1n

* CHECK dout2_25 Vdout2_25ck163 = 1.8 time = 3280
.meas tran vdout2_25ck163 FIND v(dout2_25) AT=3280.1n

* CHECK dout2_26 Vdout2_26ck163 = 1.8 time = 3280
.meas tran vdout2_26ck163 FIND v(dout2_26) AT=3280.1n

* CHECK dout2_27 Vdout2_27ck163 = 0 time = 3280
.meas tran vdout2_27ck163 FIND v(dout2_27) AT=3280.1n

* CHECK dout2_28 Vdout2_28ck163 = 0 time = 3280
.meas tran vdout2_28ck163 FIND v(dout2_28) AT=3280.1n

* CHECK dout2_29 Vdout2_29ck163 = 0 time = 3280
.meas tran vdout2_29ck163 FIND v(dout2_29) AT=3280.1n

* CHECK dout2_30 Vdout2_30ck163 = 1.8 time = 3280
.meas tran vdout2_30ck163 FIND v(dout2_30) AT=3280.1n

* CHECK dout2_31 Vdout2_31ck163 = 1.8 time = 3280
.meas tran vdout2_31ck163 FIND v(dout2_31) AT=3280.1n

* CHECK dout1_0 Vdout1_0ck164 = 0 time = 3300
.meas tran vdout1_0ck164 FIND v(dout1_0) AT=3300.1n

* CHECK dout1_1 Vdout1_1ck164 = 1.8 time = 3300
.meas tran vdout1_1ck164 FIND v(dout1_1) AT=3300.1n

* CHECK dout1_2 Vdout1_2ck164 = 0 time = 3300
.meas tran vdout1_2ck164 FIND v(dout1_2) AT=3300.1n

* CHECK dout1_3 Vdout1_3ck164 = 0 time = 3300
.meas tran vdout1_3ck164 FIND v(dout1_3) AT=3300.1n

* CHECK dout1_4 Vdout1_4ck164 = 1.8 time = 3300
.meas tran vdout1_4ck164 FIND v(dout1_4) AT=3300.1n

* CHECK dout1_5 Vdout1_5ck164 = 0 time = 3300
.meas tran vdout1_5ck164 FIND v(dout1_5) AT=3300.1n

* CHECK dout1_6 Vdout1_6ck164 = 0 time = 3300
.meas tran vdout1_6ck164 FIND v(dout1_6) AT=3300.1n

* CHECK dout1_7 Vdout1_7ck164 = 0 time = 3300
.meas tran vdout1_7ck164 FIND v(dout1_7) AT=3300.1n

* CHECK dout1_8 Vdout1_8ck164 = 1.8 time = 3300
.meas tran vdout1_8ck164 FIND v(dout1_8) AT=3300.1n

* CHECK dout1_9 Vdout1_9ck164 = 0 time = 3300
.meas tran vdout1_9ck164 FIND v(dout1_9) AT=3300.1n

* CHECK dout1_10 Vdout1_10ck164 = 0 time = 3300
.meas tran vdout1_10ck164 FIND v(dout1_10) AT=3300.1n

* CHECK dout1_11 Vdout1_11ck164 = 0 time = 3300
.meas tran vdout1_11ck164 FIND v(dout1_11) AT=3300.1n

* CHECK dout1_12 Vdout1_12ck164 = 1.8 time = 3300
.meas tran vdout1_12ck164 FIND v(dout1_12) AT=3300.1n

* CHECK dout1_13 Vdout1_13ck164 = 1.8 time = 3300
.meas tran vdout1_13ck164 FIND v(dout1_13) AT=3300.1n

* CHECK dout1_14 Vdout1_14ck164 = 1.8 time = 3300
.meas tran vdout1_14ck164 FIND v(dout1_14) AT=3300.1n

* CHECK dout1_15 Vdout1_15ck164 = 1.8 time = 3300
.meas tran vdout1_15ck164 FIND v(dout1_15) AT=3300.1n

* CHECK dout1_16 Vdout1_16ck164 = 1.8 time = 3300
.meas tran vdout1_16ck164 FIND v(dout1_16) AT=3300.1n

* CHECK dout1_17 Vdout1_17ck164 = 0 time = 3300
.meas tran vdout1_17ck164 FIND v(dout1_17) AT=3300.1n

* CHECK dout1_18 Vdout1_18ck164 = 0 time = 3300
.meas tran vdout1_18ck164 FIND v(dout1_18) AT=3300.1n

* CHECK dout1_19 Vdout1_19ck164 = 1.8 time = 3300
.meas tran vdout1_19ck164 FIND v(dout1_19) AT=3300.1n

* CHECK dout1_20 Vdout1_20ck164 = 1.8 time = 3300
.meas tran vdout1_20ck164 FIND v(dout1_20) AT=3300.1n

* CHECK dout1_21 Vdout1_21ck164 = 0 time = 3300
.meas tran vdout1_21ck164 FIND v(dout1_21) AT=3300.1n

* CHECK dout1_22 Vdout1_22ck164 = 0 time = 3300
.meas tran vdout1_22ck164 FIND v(dout1_22) AT=3300.1n

* CHECK dout1_23 Vdout1_23ck164 = 0 time = 3300
.meas tran vdout1_23ck164 FIND v(dout1_23) AT=3300.1n

* CHECK dout1_24 Vdout1_24ck164 = 1.8 time = 3300
.meas tran vdout1_24ck164 FIND v(dout1_24) AT=3300.1n

* CHECK dout1_25 Vdout1_25ck164 = 0 time = 3300
.meas tran vdout1_25ck164 FIND v(dout1_25) AT=3300.1n

* CHECK dout1_26 Vdout1_26ck164 = 1.8 time = 3300
.meas tran vdout1_26ck164 FIND v(dout1_26) AT=3300.1n

* CHECK dout1_27 Vdout1_27ck164 = 0 time = 3300
.meas tran vdout1_27ck164 FIND v(dout1_27) AT=3300.1n

* CHECK dout1_28 Vdout1_28ck164 = 0 time = 3300
.meas tran vdout1_28ck164 FIND v(dout1_28) AT=3300.1n

* CHECK dout1_29 Vdout1_29ck164 = 0 time = 3300
.meas tran vdout1_29ck164 FIND v(dout1_29) AT=3300.1n

* CHECK dout1_30 Vdout1_30ck164 = 1.8 time = 3300
.meas tran vdout1_30ck164 FIND v(dout1_30) AT=3300.1n

* CHECK dout1_31 Vdout1_31ck164 = 1.8 time = 3300
.meas tran vdout1_31ck164 FIND v(dout1_31) AT=3300.1n

* CHECK dout2_0 Vdout2_0ck164 = 0 time = 3300
.meas tran vdout2_0ck164 FIND v(dout2_0) AT=3300.1n

* CHECK dout2_1 Vdout2_1ck164 = 1.8 time = 3300
.meas tran vdout2_1ck164 FIND v(dout2_1) AT=3300.1n

* CHECK dout2_2 Vdout2_2ck164 = 0 time = 3300
.meas tran vdout2_2ck164 FIND v(dout2_2) AT=3300.1n

* CHECK dout2_3 Vdout2_3ck164 = 0 time = 3300
.meas tran vdout2_3ck164 FIND v(dout2_3) AT=3300.1n

* CHECK dout2_4 Vdout2_4ck164 = 1.8 time = 3300
.meas tran vdout2_4ck164 FIND v(dout2_4) AT=3300.1n

* CHECK dout2_5 Vdout2_5ck164 = 0 time = 3300
.meas tran vdout2_5ck164 FIND v(dout2_5) AT=3300.1n

* CHECK dout2_6 Vdout2_6ck164 = 0 time = 3300
.meas tran vdout2_6ck164 FIND v(dout2_6) AT=3300.1n

* CHECK dout2_7 Vdout2_7ck164 = 0 time = 3300
.meas tran vdout2_7ck164 FIND v(dout2_7) AT=3300.1n

* CHECK dout2_8 Vdout2_8ck164 = 1.8 time = 3300
.meas tran vdout2_8ck164 FIND v(dout2_8) AT=3300.1n

* CHECK dout2_9 Vdout2_9ck164 = 0 time = 3300
.meas tran vdout2_9ck164 FIND v(dout2_9) AT=3300.1n

* CHECK dout2_10 Vdout2_10ck164 = 0 time = 3300
.meas tran vdout2_10ck164 FIND v(dout2_10) AT=3300.1n

* CHECK dout2_11 Vdout2_11ck164 = 0 time = 3300
.meas tran vdout2_11ck164 FIND v(dout2_11) AT=3300.1n

* CHECK dout2_12 Vdout2_12ck164 = 1.8 time = 3300
.meas tran vdout2_12ck164 FIND v(dout2_12) AT=3300.1n

* CHECK dout2_13 Vdout2_13ck164 = 1.8 time = 3300
.meas tran vdout2_13ck164 FIND v(dout2_13) AT=3300.1n

* CHECK dout2_14 Vdout2_14ck164 = 1.8 time = 3300
.meas tran vdout2_14ck164 FIND v(dout2_14) AT=3300.1n

* CHECK dout2_15 Vdout2_15ck164 = 1.8 time = 3300
.meas tran vdout2_15ck164 FIND v(dout2_15) AT=3300.1n

* CHECK dout2_16 Vdout2_16ck164 = 1.8 time = 3300
.meas tran vdout2_16ck164 FIND v(dout2_16) AT=3300.1n

* CHECK dout2_17 Vdout2_17ck164 = 0 time = 3300
.meas tran vdout2_17ck164 FIND v(dout2_17) AT=3300.1n

* CHECK dout2_18 Vdout2_18ck164 = 0 time = 3300
.meas tran vdout2_18ck164 FIND v(dout2_18) AT=3300.1n

* CHECK dout2_19 Vdout2_19ck164 = 1.8 time = 3300
.meas tran vdout2_19ck164 FIND v(dout2_19) AT=3300.1n

* CHECK dout2_20 Vdout2_20ck164 = 1.8 time = 3300
.meas tran vdout2_20ck164 FIND v(dout2_20) AT=3300.1n

* CHECK dout2_21 Vdout2_21ck164 = 0 time = 3300
.meas tran vdout2_21ck164 FIND v(dout2_21) AT=3300.1n

* CHECK dout2_22 Vdout2_22ck164 = 0 time = 3300
.meas tran vdout2_22ck164 FIND v(dout2_22) AT=3300.1n

* CHECK dout2_23 Vdout2_23ck164 = 0 time = 3300
.meas tran vdout2_23ck164 FIND v(dout2_23) AT=3300.1n

* CHECK dout2_24 Vdout2_24ck164 = 1.8 time = 3300
.meas tran vdout2_24ck164 FIND v(dout2_24) AT=3300.1n

* CHECK dout2_25 Vdout2_25ck164 = 0 time = 3300
.meas tran vdout2_25ck164 FIND v(dout2_25) AT=3300.1n

* CHECK dout2_26 Vdout2_26ck164 = 1.8 time = 3300
.meas tran vdout2_26ck164 FIND v(dout2_26) AT=3300.1n

* CHECK dout2_27 Vdout2_27ck164 = 0 time = 3300
.meas tran vdout2_27ck164 FIND v(dout2_27) AT=3300.1n

* CHECK dout2_28 Vdout2_28ck164 = 0 time = 3300
.meas tran vdout2_28ck164 FIND v(dout2_28) AT=3300.1n

* CHECK dout2_29 Vdout2_29ck164 = 0 time = 3300
.meas tran vdout2_29ck164 FIND v(dout2_29) AT=3300.1n

* CHECK dout2_30 Vdout2_30ck164 = 1.8 time = 3300
.meas tran vdout2_30ck164 FIND v(dout2_30) AT=3300.1n

* CHECK dout2_31 Vdout2_31ck164 = 1.8 time = 3300
.meas tran vdout2_31ck164 FIND v(dout2_31) AT=3300.1n

* CHECK dout1_0 Vdout1_0ck166 = 0 time = 3340
.meas tran vdout1_0ck166 FIND v(dout1_0) AT=3340.1n

* CHECK dout1_1 Vdout1_1ck166 = 1.8 time = 3340
.meas tran vdout1_1ck166 FIND v(dout1_1) AT=3340.1n

* CHECK dout1_2 Vdout1_2ck166 = 0 time = 3340
.meas tran vdout1_2ck166 FIND v(dout1_2) AT=3340.1n

* CHECK dout1_3 Vdout1_3ck166 = 0 time = 3340
.meas tran vdout1_3ck166 FIND v(dout1_3) AT=3340.1n

* CHECK dout1_4 Vdout1_4ck166 = 1.8 time = 3340
.meas tran vdout1_4ck166 FIND v(dout1_4) AT=3340.1n

* CHECK dout1_5 Vdout1_5ck166 = 0 time = 3340
.meas tran vdout1_5ck166 FIND v(dout1_5) AT=3340.1n

* CHECK dout1_6 Vdout1_6ck166 = 0 time = 3340
.meas tran vdout1_6ck166 FIND v(dout1_6) AT=3340.1n

* CHECK dout1_7 Vdout1_7ck166 = 0 time = 3340
.meas tran vdout1_7ck166 FIND v(dout1_7) AT=3340.1n

* CHECK dout1_8 Vdout1_8ck166 = 1.8 time = 3340
.meas tran vdout1_8ck166 FIND v(dout1_8) AT=3340.1n

* CHECK dout1_9 Vdout1_9ck166 = 0 time = 3340
.meas tran vdout1_9ck166 FIND v(dout1_9) AT=3340.1n

* CHECK dout1_10 Vdout1_10ck166 = 0 time = 3340
.meas tran vdout1_10ck166 FIND v(dout1_10) AT=3340.1n

* CHECK dout1_11 Vdout1_11ck166 = 0 time = 3340
.meas tran vdout1_11ck166 FIND v(dout1_11) AT=3340.1n

* CHECK dout1_12 Vdout1_12ck166 = 1.8 time = 3340
.meas tran vdout1_12ck166 FIND v(dout1_12) AT=3340.1n

* CHECK dout1_13 Vdout1_13ck166 = 1.8 time = 3340
.meas tran vdout1_13ck166 FIND v(dout1_13) AT=3340.1n

* CHECK dout1_14 Vdout1_14ck166 = 1.8 time = 3340
.meas tran vdout1_14ck166 FIND v(dout1_14) AT=3340.1n

* CHECK dout1_15 Vdout1_15ck166 = 1.8 time = 3340
.meas tran vdout1_15ck166 FIND v(dout1_15) AT=3340.1n

* CHECK dout1_16 Vdout1_16ck166 = 1.8 time = 3340
.meas tran vdout1_16ck166 FIND v(dout1_16) AT=3340.1n

* CHECK dout1_17 Vdout1_17ck166 = 0 time = 3340
.meas tran vdout1_17ck166 FIND v(dout1_17) AT=3340.1n

* CHECK dout1_18 Vdout1_18ck166 = 0 time = 3340
.meas tran vdout1_18ck166 FIND v(dout1_18) AT=3340.1n

* CHECK dout1_19 Vdout1_19ck166 = 1.8 time = 3340
.meas tran vdout1_19ck166 FIND v(dout1_19) AT=3340.1n

* CHECK dout1_20 Vdout1_20ck166 = 1.8 time = 3340
.meas tran vdout1_20ck166 FIND v(dout1_20) AT=3340.1n

* CHECK dout1_21 Vdout1_21ck166 = 0 time = 3340
.meas tran vdout1_21ck166 FIND v(dout1_21) AT=3340.1n

* CHECK dout1_22 Vdout1_22ck166 = 0 time = 3340
.meas tran vdout1_22ck166 FIND v(dout1_22) AT=3340.1n

* CHECK dout1_23 Vdout1_23ck166 = 0 time = 3340
.meas tran vdout1_23ck166 FIND v(dout1_23) AT=3340.1n

* CHECK dout1_24 Vdout1_24ck166 = 1.8 time = 3340
.meas tran vdout1_24ck166 FIND v(dout1_24) AT=3340.1n

* CHECK dout1_25 Vdout1_25ck166 = 0 time = 3340
.meas tran vdout1_25ck166 FIND v(dout1_25) AT=3340.1n

* CHECK dout1_26 Vdout1_26ck166 = 1.8 time = 3340
.meas tran vdout1_26ck166 FIND v(dout1_26) AT=3340.1n

* CHECK dout1_27 Vdout1_27ck166 = 0 time = 3340
.meas tran vdout1_27ck166 FIND v(dout1_27) AT=3340.1n

* CHECK dout1_28 Vdout1_28ck166 = 0 time = 3340
.meas tran vdout1_28ck166 FIND v(dout1_28) AT=3340.1n

* CHECK dout1_29 Vdout1_29ck166 = 0 time = 3340
.meas tran vdout1_29ck166 FIND v(dout1_29) AT=3340.1n

* CHECK dout1_30 Vdout1_30ck166 = 1.8 time = 3340
.meas tran vdout1_30ck166 FIND v(dout1_30) AT=3340.1n

* CHECK dout1_31 Vdout1_31ck166 = 1.8 time = 3340
.meas tran vdout1_31ck166 FIND v(dout1_31) AT=3340.1n

* CHECK dout2_0 Vdout2_0ck166 = 0 time = 3340
.meas tran vdout2_0ck166 FIND v(dout2_0) AT=3340.1n

* CHECK dout2_1 Vdout2_1ck166 = 1.8 time = 3340
.meas tran vdout2_1ck166 FIND v(dout2_1) AT=3340.1n

* CHECK dout2_2 Vdout2_2ck166 = 0 time = 3340
.meas tran vdout2_2ck166 FIND v(dout2_2) AT=3340.1n

* CHECK dout2_3 Vdout2_3ck166 = 0 time = 3340
.meas tran vdout2_3ck166 FIND v(dout2_3) AT=3340.1n

* CHECK dout2_4 Vdout2_4ck166 = 1.8 time = 3340
.meas tran vdout2_4ck166 FIND v(dout2_4) AT=3340.1n

* CHECK dout2_5 Vdout2_5ck166 = 0 time = 3340
.meas tran vdout2_5ck166 FIND v(dout2_5) AT=3340.1n

* CHECK dout2_6 Vdout2_6ck166 = 0 time = 3340
.meas tran vdout2_6ck166 FIND v(dout2_6) AT=3340.1n

* CHECK dout2_7 Vdout2_7ck166 = 0 time = 3340
.meas tran vdout2_7ck166 FIND v(dout2_7) AT=3340.1n

* CHECK dout2_8 Vdout2_8ck166 = 1.8 time = 3340
.meas tran vdout2_8ck166 FIND v(dout2_8) AT=3340.1n

* CHECK dout2_9 Vdout2_9ck166 = 0 time = 3340
.meas tran vdout2_9ck166 FIND v(dout2_9) AT=3340.1n

* CHECK dout2_10 Vdout2_10ck166 = 0 time = 3340
.meas tran vdout2_10ck166 FIND v(dout2_10) AT=3340.1n

* CHECK dout2_11 Vdout2_11ck166 = 0 time = 3340
.meas tran vdout2_11ck166 FIND v(dout2_11) AT=3340.1n

* CHECK dout2_12 Vdout2_12ck166 = 1.8 time = 3340
.meas tran vdout2_12ck166 FIND v(dout2_12) AT=3340.1n

* CHECK dout2_13 Vdout2_13ck166 = 1.8 time = 3340
.meas tran vdout2_13ck166 FIND v(dout2_13) AT=3340.1n

* CHECK dout2_14 Vdout2_14ck166 = 1.8 time = 3340
.meas tran vdout2_14ck166 FIND v(dout2_14) AT=3340.1n

* CHECK dout2_15 Vdout2_15ck166 = 1.8 time = 3340
.meas tran vdout2_15ck166 FIND v(dout2_15) AT=3340.1n

* CHECK dout2_16 Vdout2_16ck166 = 1.8 time = 3340
.meas tran vdout2_16ck166 FIND v(dout2_16) AT=3340.1n

* CHECK dout2_17 Vdout2_17ck166 = 0 time = 3340
.meas tran vdout2_17ck166 FIND v(dout2_17) AT=3340.1n

* CHECK dout2_18 Vdout2_18ck166 = 0 time = 3340
.meas tran vdout2_18ck166 FIND v(dout2_18) AT=3340.1n

* CHECK dout2_19 Vdout2_19ck166 = 1.8 time = 3340
.meas tran vdout2_19ck166 FIND v(dout2_19) AT=3340.1n

* CHECK dout2_20 Vdout2_20ck166 = 1.8 time = 3340
.meas tran vdout2_20ck166 FIND v(dout2_20) AT=3340.1n

* CHECK dout2_21 Vdout2_21ck166 = 0 time = 3340
.meas tran vdout2_21ck166 FIND v(dout2_21) AT=3340.1n

* CHECK dout2_22 Vdout2_22ck166 = 0 time = 3340
.meas tran vdout2_22ck166 FIND v(dout2_22) AT=3340.1n

* CHECK dout2_23 Vdout2_23ck166 = 0 time = 3340
.meas tran vdout2_23ck166 FIND v(dout2_23) AT=3340.1n

* CHECK dout2_24 Vdout2_24ck166 = 1.8 time = 3340
.meas tran vdout2_24ck166 FIND v(dout2_24) AT=3340.1n

* CHECK dout2_25 Vdout2_25ck166 = 0 time = 3340
.meas tran vdout2_25ck166 FIND v(dout2_25) AT=3340.1n

* CHECK dout2_26 Vdout2_26ck166 = 1.8 time = 3340
.meas tran vdout2_26ck166 FIND v(dout2_26) AT=3340.1n

* CHECK dout2_27 Vdout2_27ck166 = 0 time = 3340
.meas tran vdout2_27ck166 FIND v(dout2_27) AT=3340.1n

* CHECK dout2_28 Vdout2_28ck166 = 0 time = 3340
.meas tran vdout2_28ck166 FIND v(dout2_28) AT=3340.1n

* CHECK dout2_29 Vdout2_29ck166 = 0 time = 3340
.meas tran vdout2_29ck166 FIND v(dout2_29) AT=3340.1n

* CHECK dout2_30 Vdout2_30ck166 = 1.8 time = 3340
.meas tran vdout2_30ck166 FIND v(dout2_30) AT=3340.1n

* CHECK dout2_31 Vdout2_31ck166 = 1.8 time = 3340
.meas tran vdout2_31ck166 FIND v(dout2_31) AT=3340.1n

* CHECK dout1_0 Vdout1_0ck167 = 1.8 time = 3360
.meas tran vdout1_0ck167 FIND v(dout1_0) AT=3360.1n

* CHECK dout1_1 Vdout1_1ck167 = 0 time = 3360
.meas tran vdout1_1ck167 FIND v(dout1_1) AT=3360.1n

* CHECK dout1_2 Vdout1_2ck167 = 0 time = 3360
.meas tran vdout1_2ck167 FIND v(dout1_2) AT=3360.1n

* CHECK dout1_3 Vdout1_3ck167 = 0 time = 3360
.meas tran vdout1_3ck167 FIND v(dout1_3) AT=3360.1n

* CHECK dout1_4 Vdout1_4ck167 = 0 time = 3360
.meas tran vdout1_4ck167 FIND v(dout1_4) AT=3360.1n

* CHECK dout1_5 Vdout1_5ck167 = 0 time = 3360
.meas tran vdout1_5ck167 FIND v(dout1_5) AT=3360.1n

* CHECK dout1_6 Vdout1_6ck167 = 1.8 time = 3360
.meas tran vdout1_6ck167 FIND v(dout1_6) AT=3360.1n

* CHECK dout1_7 Vdout1_7ck167 = 0 time = 3360
.meas tran vdout1_7ck167 FIND v(dout1_7) AT=3360.1n

* CHECK dout1_8 Vdout1_8ck167 = 0 time = 3360
.meas tran vdout1_8ck167 FIND v(dout1_8) AT=3360.1n

* CHECK dout1_9 Vdout1_9ck167 = 0 time = 3360
.meas tran vdout1_9ck167 FIND v(dout1_9) AT=3360.1n

* CHECK dout1_10 Vdout1_10ck167 = 1.8 time = 3360
.meas tran vdout1_10ck167 FIND v(dout1_10) AT=3360.1n

* CHECK dout1_11 Vdout1_11ck167 = 1.8 time = 3360
.meas tran vdout1_11ck167 FIND v(dout1_11) AT=3360.1n

* CHECK dout1_12 Vdout1_12ck167 = 1.8 time = 3360
.meas tran vdout1_12ck167 FIND v(dout1_12) AT=3360.1n

* CHECK dout1_13 Vdout1_13ck167 = 1.8 time = 3360
.meas tran vdout1_13ck167 FIND v(dout1_13) AT=3360.1n

* CHECK dout1_14 Vdout1_14ck167 = 0 time = 3360
.meas tran vdout1_14ck167 FIND v(dout1_14) AT=3360.1n

* CHECK dout1_15 Vdout1_15ck167 = 0 time = 3360
.meas tran vdout1_15ck167 FIND v(dout1_15) AT=3360.1n

* CHECK dout1_16 Vdout1_16ck167 = 1.8 time = 3360
.meas tran vdout1_16ck167 FIND v(dout1_16) AT=3360.1n

* CHECK dout1_17 Vdout1_17ck167 = 0 time = 3360
.meas tran vdout1_17ck167 FIND v(dout1_17) AT=3360.1n

* CHECK dout1_18 Vdout1_18ck167 = 0 time = 3360
.meas tran vdout1_18ck167 FIND v(dout1_18) AT=3360.1n

* CHECK dout1_19 Vdout1_19ck167 = 1.8 time = 3360
.meas tran vdout1_19ck167 FIND v(dout1_19) AT=3360.1n

* CHECK dout1_20 Vdout1_20ck167 = 1.8 time = 3360
.meas tran vdout1_20ck167 FIND v(dout1_20) AT=3360.1n

* CHECK dout1_21 Vdout1_21ck167 = 0 time = 3360
.meas tran vdout1_21ck167 FIND v(dout1_21) AT=3360.1n

* CHECK dout1_22 Vdout1_22ck167 = 1.8 time = 3360
.meas tran vdout1_22ck167 FIND v(dout1_22) AT=3360.1n

* CHECK dout1_23 Vdout1_23ck167 = 0 time = 3360
.meas tran vdout1_23ck167 FIND v(dout1_23) AT=3360.1n

* CHECK dout1_24 Vdout1_24ck167 = 0 time = 3360
.meas tran vdout1_24ck167 FIND v(dout1_24) AT=3360.1n

* CHECK dout1_25 Vdout1_25ck167 = 1.8 time = 3360
.meas tran vdout1_25ck167 FIND v(dout1_25) AT=3360.1n

* CHECK dout1_26 Vdout1_26ck167 = 1.8 time = 3360
.meas tran vdout1_26ck167 FIND v(dout1_26) AT=3360.1n

* CHECK dout1_27 Vdout1_27ck167 = 0 time = 3360
.meas tran vdout1_27ck167 FIND v(dout1_27) AT=3360.1n

* CHECK dout1_28 Vdout1_28ck167 = 1.8 time = 3360
.meas tran vdout1_28ck167 FIND v(dout1_28) AT=3360.1n

* CHECK dout1_29 Vdout1_29ck167 = 0 time = 3360
.meas tran vdout1_29ck167 FIND v(dout1_29) AT=3360.1n

* CHECK dout1_30 Vdout1_30ck167 = 0 time = 3360
.meas tran vdout1_30ck167 FIND v(dout1_30) AT=3360.1n

* CHECK dout1_31 Vdout1_31ck167 = 0 time = 3360
.meas tran vdout1_31ck167 FIND v(dout1_31) AT=3360.1n

* CHECK dout2_0 Vdout2_0ck167 = 0 time = 3360
.meas tran vdout2_0ck167 FIND v(dout2_0) AT=3360.1n

* CHECK dout2_1 Vdout2_1ck167 = 1.8 time = 3360
.meas tran vdout2_1ck167 FIND v(dout2_1) AT=3360.1n

* CHECK dout2_2 Vdout2_2ck167 = 1.8 time = 3360
.meas tran vdout2_2ck167 FIND v(dout2_2) AT=3360.1n

* CHECK dout2_3 Vdout2_3ck167 = 1.8 time = 3360
.meas tran vdout2_3ck167 FIND v(dout2_3) AT=3360.1n

* CHECK dout2_4 Vdout2_4ck167 = 0 time = 3360
.meas tran vdout2_4ck167 FIND v(dout2_4) AT=3360.1n

* CHECK dout2_5 Vdout2_5ck167 = 1.8 time = 3360
.meas tran vdout2_5ck167 FIND v(dout2_5) AT=3360.1n

* CHECK dout2_6 Vdout2_6ck167 = 0 time = 3360
.meas tran vdout2_6ck167 FIND v(dout2_6) AT=3360.1n

* CHECK dout2_7 Vdout2_7ck167 = 0 time = 3360
.meas tran vdout2_7ck167 FIND v(dout2_7) AT=3360.1n

* CHECK dout2_8 Vdout2_8ck167 = 1.8 time = 3360
.meas tran vdout2_8ck167 FIND v(dout2_8) AT=3360.1n

* CHECK dout2_9 Vdout2_9ck167 = 1.8 time = 3360
.meas tran vdout2_9ck167 FIND v(dout2_9) AT=3360.1n

* CHECK dout2_10 Vdout2_10ck167 = 1.8 time = 3360
.meas tran vdout2_10ck167 FIND v(dout2_10) AT=3360.1n

* CHECK dout2_11 Vdout2_11ck167 = 0 time = 3360
.meas tran vdout2_11ck167 FIND v(dout2_11) AT=3360.1n

* CHECK dout2_12 Vdout2_12ck167 = 1.8 time = 3360
.meas tran vdout2_12ck167 FIND v(dout2_12) AT=3360.1n

* CHECK dout2_13 Vdout2_13ck167 = 0 time = 3360
.meas tran vdout2_13ck167 FIND v(dout2_13) AT=3360.1n

* CHECK dout2_14 Vdout2_14ck167 = 1.8 time = 3360
.meas tran vdout2_14ck167 FIND v(dout2_14) AT=3360.1n

* CHECK dout2_15 Vdout2_15ck167 = 1.8 time = 3360
.meas tran vdout2_15ck167 FIND v(dout2_15) AT=3360.1n

* CHECK dout2_16 Vdout2_16ck167 = 0 time = 3360
.meas tran vdout2_16ck167 FIND v(dout2_16) AT=3360.1n

* CHECK dout2_17 Vdout2_17ck167 = 0 time = 3360
.meas tran vdout2_17ck167 FIND v(dout2_17) AT=3360.1n

* CHECK dout2_18 Vdout2_18ck167 = 1.8 time = 3360
.meas tran vdout2_18ck167 FIND v(dout2_18) AT=3360.1n

* CHECK dout2_19 Vdout2_19ck167 = 1.8 time = 3360
.meas tran vdout2_19ck167 FIND v(dout2_19) AT=3360.1n

* CHECK dout2_20 Vdout2_20ck167 = 1.8 time = 3360
.meas tran vdout2_20ck167 FIND v(dout2_20) AT=3360.1n

* CHECK dout2_21 Vdout2_21ck167 = 1.8 time = 3360
.meas tran vdout2_21ck167 FIND v(dout2_21) AT=3360.1n

* CHECK dout2_22 Vdout2_22ck167 = 1.8 time = 3360
.meas tran vdout2_22ck167 FIND v(dout2_22) AT=3360.1n

* CHECK dout2_23 Vdout2_23ck167 = 1.8 time = 3360
.meas tran vdout2_23ck167 FIND v(dout2_23) AT=3360.1n

* CHECK dout2_24 Vdout2_24ck167 = 1.8 time = 3360
.meas tran vdout2_24ck167 FIND v(dout2_24) AT=3360.1n

* CHECK dout2_25 Vdout2_25ck167 = 1.8 time = 3360
.meas tran vdout2_25ck167 FIND v(dout2_25) AT=3360.1n

* CHECK dout2_26 Vdout2_26ck167 = 1.8 time = 3360
.meas tran vdout2_26ck167 FIND v(dout2_26) AT=3360.1n

* CHECK dout2_27 Vdout2_27ck167 = 1.8 time = 3360
.meas tran vdout2_27ck167 FIND v(dout2_27) AT=3360.1n

* CHECK dout2_28 Vdout2_28ck167 = 1.8 time = 3360
.meas tran vdout2_28ck167 FIND v(dout2_28) AT=3360.1n

* CHECK dout2_29 Vdout2_29ck167 = 0 time = 3360
.meas tran vdout2_29ck167 FIND v(dout2_29) AT=3360.1n

* CHECK dout2_30 Vdout2_30ck167 = 0 time = 3360
.meas tran vdout2_30ck167 FIND v(dout2_30) AT=3360.1n

* CHECK dout2_31 Vdout2_31ck167 = 0 time = 3360
.meas tran vdout2_31ck167 FIND v(dout2_31) AT=3360.1n

* CHECK dout2_0 Vdout2_0ck168 = 0 time = 3380
.meas tran vdout2_0ck168 FIND v(dout2_0) AT=3380.1n

* CHECK dout2_1 Vdout2_1ck168 = 1.8 time = 3380
.meas tran vdout2_1ck168 FIND v(dout2_1) AT=3380.1n

* CHECK dout2_2 Vdout2_2ck168 = 0 time = 3380
.meas tran vdout2_2ck168 FIND v(dout2_2) AT=3380.1n

* CHECK dout2_3 Vdout2_3ck168 = 0 time = 3380
.meas tran vdout2_3ck168 FIND v(dout2_3) AT=3380.1n

* CHECK dout2_4 Vdout2_4ck168 = 1.8 time = 3380
.meas tran vdout2_4ck168 FIND v(dout2_4) AT=3380.1n

* CHECK dout2_5 Vdout2_5ck168 = 0 time = 3380
.meas tran vdout2_5ck168 FIND v(dout2_5) AT=3380.1n

* CHECK dout2_6 Vdout2_6ck168 = 0 time = 3380
.meas tran vdout2_6ck168 FIND v(dout2_6) AT=3380.1n

* CHECK dout2_7 Vdout2_7ck168 = 0 time = 3380
.meas tran vdout2_7ck168 FIND v(dout2_7) AT=3380.1n

* CHECK dout2_8 Vdout2_8ck168 = 1.8 time = 3380
.meas tran vdout2_8ck168 FIND v(dout2_8) AT=3380.1n

* CHECK dout2_9 Vdout2_9ck168 = 0 time = 3380
.meas tran vdout2_9ck168 FIND v(dout2_9) AT=3380.1n

* CHECK dout2_10 Vdout2_10ck168 = 0 time = 3380
.meas tran vdout2_10ck168 FIND v(dout2_10) AT=3380.1n

* CHECK dout2_11 Vdout2_11ck168 = 0 time = 3380
.meas tran vdout2_11ck168 FIND v(dout2_11) AT=3380.1n

* CHECK dout2_12 Vdout2_12ck168 = 1.8 time = 3380
.meas tran vdout2_12ck168 FIND v(dout2_12) AT=3380.1n

* CHECK dout2_13 Vdout2_13ck168 = 1.8 time = 3380
.meas tran vdout2_13ck168 FIND v(dout2_13) AT=3380.1n

* CHECK dout2_14 Vdout2_14ck168 = 1.8 time = 3380
.meas tran vdout2_14ck168 FIND v(dout2_14) AT=3380.1n

* CHECK dout2_15 Vdout2_15ck168 = 1.8 time = 3380
.meas tran vdout2_15ck168 FIND v(dout2_15) AT=3380.1n

* CHECK dout2_16 Vdout2_16ck168 = 1.8 time = 3380
.meas tran vdout2_16ck168 FIND v(dout2_16) AT=3380.1n

* CHECK dout2_17 Vdout2_17ck168 = 0 time = 3380
.meas tran vdout2_17ck168 FIND v(dout2_17) AT=3380.1n

* CHECK dout2_18 Vdout2_18ck168 = 0 time = 3380
.meas tran vdout2_18ck168 FIND v(dout2_18) AT=3380.1n

* CHECK dout2_19 Vdout2_19ck168 = 1.8 time = 3380
.meas tran vdout2_19ck168 FIND v(dout2_19) AT=3380.1n

* CHECK dout2_20 Vdout2_20ck168 = 1.8 time = 3380
.meas tran vdout2_20ck168 FIND v(dout2_20) AT=3380.1n

* CHECK dout2_21 Vdout2_21ck168 = 0 time = 3380
.meas tran vdout2_21ck168 FIND v(dout2_21) AT=3380.1n

* CHECK dout2_22 Vdout2_22ck168 = 0 time = 3380
.meas tran vdout2_22ck168 FIND v(dout2_22) AT=3380.1n

* CHECK dout2_23 Vdout2_23ck168 = 0 time = 3380
.meas tran vdout2_23ck168 FIND v(dout2_23) AT=3380.1n

* CHECK dout2_24 Vdout2_24ck168 = 1.8 time = 3380
.meas tran vdout2_24ck168 FIND v(dout2_24) AT=3380.1n

* CHECK dout2_25 Vdout2_25ck168 = 0 time = 3380
.meas tran vdout2_25ck168 FIND v(dout2_25) AT=3380.1n

* CHECK dout2_26 Vdout2_26ck168 = 1.8 time = 3380
.meas tran vdout2_26ck168 FIND v(dout2_26) AT=3380.1n

* CHECK dout2_27 Vdout2_27ck168 = 0 time = 3380
.meas tran vdout2_27ck168 FIND v(dout2_27) AT=3380.1n

* CHECK dout2_28 Vdout2_28ck168 = 0 time = 3380
.meas tran vdout2_28ck168 FIND v(dout2_28) AT=3380.1n

* CHECK dout2_29 Vdout2_29ck168 = 0 time = 3380
.meas tran vdout2_29ck168 FIND v(dout2_29) AT=3380.1n

* CHECK dout2_30 Vdout2_30ck168 = 1.8 time = 3380
.meas tran vdout2_30ck168 FIND v(dout2_30) AT=3380.1n

* CHECK dout2_31 Vdout2_31ck168 = 1.8 time = 3380
.meas tran vdout2_31ck168 FIND v(dout2_31) AT=3380.1n

* CHECK dout2_0 Vdout2_0ck169 = 0 time = 3400
.meas tran vdout2_0ck169 FIND v(dout2_0) AT=3400.1n

* CHECK dout2_1 Vdout2_1ck169 = 1.8 time = 3400
.meas tran vdout2_1ck169 FIND v(dout2_1) AT=3400.1n

* CHECK dout2_2 Vdout2_2ck169 = 0 time = 3400
.meas tran vdout2_2ck169 FIND v(dout2_2) AT=3400.1n

* CHECK dout2_3 Vdout2_3ck169 = 0 time = 3400
.meas tran vdout2_3ck169 FIND v(dout2_3) AT=3400.1n

* CHECK dout2_4 Vdout2_4ck169 = 0 time = 3400
.meas tran vdout2_4ck169 FIND v(dout2_4) AT=3400.1n

* CHECK dout2_5 Vdout2_5ck169 = 0 time = 3400
.meas tran vdout2_5ck169 FIND v(dout2_5) AT=3400.1n

* CHECK dout2_6 Vdout2_6ck169 = 0 time = 3400
.meas tran vdout2_6ck169 FIND v(dout2_6) AT=3400.1n

* CHECK dout2_7 Vdout2_7ck169 = 0 time = 3400
.meas tran vdout2_7ck169 FIND v(dout2_7) AT=3400.1n

* CHECK dout2_8 Vdout2_8ck169 = 1.8 time = 3400
.meas tran vdout2_8ck169 FIND v(dout2_8) AT=3400.1n

* CHECK dout2_9 Vdout2_9ck169 = 1.8 time = 3400
.meas tran vdout2_9ck169 FIND v(dout2_9) AT=3400.1n

* CHECK dout2_10 Vdout2_10ck169 = 0 time = 3400
.meas tran vdout2_10ck169 FIND v(dout2_10) AT=3400.1n

* CHECK dout2_11 Vdout2_11ck169 = 1.8 time = 3400
.meas tran vdout2_11ck169 FIND v(dout2_11) AT=3400.1n

* CHECK dout2_12 Vdout2_12ck169 = 1.8 time = 3400
.meas tran vdout2_12ck169 FIND v(dout2_12) AT=3400.1n

* CHECK dout2_13 Vdout2_13ck169 = 0 time = 3400
.meas tran vdout2_13ck169 FIND v(dout2_13) AT=3400.1n

* CHECK dout2_14 Vdout2_14ck169 = 0 time = 3400
.meas tran vdout2_14ck169 FIND v(dout2_14) AT=3400.1n

* CHECK dout2_15 Vdout2_15ck169 = 0 time = 3400
.meas tran vdout2_15ck169 FIND v(dout2_15) AT=3400.1n

* CHECK dout2_16 Vdout2_16ck169 = 0 time = 3400
.meas tran vdout2_16ck169 FIND v(dout2_16) AT=3400.1n

* CHECK dout2_17 Vdout2_17ck169 = 1.8 time = 3400
.meas tran vdout2_17ck169 FIND v(dout2_17) AT=3400.1n

* CHECK dout2_18 Vdout2_18ck169 = 0 time = 3400
.meas tran vdout2_18ck169 FIND v(dout2_18) AT=3400.1n

* CHECK dout2_19 Vdout2_19ck169 = 1.8 time = 3400
.meas tran vdout2_19ck169 FIND v(dout2_19) AT=3400.1n

* CHECK dout2_20 Vdout2_20ck169 = 1.8 time = 3400
.meas tran vdout2_20ck169 FIND v(dout2_20) AT=3400.1n

* CHECK dout2_21 Vdout2_21ck169 = 1.8 time = 3400
.meas tran vdout2_21ck169 FIND v(dout2_21) AT=3400.1n

* CHECK dout2_22 Vdout2_22ck169 = 0 time = 3400
.meas tran vdout2_22ck169 FIND v(dout2_22) AT=3400.1n

* CHECK dout2_23 Vdout2_23ck169 = 1.8 time = 3400
.meas tran vdout2_23ck169 FIND v(dout2_23) AT=3400.1n

* CHECK dout2_24 Vdout2_24ck169 = 0 time = 3400
.meas tran vdout2_24ck169 FIND v(dout2_24) AT=3400.1n

* CHECK dout2_25 Vdout2_25ck169 = 0 time = 3400
.meas tran vdout2_25ck169 FIND v(dout2_25) AT=3400.1n

* CHECK dout2_26 Vdout2_26ck169 = 1.8 time = 3400
.meas tran vdout2_26ck169 FIND v(dout2_26) AT=3400.1n

* CHECK dout2_27 Vdout2_27ck169 = 1.8 time = 3400
.meas tran vdout2_27ck169 FIND v(dout2_27) AT=3400.1n

* CHECK dout2_28 Vdout2_28ck169 = 0 time = 3400
.meas tran vdout2_28ck169 FIND v(dout2_28) AT=3400.1n

* CHECK dout2_29 Vdout2_29ck169 = 1.8 time = 3400
.meas tran vdout2_29ck169 FIND v(dout2_29) AT=3400.1n

* CHECK dout2_30 Vdout2_30ck169 = 1.8 time = 3400
.meas tran vdout2_30ck169 FIND v(dout2_30) AT=3400.1n

* CHECK dout2_31 Vdout2_31ck169 = 0 time = 3400
.meas tran vdout2_31ck169 FIND v(dout2_31) AT=3400.1n

* CHECK dout1_0 Vdout1_0ck170 = 0 time = 3420
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=3420.1n

* CHECK dout1_1 Vdout1_1ck170 = 1.8 time = 3420
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=3420.1n

* CHECK dout1_2 Vdout1_2ck170 = 0 time = 3420
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=3420.1n

* CHECK dout1_3 Vdout1_3ck170 = 1.8 time = 3420
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=3420.1n

* CHECK dout1_4 Vdout1_4ck170 = 0 time = 3420
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=3420.1n

* CHECK dout1_5 Vdout1_5ck170 = 0 time = 3420
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=3420.1n

* CHECK dout1_6 Vdout1_6ck170 = 0 time = 3420
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=3420.1n

* CHECK dout1_7 Vdout1_7ck170 = 1.8 time = 3420
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=3420.1n

* CHECK dout1_8 Vdout1_8ck170 = 1.8 time = 3420
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=3420.1n

* CHECK dout1_9 Vdout1_9ck170 = 1.8 time = 3420
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=3420.1n

* CHECK dout1_10 Vdout1_10ck170 = 1.8 time = 3420
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=3420.1n

* CHECK dout1_11 Vdout1_11ck170 = 0 time = 3420
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=3420.1n

* CHECK dout1_12 Vdout1_12ck170 = 0 time = 3420
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=3420.1n

* CHECK dout1_13 Vdout1_13ck170 = 1.8 time = 3420
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=3420.1n

* CHECK dout1_14 Vdout1_14ck170 = 0 time = 3420
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=3420.1n

* CHECK dout1_15 Vdout1_15ck170 = 1.8 time = 3420
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=3420.1n

* CHECK dout1_16 Vdout1_16ck170 = 0 time = 3420
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=3420.1n

* CHECK dout1_17 Vdout1_17ck170 = 0 time = 3420
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=3420.1n

* CHECK dout1_18 Vdout1_18ck170 = 0 time = 3420
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=3420.1n

* CHECK dout1_19 Vdout1_19ck170 = 1.8 time = 3420
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=3420.1n

* CHECK dout1_20 Vdout1_20ck170 = 1.8 time = 3420
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=3420.1n

* CHECK dout1_21 Vdout1_21ck170 = 1.8 time = 3420
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=3420.1n

* CHECK dout1_22 Vdout1_22ck170 = 1.8 time = 3420
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=3420.1n

* CHECK dout1_23 Vdout1_23ck170 = 0 time = 3420
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=3420.1n

* CHECK dout1_24 Vdout1_24ck170 = 1.8 time = 3420
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=3420.1n

* CHECK dout1_25 Vdout1_25ck170 = 0 time = 3420
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=3420.1n

* CHECK dout1_26 Vdout1_26ck170 = 0 time = 3420
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=3420.1n

* CHECK dout1_27 Vdout1_27ck170 = 0 time = 3420
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=3420.1n

* CHECK dout1_28 Vdout1_28ck170 = 0 time = 3420
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=3420.1n

* CHECK dout1_29 Vdout1_29ck170 = 1.8 time = 3420
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=3420.1n

* CHECK dout1_30 Vdout1_30ck170 = 1.8 time = 3420
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=3420.1n

* CHECK dout1_31 Vdout1_31ck170 = 0 time = 3420
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=3420.1n

* CHECK dout2_0 Vdout2_0ck170 = 1.8 time = 3420
.meas tran vdout2_0ck170 FIND v(dout2_0) AT=3420.1n

* CHECK dout2_1 Vdout2_1ck170 = 1.8 time = 3420
.meas tran vdout2_1ck170 FIND v(dout2_1) AT=3420.1n

* CHECK dout2_2 Vdout2_2ck170 = 1.8 time = 3420
.meas tran vdout2_2ck170 FIND v(dout2_2) AT=3420.1n

* CHECK dout2_3 Vdout2_3ck170 = 1.8 time = 3420
.meas tran vdout2_3ck170 FIND v(dout2_3) AT=3420.1n

* CHECK dout2_4 Vdout2_4ck170 = 1.8 time = 3420
.meas tran vdout2_4ck170 FIND v(dout2_4) AT=3420.1n

* CHECK dout2_5 Vdout2_5ck170 = 0 time = 3420
.meas tran vdout2_5ck170 FIND v(dout2_5) AT=3420.1n

* CHECK dout2_6 Vdout2_6ck170 = 1.8 time = 3420
.meas tran vdout2_6ck170 FIND v(dout2_6) AT=3420.1n

* CHECK dout2_7 Vdout2_7ck170 = 1.8 time = 3420
.meas tran vdout2_7ck170 FIND v(dout2_7) AT=3420.1n

* CHECK dout2_8 Vdout2_8ck170 = 0 time = 3420
.meas tran vdout2_8ck170 FIND v(dout2_8) AT=3420.1n

* CHECK dout2_9 Vdout2_9ck170 = 1.8 time = 3420
.meas tran vdout2_9ck170 FIND v(dout2_9) AT=3420.1n

* CHECK dout2_10 Vdout2_10ck170 = 0 time = 3420
.meas tran vdout2_10ck170 FIND v(dout2_10) AT=3420.1n

* CHECK dout2_11 Vdout2_11ck170 = 0 time = 3420
.meas tran vdout2_11ck170 FIND v(dout2_11) AT=3420.1n

* CHECK dout2_12 Vdout2_12ck170 = 0 time = 3420
.meas tran vdout2_12ck170 FIND v(dout2_12) AT=3420.1n

* CHECK dout2_13 Vdout2_13ck170 = 0 time = 3420
.meas tran vdout2_13ck170 FIND v(dout2_13) AT=3420.1n

* CHECK dout2_14 Vdout2_14ck170 = 0 time = 3420
.meas tran vdout2_14ck170 FIND v(dout2_14) AT=3420.1n

* CHECK dout2_15 Vdout2_15ck170 = 0 time = 3420
.meas tran vdout2_15ck170 FIND v(dout2_15) AT=3420.1n

* CHECK dout2_16 Vdout2_16ck170 = 0 time = 3420
.meas tran vdout2_16ck170 FIND v(dout2_16) AT=3420.1n

* CHECK dout2_17 Vdout2_17ck170 = 0 time = 3420
.meas tran vdout2_17ck170 FIND v(dout2_17) AT=3420.1n

* CHECK dout2_18 Vdout2_18ck170 = 0 time = 3420
.meas tran vdout2_18ck170 FIND v(dout2_18) AT=3420.1n

* CHECK dout2_19 Vdout2_19ck170 = 1.8 time = 3420
.meas tran vdout2_19ck170 FIND v(dout2_19) AT=3420.1n

* CHECK dout2_20 Vdout2_20ck170 = 0 time = 3420
.meas tran vdout2_20ck170 FIND v(dout2_20) AT=3420.1n

* CHECK dout2_21 Vdout2_21ck170 = 1.8 time = 3420
.meas tran vdout2_21ck170 FIND v(dout2_21) AT=3420.1n

* CHECK dout2_22 Vdout2_22ck170 = 1.8 time = 3420
.meas tran vdout2_22ck170 FIND v(dout2_22) AT=3420.1n

* CHECK dout2_23 Vdout2_23ck170 = 0 time = 3420
.meas tran vdout2_23ck170 FIND v(dout2_23) AT=3420.1n

* CHECK dout2_24 Vdout2_24ck170 = 0 time = 3420
.meas tran vdout2_24ck170 FIND v(dout2_24) AT=3420.1n

* CHECK dout2_25 Vdout2_25ck170 = 1.8 time = 3420
.meas tran vdout2_25ck170 FIND v(dout2_25) AT=3420.1n

* CHECK dout2_26 Vdout2_26ck170 = 0 time = 3420
.meas tran vdout2_26ck170 FIND v(dout2_26) AT=3420.1n

* CHECK dout2_27 Vdout2_27ck170 = 1.8 time = 3420
.meas tran vdout2_27ck170 FIND v(dout2_27) AT=3420.1n

* CHECK dout2_28 Vdout2_28ck170 = 1.8 time = 3420
.meas tran vdout2_28ck170 FIND v(dout2_28) AT=3420.1n

* CHECK dout2_29 Vdout2_29ck170 = 0 time = 3420
.meas tran vdout2_29ck170 FIND v(dout2_29) AT=3420.1n

* CHECK dout2_30 Vdout2_30ck170 = 1.8 time = 3420
.meas tran vdout2_30ck170 FIND v(dout2_30) AT=3420.1n

* CHECK dout2_31 Vdout2_31ck170 = 0 time = 3420
.meas tran vdout2_31ck170 FIND v(dout2_31) AT=3420.1n

* CHECK dout1_0 Vdout1_0ck171 = 1.8 time = 3440
.meas tran vdout1_0ck171 FIND v(dout1_0) AT=3440.1n

* CHECK dout1_1 Vdout1_1ck171 = 1.8 time = 3440
.meas tran vdout1_1ck171 FIND v(dout1_1) AT=3440.1n

* CHECK dout1_2 Vdout1_2ck171 = 1.8 time = 3440
.meas tran vdout1_2ck171 FIND v(dout1_2) AT=3440.1n

* CHECK dout1_3 Vdout1_3ck171 = 1.8 time = 3440
.meas tran vdout1_3ck171 FIND v(dout1_3) AT=3440.1n

* CHECK dout1_4 Vdout1_4ck171 = 1.8 time = 3440
.meas tran vdout1_4ck171 FIND v(dout1_4) AT=3440.1n

* CHECK dout1_5 Vdout1_5ck171 = 0 time = 3440
.meas tran vdout1_5ck171 FIND v(dout1_5) AT=3440.1n

* CHECK dout1_6 Vdout1_6ck171 = 1.8 time = 3440
.meas tran vdout1_6ck171 FIND v(dout1_6) AT=3440.1n

* CHECK dout1_7 Vdout1_7ck171 = 1.8 time = 3440
.meas tran vdout1_7ck171 FIND v(dout1_7) AT=3440.1n

* CHECK dout1_8 Vdout1_8ck171 = 0 time = 3440
.meas tran vdout1_8ck171 FIND v(dout1_8) AT=3440.1n

* CHECK dout1_9 Vdout1_9ck171 = 1.8 time = 3440
.meas tran vdout1_9ck171 FIND v(dout1_9) AT=3440.1n

* CHECK dout1_10 Vdout1_10ck171 = 0 time = 3440
.meas tran vdout1_10ck171 FIND v(dout1_10) AT=3440.1n

* CHECK dout1_11 Vdout1_11ck171 = 0 time = 3440
.meas tran vdout1_11ck171 FIND v(dout1_11) AT=3440.1n

* CHECK dout1_12 Vdout1_12ck171 = 0 time = 3440
.meas tran vdout1_12ck171 FIND v(dout1_12) AT=3440.1n

* CHECK dout1_13 Vdout1_13ck171 = 0 time = 3440
.meas tran vdout1_13ck171 FIND v(dout1_13) AT=3440.1n

* CHECK dout1_14 Vdout1_14ck171 = 0 time = 3440
.meas tran vdout1_14ck171 FIND v(dout1_14) AT=3440.1n

* CHECK dout1_15 Vdout1_15ck171 = 0 time = 3440
.meas tran vdout1_15ck171 FIND v(dout1_15) AT=3440.1n

* CHECK dout1_16 Vdout1_16ck171 = 0 time = 3440
.meas tran vdout1_16ck171 FIND v(dout1_16) AT=3440.1n

* CHECK dout1_17 Vdout1_17ck171 = 0 time = 3440
.meas tran vdout1_17ck171 FIND v(dout1_17) AT=3440.1n

* CHECK dout1_18 Vdout1_18ck171 = 0 time = 3440
.meas tran vdout1_18ck171 FIND v(dout1_18) AT=3440.1n

* CHECK dout1_19 Vdout1_19ck171 = 1.8 time = 3440
.meas tran vdout1_19ck171 FIND v(dout1_19) AT=3440.1n

* CHECK dout1_20 Vdout1_20ck171 = 0 time = 3440
.meas tran vdout1_20ck171 FIND v(dout1_20) AT=3440.1n

* CHECK dout1_21 Vdout1_21ck171 = 1.8 time = 3440
.meas tran vdout1_21ck171 FIND v(dout1_21) AT=3440.1n

* CHECK dout1_22 Vdout1_22ck171 = 1.8 time = 3440
.meas tran vdout1_22ck171 FIND v(dout1_22) AT=3440.1n

* CHECK dout1_23 Vdout1_23ck171 = 0 time = 3440
.meas tran vdout1_23ck171 FIND v(dout1_23) AT=3440.1n

* CHECK dout1_24 Vdout1_24ck171 = 0 time = 3440
.meas tran vdout1_24ck171 FIND v(dout1_24) AT=3440.1n

* CHECK dout1_25 Vdout1_25ck171 = 1.8 time = 3440
.meas tran vdout1_25ck171 FIND v(dout1_25) AT=3440.1n

* CHECK dout1_26 Vdout1_26ck171 = 0 time = 3440
.meas tran vdout1_26ck171 FIND v(dout1_26) AT=3440.1n

* CHECK dout1_27 Vdout1_27ck171 = 1.8 time = 3440
.meas tran vdout1_27ck171 FIND v(dout1_27) AT=3440.1n

* CHECK dout1_28 Vdout1_28ck171 = 1.8 time = 3440
.meas tran vdout1_28ck171 FIND v(dout1_28) AT=3440.1n

* CHECK dout1_29 Vdout1_29ck171 = 0 time = 3440
.meas tran vdout1_29ck171 FIND v(dout1_29) AT=3440.1n

* CHECK dout1_30 Vdout1_30ck171 = 1.8 time = 3440
.meas tran vdout1_30ck171 FIND v(dout1_30) AT=3440.1n

* CHECK dout1_31 Vdout1_31ck171 = 0 time = 3440
.meas tran vdout1_31ck171 FIND v(dout1_31) AT=3440.1n

* CHECK dout2_0 Vdout2_0ck171 = 1.8 time = 3440
.meas tran vdout2_0ck171 FIND v(dout2_0) AT=3440.1n

* CHECK dout2_1 Vdout2_1ck171 = 1.8 time = 3440
.meas tran vdout2_1ck171 FIND v(dout2_1) AT=3440.1n

* CHECK dout2_2 Vdout2_2ck171 = 1.8 time = 3440
.meas tran vdout2_2ck171 FIND v(dout2_2) AT=3440.1n

* CHECK dout2_3 Vdout2_3ck171 = 1.8 time = 3440
.meas tran vdout2_3ck171 FIND v(dout2_3) AT=3440.1n

* CHECK dout2_4 Vdout2_4ck171 = 1.8 time = 3440
.meas tran vdout2_4ck171 FIND v(dout2_4) AT=3440.1n

* CHECK dout2_5 Vdout2_5ck171 = 0 time = 3440
.meas tran vdout2_5ck171 FIND v(dout2_5) AT=3440.1n

* CHECK dout2_6 Vdout2_6ck171 = 1.8 time = 3440
.meas tran vdout2_6ck171 FIND v(dout2_6) AT=3440.1n

* CHECK dout2_7 Vdout2_7ck171 = 1.8 time = 3440
.meas tran vdout2_7ck171 FIND v(dout2_7) AT=3440.1n

* CHECK dout2_8 Vdout2_8ck171 = 0 time = 3440
.meas tran vdout2_8ck171 FIND v(dout2_8) AT=3440.1n

* CHECK dout2_9 Vdout2_9ck171 = 1.8 time = 3440
.meas tran vdout2_9ck171 FIND v(dout2_9) AT=3440.1n

* CHECK dout2_10 Vdout2_10ck171 = 0 time = 3440
.meas tran vdout2_10ck171 FIND v(dout2_10) AT=3440.1n

* CHECK dout2_11 Vdout2_11ck171 = 0 time = 3440
.meas tran vdout2_11ck171 FIND v(dout2_11) AT=3440.1n

* CHECK dout2_12 Vdout2_12ck171 = 0 time = 3440
.meas tran vdout2_12ck171 FIND v(dout2_12) AT=3440.1n

* CHECK dout2_13 Vdout2_13ck171 = 0 time = 3440
.meas tran vdout2_13ck171 FIND v(dout2_13) AT=3440.1n

* CHECK dout2_14 Vdout2_14ck171 = 0 time = 3440
.meas tran vdout2_14ck171 FIND v(dout2_14) AT=3440.1n

* CHECK dout2_15 Vdout2_15ck171 = 0 time = 3440
.meas tran vdout2_15ck171 FIND v(dout2_15) AT=3440.1n

* CHECK dout2_16 Vdout2_16ck171 = 0 time = 3440
.meas tran vdout2_16ck171 FIND v(dout2_16) AT=3440.1n

* CHECK dout2_17 Vdout2_17ck171 = 0 time = 3440
.meas tran vdout2_17ck171 FIND v(dout2_17) AT=3440.1n

* CHECK dout2_18 Vdout2_18ck171 = 0 time = 3440
.meas tran vdout2_18ck171 FIND v(dout2_18) AT=3440.1n

* CHECK dout2_19 Vdout2_19ck171 = 1.8 time = 3440
.meas tran vdout2_19ck171 FIND v(dout2_19) AT=3440.1n

* CHECK dout2_20 Vdout2_20ck171 = 0 time = 3440
.meas tran vdout2_20ck171 FIND v(dout2_20) AT=3440.1n

* CHECK dout2_21 Vdout2_21ck171 = 1.8 time = 3440
.meas tran vdout2_21ck171 FIND v(dout2_21) AT=3440.1n

* CHECK dout2_22 Vdout2_22ck171 = 1.8 time = 3440
.meas tran vdout2_22ck171 FIND v(dout2_22) AT=3440.1n

* CHECK dout2_23 Vdout2_23ck171 = 0 time = 3440
.meas tran vdout2_23ck171 FIND v(dout2_23) AT=3440.1n

* CHECK dout2_24 Vdout2_24ck171 = 0 time = 3440
.meas tran vdout2_24ck171 FIND v(dout2_24) AT=3440.1n

* CHECK dout2_25 Vdout2_25ck171 = 1.8 time = 3440
.meas tran vdout2_25ck171 FIND v(dout2_25) AT=3440.1n

* CHECK dout2_26 Vdout2_26ck171 = 0 time = 3440
.meas tran vdout2_26ck171 FIND v(dout2_26) AT=3440.1n

* CHECK dout2_27 Vdout2_27ck171 = 1.8 time = 3440
.meas tran vdout2_27ck171 FIND v(dout2_27) AT=3440.1n

* CHECK dout2_28 Vdout2_28ck171 = 1.8 time = 3440
.meas tran vdout2_28ck171 FIND v(dout2_28) AT=3440.1n

* CHECK dout2_29 Vdout2_29ck171 = 0 time = 3440
.meas tran vdout2_29ck171 FIND v(dout2_29) AT=3440.1n

* CHECK dout2_30 Vdout2_30ck171 = 1.8 time = 3440
.meas tran vdout2_30ck171 FIND v(dout2_30) AT=3440.1n

* CHECK dout2_31 Vdout2_31ck171 = 0 time = 3440
.meas tran vdout2_31ck171 FIND v(dout2_31) AT=3440.1n

* CHECK dout2_0 Vdout2_0ck172 = 1.8 time = 3460
.meas tran vdout2_0ck172 FIND v(dout2_0) AT=3460.1n

* CHECK dout2_1 Vdout2_1ck172 = 1.8 time = 3460
.meas tran vdout2_1ck172 FIND v(dout2_1) AT=3460.1n

* CHECK dout2_2 Vdout2_2ck172 = 1.8 time = 3460
.meas tran vdout2_2ck172 FIND v(dout2_2) AT=3460.1n

* CHECK dout2_3 Vdout2_3ck172 = 1.8 time = 3460
.meas tran vdout2_3ck172 FIND v(dout2_3) AT=3460.1n

* CHECK dout2_4 Vdout2_4ck172 = 1.8 time = 3460
.meas tran vdout2_4ck172 FIND v(dout2_4) AT=3460.1n

* CHECK dout2_5 Vdout2_5ck172 = 0 time = 3460
.meas tran vdout2_5ck172 FIND v(dout2_5) AT=3460.1n

* CHECK dout2_6 Vdout2_6ck172 = 1.8 time = 3460
.meas tran vdout2_6ck172 FIND v(dout2_6) AT=3460.1n

* CHECK dout2_7 Vdout2_7ck172 = 1.8 time = 3460
.meas tran vdout2_7ck172 FIND v(dout2_7) AT=3460.1n

* CHECK dout2_8 Vdout2_8ck172 = 0 time = 3460
.meas tran vdout2_8ck172 FIND v(dout2_8) AT=3460.1n

* CHECK dout2_9 Vdout2_9ck172 = 1.8 time = 3460
.meas tran vdout2_9ck172 FIND v(dout2_9) AT=3460.1n

* CHECK dout2_10 Vdout2_10ck172 = 0 time = 3460
.meas tran vdout2_10ck172 FIND v(dout2_10) AT=3460.1n

* CHECK dout2_11 Vdout2_11ck172 = 0 time = 3460
.meas tran vdout2_11ck172 FIND v(dout2_11) AT=3460.1n

* CHECK dout2_12 Vdout2_12ck172 = 0 time = 3460
.meas tran vdout2_12ck172 FIND v(dout2_12) AT=3460.1n

* CHECK dout2_13 Vdout2_13ck172 = 0 time = 3460
.meas tran vdout2_13ck172 FIND v(dout2_13) AT=3460.1n

* CHECK dout2_14 Vdout2_14ck172 = 0 time = 3460
.meas tran vdout2_14ck172 FIND v(dout2_14) AT=3460.1n

* CHECK dout2_15 Vdout2_15ck172 = 0 time = 3460
.meas tran vdout2_15ck172 FIND v(dout2_15) AT=3460.1n

* CHECK dout2_16 Vdout2_16ck172 = 0 time = 3460
.meas tran vdout2_16ck172 FIND v(dout2_16) AT=3460.1n

* CHECK dout2_17 Vdout2_17ck172 = 0 time = 3460
.meas tran vdout2_17ck172 FIND v(dout2_17) AT=3460.1n

* CHECK dout2_18 Vdout2_18ck172 = 0 time = 3460
.meas tran vdout2_18ck172 FIND v(dout2_18) AT=3460.1n

* CHECK dout2_19 Vdout2_19ck172 = 1.8 time = 3460
.meas tran vdout2_19ck172 FIND v(dout2_19) AT=3460.1n

* CHECK dout2_20 Vdout2_20ck172 = 0 time = 3460
.meas tran vdout2_20ck172 FIND v(dout2_20) AT=3460.1n

* CHECK dout2_21 Vdout2_21ck172 = 1.8 time = 3460
.meas tran vdout2_21ck172 FIND v(dout2_21) AT=3460.1n

* CHECK dout2_22 Vdout2_22ck172 = 1.8 time = 3460
.meas tran vdout2_22ck172 FIND v(dout2_22) AT=3460.1n

* CHECK dout2_23 Vdout2_23ck172 = 0 time = 3460
.meas tran vdout2_23ck172 FIND v(dout2_23) AT=3460.1n

* CHECK dout2_24 Vdout2_24ck172 = 0 time = 3460
.meas tran vdout2_24ck172 FIND v(dout2_24) AT=3460.1n

* CHECK dout2_25 Vdout2_25ck172 = 1.8 time = 3460
.meas tran vdout2_25ck172 FIND v(dout2_25) AT=3460.1n

* CHECK dout2_26 Vdout2_26ck172 = 0 time = 3460
.meas tran vdout2_26ck172 FIND v(dout2_26) AT=3460.1n

* CHECK dout2_27 Vdout2_27ck172 = 1.8 time = 3460
.meas tran vdout2_27ck172 FIND v(dout2_27) AT=3460.1n

* CHECK dout2_28 Vdout2_28ck172 = 1.8 time = 3460
.meas tran vdout2_28ck172 FIND v(dout2_28) AT=3460.1n

* CHECK dout2_29 Vdout2_29ck172 = 0 time = 3460
.meas tran vdout2_29ck172 FIND v(dout2_29) AT=3460.1n

* CHECK dout2_30 Vdout2_30ck172 = 1.8 time = 3460
.meas tran vdout2_30ck172 FIND v(dout2_30) AT=3460.1n

* CHECK dout2_31 Vdout2_31ck172 = 0 time = 3460
.meas tran vdout2_31ck172 FIND v(dout2_31) AT=3460.1n

* CHECK dout1_0 Vdout1_0ck173 = 0 time = 3480
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=3480.1n

* CHECK dout1_1 Vdout1_1ck173 = 1.8 time = 3480
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=3480.1n

* CHECK dout1_2 Vdout1_2ck173 = 0 time = 3480
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=3480.1n

* CHECK dout1_3 Vdout1_3ck173 = 1.8 time = 3480
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=3480.1n

* CHECK dout1_4 Vdout1_4ck173 = 0 time = 3480
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=3480.1n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 3480
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=3480.1n

* CHECK dout1_6 Vdout1_6ck173 = 0 time = 3480
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=3480.1n

* CHECK dout1_7 Vdout1_7ck173 = 1.8 time = 3480
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=3480.1n

* CHECK dout1_8 Vdout1_8ck173 = 1.8 time = 3480
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=3480.1n

* CHECK dout1_9 Vdout1_9ck173 = 1.8 time = 3480
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=3480.1n

* CHECK dout1_10 Vdout1_10ck173 = 1.8 time = 3480
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=3480.1n

* CHECK dout1_11 Vdout1_11ck173 = 0 time = 3480
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=3480.1n

* CHECK dout1_12 Vdout1_12ck173 = 0 time = 3480
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=3480.1n

* CHECK dout1_13 Vdout1_13ck173 = 1.8 time = 3480
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=3480.1n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 3480
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=3480.1n

* CHECK dout1_15 Vdout1_15ck173 = 1.8 time = 3480
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=3480.1n

* CHECK dout1_16 Vdout1_16ck173 = 0 time = 3480
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=3480.1n

* CHECK dout1_17 Vdout1_17ck173 = 0 time = 3480
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=3480.1n

* CHECK dout1_18 Vdout1_18ck173 = 0 time = 3480
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=3480.1n

* CHECK dout1_19 Vdout1_19ck173 = 1.8 time = 3480
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=3480.1n

* CHECK dout1_20 Vdout1_20ck173 = 1.8 time = 3480
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=3480.1n

* CHECK dout1_21 Vdout1_21ck173 = 1.8 time = 3480
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=3480.1n

* CHECK dout1_22 Vdout1_22ck173 = 1.8 time = 3480
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=3480.1n

* CHECK dout1_23 Vdout1_23ck173 = 0 time = 3480
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=3480.1n

* CHECK dout1_24 Vdout1_24ck173 = 1.8 time = 3480
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=3480.1n

* CHECK dout1_25 Vdout1_25ck173 = 0 time = 3480
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=3480.1n

* CHECK dout1_26 Vdout1_26ck173 = 0 time = 3480
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=3480.1n

* CHECK dout1_27 Vdout1_27ck173 = 0 time = 3480
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=3480.1n

* CHECK dout1_28 Vdout1_28ck173 = 0 time = 3480
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=3480.1n

* CHECK dout1_29 Vdout1_29ck173 = 1.8 time = 3480
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=3480.1n

* CHECK dout1_30 Vdout1_30ck173 = 1.8 time = 3480
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=3480.1n

* CHECK dout1_31 Vdout1_31ck173 = 0 time = 3480
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=3480.1n

* CHECK dout2_0 Vdout2_0ck173 = 0 time = 3480
.meas tran vdout2_0ck173 FIND v(dout2_0) AT=3480.1n

* CHECK dout2_1 Vdout2_1ck173 = 1.8 time = 3480
.meas tran vdout2_1ck173 FIND v(dout2_1) AT=3480.1n

* CHECK dout2_2 Vdout2_2ck173 = 1.8 time = 3480
.meas tran vdout2_2ck173 FIND v(dout2_2) AT=3480.1n

* CHECK dout2_3 Vdout2_3ck173 = 0 time = 3480
.meas tran vdout2_3ck173 FIND v(dout2_3) AT=3480.1n

* CHECK dout2_4 Vdout2_4ck173 = 0 time = 3480
.meas tran vdout2_4ck173 FIND v(dout2_4) AT=3480.1n

* CHECK dout2_5 Vdout2_5ck173 = 1.8 time = 3480
.meas tran vdout2_5ck173 FIND v(dout2_5) AT=3480.1n

* CHECK dout2_6 Vdout2_6ck173 = 0 time = 3480
.meas tran vdout2_6ck173 FIND v(dout2_6) AT=3480.1n

* CHECK dout2_7 Vdout2_7ck173 = 1.8 time = 3480
.meas tran vdout2_7ck173 FIND v(dout2_7) AT=3480.1n

* CHECK dout2_8 Vdout2_8ck173 = 1.8 time = 3480
.meas tran vdout2_8ck173 FIND v(dout2_8) AT=3480.1n

* CHECK dout2_9 Vdout2_9ck173 = 0 time = 3480
.meas tran vdout2_9ck173 FIND v(dout2_9) AT=3480.1n

* CHECK dout2_10 Vdout2_10ck173 = 1.8 time = 3480
.meas tran vdout2_10ck173 FIND v(dout2_10) AT=3480.1n

* CHECK dout2_11 Vdout2_11ck173 = 1.8 time = 3480
.meas tran vdout2_11ck173 FIND v(dout2_11) AT=3480.1n

* CHECK dout2_12 Vdout2_12ck173 = 1.8 time = 3480
.meas tran vdout2_12ck173 FIND v(dout2_12) AT=3480.1n

* CHECK dout2_13 Vdout2_13ck173 = 0 time = 3480
.meas tran vdout2_13ck173 FIND v(dout2_13) AT=3480.1n

* CHECK dout2_14 Vdout2_14ck173 = 0 time = 3480
.meas tran vdout2_14ck173 FIND v(dout2_14) AT=3480.1n

* CHECK dout2_15 Vdout2_15ck173 = 0 time = 3480
.meas tran vdout2_15ck173 FIND v(dout2_15) AT=3480.1n

* CHECK dout2_16 Vdout2_16ck173 = 1.8 time = 3480
.meas tran vdout2_16ck173 FIND v(dout2_16) AT=3480.1n

* CHECK dout2_17 Vdout2_17ck173 = 1.8 time = 3480
.meas tran vdout2_17ck173 FIND v(dout2_17) AT=3480.1n

* CHECK dout2_18 Vdout2_18ck173 = 0 time = 3480
.meas tran vdout2_18ck173 FIND v(dout2_18) AT=3480.1n

* CHECK dout2_19 Vdout2_19ck173 = 1.8 time = 3480
.meas tran vdout2_19ck173 FIND v(dout2_19) AT=3480.1n

* CHECK dout2_20 Vdout2_20ck173 = 1.8 time = 3480
.meas tran vdout2_20ck173 FIND v(dout2_20) AT=3480.1n

* CHECK dout2_21 Vdout2_21ck173 = 1.8 time = 3480
.meas tran vdout2_21ck173 FIND v(dout2_21) AT=3480.1n

* CHECK dout2_22 Vdout2_22ck173 = 1.8 time = 3480
.meas tran vdout2_22ck173 FIND v(dout2_22) AT=3480.1n

* CHECK dout2_23 Vdout2_23ck173 = 1.8 time = 3480
.meas tran vdout2_23ck173 FIND v(dout2_23) AT=3480.1n

* CHECK dout2_24 Vdout2_24ck173 = 0 time = 3480
.meas tran vdout2_24ck173 FIND v(dout2_24) AT=3480.1n

* CHECK dout2_25 Vdout2_25ck173 = 1.8 time = 3480
.meas tran vdout2_25ck173 FIND v(dout2_25) AT=3480.1n

* CHECK dout2_26 Vdout2_26ck173 = 0 time = 3480
.meas tran vdout2_26ck173 FIND v(dout2_26) AT=3480.1n

* CHECK dout2_27 Vdout2_27ck173 = 1.8 time = 3480
.meas tran vdout2_27ck173 FIND v(dout2_27) AT=3480.1n

* CHECK dout2_28 Vdout2_28ck173 = 1.8 time = 3480
.meas tran vdout2_28ck173 FIND v(dout2_28) AT=3480.1n

* CHECK dout2_29 Vdout2_29ck173 = 1.8 time = 3480
.meas tran vdout2_29ck173 FIND v(dout2_29) AT=3480.1n

* CHECK dout2_30 Vdout2_30ck173 = 0 time = 3480
.meas tran vdout2_30ck173 FIND v(dout2_30) AT=3480.1n

* CHECK dout2_31 Vdout2_31ck173 = 0 time = 3480
.meas tran vdout2_31ck173 FIND v(dout2_31) AT=3480.1n

* CHECK dout1_0 Vdout1_0ck174 = 1.8 time = 3500
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=3500.1n

* CHECK dout1_1 Vdout1_1ck174 = 0 time = 3500
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=3500.1n

* CHECK dout1_2 Vdout1_2ck174 = 1.8 time = 3500
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=3500.1n

* CHECK dout1_3 Vdout1_3ck174 = 0 time = 3500
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=3500.1n

* CHECK dout1_4 Vdout1_4ck174 = 0 time = 3500
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=3500.1n

* CHECK dout1_5 Vdout1_5ck174 = 1.8 time = 3500
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=3500.1n

* CHECK dout1_6 Vdout1_6ck174 = 1.8 time = 3500
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=3500.1n

* CHECK dout1_7 Vdout1_7ck174 = 1.8 time = 3500
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=3500.1n

* CHECK dout1_8 Vdout1_8ck174 = 0 time = 3500
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=3500.1n

* CHECK dout1_9 Vdout1_9ck174 = 0 time = 3500
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=3500.1n

* CHECK dout1_10 Vdout1_10ck174 = 0 time = 3500
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=3500.1n

* CHECK dout1_11 Vdout1_11ck174 = 1.8 time = 3500
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=3500.1n

* CHECK dout1_12 Vdout1_12ck174 = 1.8 time = 3500
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=3500.1n

* CHECK dout1_13 Vdout1_13ck174 = 0 time = 3500
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=3500.1n

* CHECK dout1_14 Vdout1_14ck174 = 1.8 time = 3500
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=3500.1n

* CHECK dout1_15 Vdout1_15ck174 = 0 time = 3500
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=3500.1n

* CHECK dout1_16 Vdout1_16ck174 = 1.8 time = 3500
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=3500.1n

* CHECK dout1_17 Vdout1_17ck174 = 0 time = 3500
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=3500.1n

* CHECK dout1_18 Vdout1_18ck174 = 1.8 time = 3500
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=3500.1n

* CHECK dout1_19 Vdout1_19ck174 = 0 time = 3500
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=3500.1n

* CHECK dout1_20 Vdout1_20ck174 = 0 time = 3500
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=3500.1n

* CHECK dout1_21 Vdout1_21ck174 = 1.8 time = 3500
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=3500.1n

* CHECK dout1_22 Vdout1_22ck174 = 1.8 time = 3500
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=3500.1n

* CHECK dout1_23 Vdout1_23ck174 = 1.8 time = 3500
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=3500.1n

* CHECK dout1_24 Vdout1_24ck174 = 0 time = 3500
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=3500.1n

* CHECK dout1_25 Vdout1_25ck174 = 1.8 time = 3500
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=3500.1n

* CHECK dout1_26 Vdout1_26ck174 = 0 time = 3500
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=3500.1n

* CHECK dout1_27 Vdout1_27ck174 = 1.8 time = 3500
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=3500.1n

* CHECK dout1_28 Vdout1_28ck174 = 1.8 time = 3500
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=3500.1n

* CHECK dout1_29 Vdout1_29ck174 = 1.8 time = 3500
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=3500.1n

* CHECK dout1_30 Vdout1_30ck174 = 1.8 time = 3500
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=3500.1n

* CHECK dout1_31 Vdout1_31ck174 = 1.8 time = 3500
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=3500.1n

* CHECK dout2_0 Vdout2_0ck174 = 1.8 time = 3500
.meas tran vdout2_0ck174 FIND v(dout2_0) AT=3500.1n

* CHECK dout2_1 Vdout2_1ck174 = 0 time = 3500
.meas tran vdout2_1ck174 FIND v(dout2_1) AT=3500.1n

* CHECK dout2_2 Vdout2_2ck174 = 1.8 time = 3500
.meas tran vdout2_2ck174 FIND v(dout2_2) AT=3500.1n

* CHECK dout2_3 Vdout2_3ck174 = 0 time = 3500
.meas tran vdout2_3ck174 FIND v(dout2_3) AT=3500.1n

* CHECK dout2_4 Vdout2_4ck174 = 0 time = 3500
.meas tran vdout2_4ck174 FIND v(dout2_4) AT=3500.1n

* CHECK dout2_5 Vdout2_5ck174 = 1.8 time = 3500
.meas tran vdout2_5ck174 FIND v(dout2_5) AT=3500.1n

* CHECK dout2_6 Vdout2_6ck174 = 1.8 time = 3500
.meas tran vdout2_6ck174 FIND v(dout2_6) AT=3500.1n

* CHECK dout2_7 Vdout2_7ck174 = 1.8 time = 3500
.meas tran vdout2_7ck174 FIND v(dout2_7) AT=3500.1n

* CHECK dout2_8 Vdout2_8ck174 = 0 time = 3500
.meas tran vdout2_8ck174 FIND v(dout2_8) AT=3500.1n

* CHECK dout2_9 Vdout2_9ck174 = 0 time = 3500
.meas tran vdout2_9ck174 FIND v(dout2_9) AT=3500.1n

* CHECK dout2_10 Vdout2_10ck174 = 0 time = 3500
.meas tran vdout2_10ck174 FIND v(dout2_10) AT=3500.1n

* CHECK dout2_11 Vdout2_11ck174 = 1.8 time = 3500
.meas tran vdout2_11ck174 FIND v(dout2_11) AT=3500.1n

* CHECK dout2_12 Vdout2_12ck174 = 1.8 time = 3500
.meas tran vdout2_12ck174 FIND v(dout2_12) AT=3500.1n

* CHECK dout2_13 Vdout2_13ck174 = 0 time = 3500
.meas tran vdout2_13ck174 FIND v(dout2_13) AT=3500.1n

* CHECK dout2_14 Vdout2_14ck174 = 1.8 time = 3500
.meas tran vdout2_14ck174 FIND v(dout2_14) AT=3500.1n

* CHECK dout2_15 Vdout2_15ck174 = 0 time = 3500
.meas tran vdout2_15ck174 FIND v(dout2_15) AT=3500.1n

* CHECK dout2_16 Vdout2_16ck174 = 1.8 time = 3500
.meas tran vdout2_16ck174 FIND v(dout2_16) AT=3500.1n

* CHECK dout2_17 Vdout2_17ck174 = 0 time = 3500
.meas tran vdout2_17ck174 FIND v(dout2_17) AT=3500.1n

* CHECK dout2_18 Vdout2_18ck174 = 1.8 time = 3500
.meas tran vdout2_18ck174 FIND v(dout2_18) AT=3500.1n

* CHECK dout2_19 Vdout2_19ck174 = 0 time = 3500
.meas tran vdout2_19ck174 FIND v(dout2_19) AT=3500.1n

* CHECK dout2_20 Vdout2_20ck174 = 0 time = 3500
.meas tran vdout2_20ck174 FIND v(dout2_20) AT=3500.1n

* CHECK dout2_21 Vdout2_21ck174 = 1.8 time = 3500
.meas tran vdout2_21ck174 FIND v(dout2_21) AT=3500.1n

* CHECK dout2_22 Vdout2_22ck174 = 1.8 time = 3500
.meas tran vdout2_22ck174 FIND v(dout2_22) AT=3500.1n

* CHECK dout2_23 Vdout2_23ck174 = 1.8 time = 3500
.meas tran vdout2_23ck174 FIND v(dout2_23) AT=3500.1n

* CHECK dout2_24 Vdout2_24ck174 = 0 time = 3500
.meas tran vdout2_24ck174 FIND v(dout2_24) AT=3500.1n

* CHECK dout2_25 Vdout2_25ck174 = 1.8 time = 3500
.meas tran vdout2_25ck174 FIND v(dout2_25) AT=3500.1n

* CHECK dout2_26 Vdout2_26ck174 = 0 time = 3500
.meas tran vdout2_26ck174 FIND v(dout2_26) AT=3500.1n

* CHECK dout2_27 Vdout2_27ck174 = 1.8 time = 3500
.meas tran vdout2_27ck174 FIND v(dout2_27) AT=3500.1n

* CHECK dout2_28 Vdout2_28ck174 = 1.8 time = 3500
.meas tran vdout2_28ck174 FIND v(dout2_28) AT=3500.1n

* CHECK dout2_29 Vdout2_29ck174 = 1.8 time = 3500
.meas tran vdout2_29ck174 FIND v(dout2_29) AT=3500.1n

* CHECK dout2_30 Vdout2_30ck174 = 1.8 time = 3500
.meas tran vdout2_30ck174 FIND v(dout2_30) AT=3500.1n

* CHECK dout2_31 Vdout2_31ck174 = 1.8 time = 3500
.meas tran vdout2_31ck174 FIND v(dout2_31) AT=3500.1n

* CHECK dout1_0 Vdout1_0ck175 = 0 time = 3520
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=3520.1n

* CHECK dout1_1 Vdout1_1ck175 = 1.8 time = 3520
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=3520.1n

* CHECK dout1_2 Vdout1_2ck175 = 1.8 time = 3520
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=3520.1n

* CHECK dout1_3 Vdout1_3ck175 = 0 time = 3520
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=3520.1n

* CHECK dout1_4 Vdout1_4ck175 = 0 time = 3520
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=3520.1n

* CHECK dout1_5 Vdout1_5ck175 = 1.8 time = 3520
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=3520.1n

* CHECK dout1_6 Vdout1_6ck175 = 0 time = 3520
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=3520.1n

* CHECK dout1_7 Vdout1_7ck175 = 1.8 time = 3520
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=3520.1n

* CHECK dout1_8 Vdout1_8ck175 = 1.8 time = 3520
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=3520.1n

* CHECK dout1_9 Vdout1_9ck175 = 0 time = 3520
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=3520.1n

* CHECK dout1_10 Vdout1_10ck175 = 1.8 time = 3520
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=3520.1n

* CHECK dout1_11 Vdout1_11ck175 = 1.8 time = 3520
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=3520.1n

* CHECK dout1_12 Vdout1_12ck175 = 1.8 time = 3520
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=3520.1n

* CHECK dout1_13 Vdout1_13ck175 = 0 time = 3520
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=3520.1n

* CHECK dout1_14 Vdout1_14ck175 = 0 time = 3520
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=3520.1n

* CHECK dout1_15 Vdout1_15ck175 = 0 time = 3520
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=3520.1n

* CHECK dout1_16 Vdout1_16ck175 = 1.8 time = 3520
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=3520.1n

* CHECK dout1_17 Vdout1_17ck175 = 1.8 time = 3520
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=3520.1n

* CHECK dout1_18 Vdout1_18ck175 = 0 time = 3520
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=3520.1n

* CHECK dout1_19 Vdout1_19ck175 = 1.8 time = 3520
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=3520.1n

* CHECK dout1_20 Vdout1_20ck175 = 1.8 time = 3520
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=3520.1n

* CHECK dout1_21 Vdout1_21ck175 = 1.8 time = 3520
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=3520.1n

* CHECK dout1_22 Vdout1_22ck175 = 1.8 time = 3520
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=3520.1n

* CHECK dout1_23 Vdout1_23ck175 = 1.8 time = 3520
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=3520.1n

* CHECK dout1_24 Vdout1_24ck175 = 0 time = 3520
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=3520.1n

* CHECK dout1_25 Vdout1_25ck175 = 1.8 time = 3520
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=3520.1n

* CHECK dout1_26 Vdout1_26ck175 = 0 time = 3520
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=3520.1n

* CHECK dout1_27 Vdout1_27ck175 = 1.8 time = 3520
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=3520.1n

* CHECK dout1_28 Vdout1_28ck175 = 1.8 time = 3520
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=3520.1n

* CHECK dout1_29 Vdout1_29ck175 = 1.8 time = 3520
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=3520.1n

* CHECK dout1_30 Vdout1_30ck175 = 0 time = 3520
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=3520.1n

* CHECK dout1_31 Vdout1_31ck175 = 0 time = 3520
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=3520.1n

* CHECK dout2_0 Vdout2_0ck175 = 0 time = 3520
.meas tran vdout2_0ck175 FIND v(dout2_0) AT=3520.1n

* CHECK dout2_1 Vdout2_1ck175 = 1.8 time = 3520
.meas tran vdout2_1ck175 FIND v(dout2_1) AT=3520.1n

* CHECK dout2_2 Vdout2_2ck175 = 1.8 time = 3520
.meas tran vdout2_2ck175 FIND v(dout2_2) AT=3520.1n

* CHECK dout2_3 Vdout2_3ck175 = 0 time = 3520
.meas tran vdout2_3ck175 FIND v(dout2_3) AT=3520.1n

* CHECK dout2_4 Vdout2_4ck175 = 0 time = 3520
.meas tran vdout2_4ck175 FIND v(dout2_4) AT=3520.1n

* CHECK dout2_5 Vdout2_5ck175 = 1.8 time = 3520
.meas tran vdout2_5ck175 FIND v(dout2_5) AT=3520.1n

* CHECK dout2_6 Vdout2_6ck175 = 0 time = 3520
.meas tran vdout2_6ck175 FIND v(dout2_6) AT=3520.1n

* CHECK dout2_7 Vdout2_7ck175 = 1.8 time = 3520
.meas tran vdout2_7ck175 FIND v(dout2_7) AT=3520.1n

* CHECK dout2_8 Vdout2_8ck175 = 1.8 time = 3520
.meas tran vdout2_8ck175 FIND v(dout2_8) AT=3520.1n

* CHECK dout2_9 Vdout2_9ck175 = 0 time = 3520
.meas tran vdout2_9ck175 FIND v(dout2_9) AT=3520.1n

* CHECK dout2_10 Vdout2_10ck175 = 1.8 time = 3520
.meas tran vdout2_10ck175 FIND v(dout2_10) AT=3520.1n

* CHECK dout2_11 Vdout2_11ck175 = 1.8 time = 3520
.meas tran vdout2_11ck175 FIND v(dout2_11) AT=3520.1n

* CHECK dout2_12 Vdout2_12ck175 = 1.8 time = 3520
.meas tran vdout2_12ck175 FIND v(dout2_12) AT=3520.1n

* CHECK dout2_13 Vdout2_13ck175 = 0 time = 3520
.meas tran vdout2_13ck175 FIND v(dout2_13) AT=3520.1n

* CHECK dout2_14 Vdout2_14ck175 = 0 time = 3520
.meas tran vdout2_14ck175 FIND v(dout2_14) AT=3520.1n

* CHECK dout2_15 Vdout2_15ck175 = 0 time = 3520
.meas tran vdout2_15ck175 FIND v(dout2_15) AT=3520.1n

* CHECK dout2_16 Vdout2_16ck175 = 1.8 time = 3520
.meas tran vdout2_16ck175 FIND v(dout2_16) AT=3520.1n

* CHECK dout2_17 Vdout2_17ck175 = 1.8 time = 3520
.meas tran vdout2_17ck175 FIND v(dout2_17) AT=3520.1n

* CHECK dout2_18 Vdout2_18ck175 = 0 time = 3520
.meas tran vdout2_18ck175 FIND v(dout2_18) AT=3520.1n

* CHECK dout2_19 Vdout2_19ck175 = 1.8 time = 3520
.meas tran vdout2_19ck175 FIND v(dout2_19) AT=3520.1n

* CHECK dout2_20 Vdout2_20ck175 = 1.8 time = 3520
.meas tran vdout2_20ck175 FIND v(dout2_20) AT=3520.1n

* CHECK dout2_21 Vdout2_21ck175 = 1.8 time = 3520
.meas tran vdout2_21ck175 FIND v(dout2_21) AT=3520.1n

* CHECK dout2_22 Vdout2_22ck175 = 1.8 time = 3520
.meas tran vdout2_22ck175 FIND v(dout2_22) AT=3520.1n

* CHECK dout2_23 Vdout2_23ck175 = 1.8 time = 3520
.meas tran vdout2_23ck175 FIND v(dout2_23) AT=3520.1n

* CHECK dout2_24 Vdout2_24ck175 = 0 time = 3520
.meas tran vdout2_24ck175 FIND v(dout2_24) AT=3520.1n

* CHECK dout2_25 Vdout2_25ck175 = 1.8 time = 3520
.meas tran vdout2_25ck175 FIND v(dout2_25) AT=3520.1n

* CHECK dout2_26 Vdout2_26ck175 = 0 time = 3520
.meas tran vdout2_26ck175 FIND v(dout2_26) AT=3520.1n

* CHECK dout2_27 Vdout2_27ck175 = 1.8 time = 3520
.meas tran vdout2_27ck175 FIND v(dout2_27) AT=3520.1n

* CHECK dout2_28 Vdout2_28ck175 = 1.8 time = 3520
.meas tran vdout2_28ck175 FIND v(dout2_28) AT=3520.1n

* CHECK dout2_29 Vdout2_29ck175 = 1.8 time = 3520
.meas tran vdout2_29ck175 FIND v(dout2_29) AT=3520.1n

* CHECK dout2_30 Vdout2_30ck175 = 0 time = 3520
.meas tran vdout2_30ck175 FIND v(dout2_30) AT=3520.1n

* CHECK dout2_31 Vdout2_31ck175 = 0 time = 3520
.meas tran vdout2_31ck175 FIND v(dout2_31) AT=3520.1n

* CHECK dout2_0 Vdout2_0ck176 = 0 time = 3540
.meas tran vdout2_0ck176 FIND v(dout2_0) AT=3540.1n

* CHECK dout2_1 Vdout2_1ck176 = 1.8 time = 3540
.meas tran vdout2_1ck176 FIND v(dout2_1) AT=3540.1n

* CHECK dout2_2 Vdout2_2ck176 = 0 time = 3540
.meas tran vdout2_2ck176 FIND v(dout2_2) AT=3540.1n

* CHECK dout2_3 Vdout2_3ck176 = 1.8 time = 3540
.meas tran vdout2_3ck176 FIND v(dout2_3) AT=3540.1n

* CHECK dout2_4 Vdout2_4ck176 = 0 time = 3540
.meas tran vdout2_4ck176 FIND v(dout2_4) AT=3540.1n

* CHECK dout2_5 Vdout2_5ck176 = 0 time = 3540
.meas tran vdout2_5ck176 FIND v(dout2_5) AT=3540.1n

* CHECK dout2_6 Vdout2_6ck176 = 0 time = 3540
.meas tran vdout2_6ck176 FIND v(dout2_6) AT=3540.1n

* CHECK dout2_7 Vdout2_7ck176 = 1.8 time = 3540
.meas tran vdout2_7ck176 FIND v(dout2_7) AT=3540.1n

* CHECK dout2_8 Vdout2_8ck176 = 1.8 time = 3540
.meas tran vdout2_8ck176 FIND v(dout2_8) AT=3540.1n

* CHECK dout2_9 Vdout2_9ck176 = 1.8 time = 3540
.meas tran vdout2_9ck176 FIND v(dout2_9) AT=3540.1n

* CHECK dout2_10 Vdout2_10ck176 = 1.8 time = 3540
.meas tran vdout2_10ck176 FIND v(dout2_10) AT=3540.1n

* CHECK dout2_11 Vdout2_11ck176 = 0 time = 3540
.meas tran vdout2_11ck176 FIND v(dout2_11) AT=3540.1n

* CHECK dout2_12 Vdout2_12ck176 = 0 time = 3540
.meas tran vdout2_12ck176 FIND v(dout2_12) AT=3540.1n

* CHECK dout2_13 Vdout2_13ck176 = 1.8 time = 3540
.meas tran vdout2_13ck176 FIND v(dout2_13) AT=3540.1n

* CHECK dout2_14 Vdout2_14ck176 = 0 time = 3540
.meas tran vdout2_14ck176 FIND v(dout2_14) AT=3540.1n

* CHECK dout2_15 Vdout2_15ck176 = 1.8 time = 3540
.meas tran vdout2_15ck176 FIND v(dout2_15) AT=3540.1n

* CHECK dout2_16 Vdout2_16ck176 = 0 time = 3540
.meas tran vdout2_16ck176 FIND v(dout2_16) AT=3540.1n

* CHECK dout2_17 Vdout2_17ck176 = 0 time = 3540
.meas tran vdout2_17ck176 FIND v(dout2_17) AT=3540.1n

* CHECK dout2_18 Vdout2_18ck176 = 0 time = 3540
.meas tran vdout2_18ck176 FIND v(dout2_18) AT=3540.1n

* CHECK dout2_19 Vdout2_19ck176 = 1.8 time = 3540
.meas tran vdout2_19ck176 FIND v(dout2_19) AT=3540.1n

* CHECK dout2_20 Vdout2_20ck176 = 1.8 time = 3540
.meas tran vdout2_20ck176 FIND v(dout2_20) AT=3540.1n

* CHECK dout2_21 Vdout2_21ck176 = 1.8 time = 3540
.meas tran vdout2_21ck176 FIND v(dout2_21) AT=3540.1n

* CHECK dout2_22 Vdout2_22ck176 = 1.8 time = 3540
.meas tran vdout2_22ck176 FIND v(dout2_22) AT=3540.1n

* CHECK dout2_23 Vdout2_23ck176 = 0 time = 3540
.meas tran vdout2_23ck176 FIND v(dout2_23) AT=3540.1n

* CHECK dout2_24 Vdout2_24ck176 = 1.8 time = 3540
.meas tran vdout2_24ck176 FIND v(dout2_24) AT=3540.1n

* CHECK dout2_25 Vdout2_25ck176 = 0 time = 3540
.meas tran vdout2_25ck176 FIND v(dout2_25) AT=3540.1n

* CHECK dout2_26 Vdout2_26ck176 = 0 time = 3540
.meas tran vdout2_26ck176 FIND v(dout2_26) AT=3540.1n

* CHECK dout2_27 Vdout2_27ck176 = 0 time = 3540
.meas tran vdout2_27ck176 FIND v(dout2_27) AT=3540.1n

* CHECK dout2_28 Vdout2_28ck176 = 0 time = 3540
.meas tran vdout2_28ck176 FIND v(dout2_28) AT=3540.1n

* CHECK dout2_29 Vdout2_29ck176 = 1.8 time = 3540
.meas tran vdout2_29ck176 FIND v(dout2_29) AT=3540.1n

* CHECK dout2_30 Vdout2_30ck176 = 1.8 time = 3540
.meas tran vdout2_30ck176 FIND v(dout2_30) AT=3540.1n

* CHECK dout2_31 Vdout2_31ck176 = 0 time = 3540
.meas tran vdout2_31ck176 FIND v(dout2_31) AT=3540.1n

* CHECK dout1_0 Vdout1_0ck177 = 0 time = 3560
.meas tran vdout1_0ck177 FIND v(dout1_0) AT=3560.1n

* CHECK dout1_1 Vdout1_1ck177 = 1.8 time = 3560
.meas tran vdout1_1ck177 FIND v(dout1_1) AT=3560.1n

* CHECK dout1_2 Vdout1_2ck177 = 1.8 time = 3560
.meas tran vdout1_2ck177 FIND v(dout1_2) AT=3560.1n

* CHECK dout1_3 Vdout1_3ck177 = 0 time = 3560
.meas tran vdout1_3ck177 FIND v(dout1_3) AT=3560.1n

* CHECK dout1_4 Vdout1_4ck177 = 0 time = 3560
.meas tran vdout1_4ck177 FIND v(dout1_4) AT=3560.1n

* CHECK dout1_5 Vdout1_5ck177 = 1.8 time = 3560
.meas tran vdout1_5ck177 FIND v(dout1_5) AT=3560.1n

* CHECK dout1_6 Vdout1_6ck177 = 0 time = 3560
.meas tran vdout1_6ck177 FIND v(dout1_6) AT=3560.1n

* CHECK dout1_7 Vdout1_7ck177 = 1.8 time = 3560
.meas tran vdout1_7ck177 FIND v(dout1_7) AT=3560.1n

* CHECK dout1_8 Vdout1_8ck177 = 1.8 time = 3560
.meas tran vdout1_8ck177 FIND v(dout1_8) AT=3560.1n

* CHECK dout1_9 Vdout1_9ck177 = 0 time = 3560
.meas tran vdout1_9ck177 FIND v(dout1_9) AT=3560.1n

* CHECK dout1_10 Vdout1_10ck177 = 1.8 time = 3560
.meas tran vdout1_10ck177 FIND v(dout1_10) AT=3560.1n

* CHECK dout1_11 Vdout1_11ck177 = 1.8 time = 3560
.meas tran vdout1_11ck177 FIND v(dout1_11) AT=3560.1n

* CHECK dout1_12 Vdout1_12ck177 = 1.8 time = 3560
.meas tran vdout1_12ck177 FIND v(dout1_12) AT=3560.1n

* CHECK dout1_13 Vdout1_13ck177 = 0 time = 3560
.meas tran vdout1_13ck177 FIND v(dout1_13) AT=3560.1n

* CHECK dout1_14 Vdout1_14ck177 = 0 time = 3560
.meas tran vdout1_14ck177 FIND v(dout1_14) AT=3560.1n

* CHECK dout1_15 Vdout1_15ck177 = 0 time = 3560
.meas tran vdout1_15ck177 FIND v(dout1_15) AT=3560.1n

* CHECK dout1_16 Vdout1_16ck177 = 1.8 time = 3560
.meas tran vdout1_16ck177 FIND v(dout1_16) AT=3560.1n

* CHECK dout1_17 Vdout1_17ck177 = 1.8 time = 3560
.meas tran vdout1_17ck177 FIND v(dout1_17) AT=3560.1n

* CHECK dout1_18 Vdout1_18ck177 = 0 time = 3560
.meas tran vdout1_18ck177 FIND v(dout1_18) AT=3560.1n

* CHECK dout1_19 Vdout1_19ck177 = 1.8 time = 3560
.meas tran vdout1_19ck177 FIND v(dout1_19) AT=3560.1n

* CHECK dout1_20 Vdout1_20ck177 = 1.8 time = 3560
.meas tran vdout1_20ck177 FIND v(dout1_20) AT=3560.1n

* CHECK dout1_21 Vdout1_21ck177 = 1.8 time = 3560
.meas tran vdout1_21ck177 FIND v(dout1_21) AT=3560.1n

* CHECK dout1_22 Vdout1_22ck177 = 1.8 time = 3560
.meas tran vdout1_22ck177 FIND v(dout1_22) AT=3560.1n

* CHECK dout1_23 Vdout1_23ck177 = 1.8 time = 3560
.meas tran vdout1_23ck177 FIND v(dout1_23) AT=3560.1n

* CHECK dout1_24 Vdout1_24ck177 = 0 time = 3560
.meas tran vdout1_24ck177 FIND v(dout1_24) AT=3560.1n

* CHECK dout1_25 Vdout1_25ck177 = 1.8 time = 3560
.meas tran vdout1_25ck177 FIND v(dout1_25) AT=3560.1n

* CHECK dout1_26 Vdout1_26ck177 = 0 time = 3560
.meas tran vdout1_26ck177 FIND v(dout1_26) AT=3560.1n

* CHECK dout1_27 Vdout1_27ck177 = 1.8 time = 3560
.meas tran vdout1_27ck177 FIND v(dout1_27) AT=3560.1n

* CHECK dout1_28 Vdout1_28ck177 = 1.8 time = 3560
.meas tran vdout1_28ck177 FIND v(dout1_28) AT=3560.1n

* CHECK dout1_29 Vdout1_29ck177 = 1.8 time = 3560
.meas tran vdout1_29ck177 FIND v(dout1_29) AT=3560.1n

* CHECK dout1_30 Vdout1_30ck177 = 0 time = 3560
.meas tran vdout1_30ck177 FIND v(dout1_30) AT=3560.1n

* CHECK dout1_31 Vdout1_31ck177 = 0 time = 3560
.meas tran vdout1_31ck177 FIND v(dout1_31) AT=3560.1n

* CHECK dout2_0 Vdout2_0ck177 = 0 time = 3560
.meas tran vdout2_0ck177 FIND v(dout2_0) AT=3560.1n

* CHECK dout2_1 Vdout2_1ck177 = 1.8 time = 3560
.meas tran vdout2_1ck177 FIND v(dout2_1) AT=3560.1n

* CHECK dout2_2 Vdout2_2ck177 = 1.8 time = 3560
.meas tran vdout2_2ck177 FIND v(dout2_2) AT=3560.1n

* CHECK dout2_3 Vdout2_3ck177 = 0 time = 3560
.meas tran vdout2_3ck177 FIND v(dout2_3) AT=3560.1n

* CHECK dout2_4 Vdout2_4ck177 = 0 time = 3560
.meas tran vdout2_4ck177 FIND v(dout2_4) AT=3560.1n

* CHECK dout2_5 Vdout2_5ck177 = 1.8 time = 3560
.meas tran vdout2_5ck177 FIND v(dout2_5) AT=3560.1n

* CHECK dout2_6 Vdout2_6ck177 = 0 time = 3560
.meas tran vdout2_6ck177 FIND v(dout2_6) AT=3560.1n

* CHECK dout2_7 Vdout2_7ck177 = 1.8 time = 3560
.meas tran vdout2_7ck177 FIND v(dout2_7) AT=3560.1n

* CHECK dout2_8 Vdout2_8ck177 = 1.8 time = 3560
.meas tran vdout2_8ck177 FIND v(dout2_8) AT=3560.1n

* CHECK dout2_9 Vdout2_9ck177 = 0 time = 3560
.meas tran vdout2_9ck177 FIND v(dout2_9) AT=3560.1n

* CHECK dout2_10 Vdout2_10ck177 = 1.8 time = 3560
.meas tran vdout2_10ck177 FIND v(dout2_10) AT=3560.1n

* CHECK dout2_11 Vdout2_11ck177 = 1.8 time = 3560
.meas tran vdout2_11ck177 FIND v(dout2_11) AT=3560.1n

* CHECK dout2_12 Vdout2_12ck177 = 1.8 time = 3560
.meas tran vdout2_12ck177 FIND v(dout2_12) AT=3560.1n

* CHECK dout2_13 Vdout2_13ck177 = 0 time = 3560
.meas tran vdout2_13ck177 FIND v(dout2_13) AT=3560.1n

* CHECK dout2_14 Vdout2_14ck177 = 0 time = 3560
.meas tran vdout2_14ck177 FIND v(dout2_14) AT=3560.1n

* CHECK dout2_15 Vdout2_15ck177 = 0 time = 3560
.meas tran vdout2_15ck177 FIND v(dout2_15) AT=3560.1n

* CHECK dout2_16 Vdout2_16ck177 = 1.8 time = 3560
.meas tran vdout2_16ck177 FIND v(dout2_16) AT=3560.1n

* CHECK dout2_17 Vdout2_17ck177 = 1.8 time = 3560
.meas tran vdout2_17ck177 FIND v(dout2_17) AT=3560.1n

* CHECK dout2_18 Vdout2_18ck177 = 0 time = 3560
.meas tran vdout2_18ck177 FIND v(dout2_18) AT=3560.1n

* CHECK dout2_19 Vdout2_19ck177 = 1.8 time = 3560
.meas tran vdout2_19ck177 FIND v(dout2_19) AT=3560.1n

* CHECK dout2_20 Vdout2_20ck177 = 1.8 time = 3560
.meas tran vdout2_20ck177 FIND v(dout2_20) AT=3560.1n

* CHECK dout2_21 Vdout2_21ck177 = 1.8 time = 3560
.meas tran vdout2_21ck177 FIND v(dout2_21) AT=3560.1n

* CHECK dout2_22 Vdout2_22ck177 = 1.8 time = 3560
.meas tran vdout2_22ck177 FIND v(dout2_22) AT=3560.1n

* CHECK dout2_23 Vdout2_23ck177 = 1.8 time = 3560
.meas tran vdout2_23ck177 FIND v(dout2_23) AT=3560.1n

* CHECK dout2_24 Vdout2_24ck177 = 0 time = 3560
.meas tran vdout2_24ck177 FIND v(dout2_24) AT=3560.1n

* CHECK dout2_25 Vdout2_25ck177 = 1.8 time = 3560
.meas tran vdout2_25ck177 FIND v(dout2_25) AT=3560.1n

* CHECK dout2_26 Vdout2_26ck177 = 0 time = 3560
.meas tran vdout2_26ck177 FIND v(dout2_26) AT=3560.1n

* CHECK dout2_27 Vdout2_27ck177 = 1.8 time = 3560
.meas tran vdout2_27ck177 FIND v(dout2_27) AT=3560.1n

* CHECK dout2_28 Vdout2_28ck177 = 1.8 time = 3560
.meas tran vdout2_28ck177 FIND v(dout2_28) AT=3560.1n

* CHECK dout2_29 Vdout2_29ck177 = 1.8 time = 3560
.meas tran vdout2_29ck177 FIND v(dout2_29) AT=3560.1n

* CHECK dout2_30 Vdout2_30ck177 = 0 time = 3560
.meas tran vdout2_30ck177 FIND v(dout2_30) AT=3560.1n

* CHECK dout2_31 Vdout2_31ck177 = 0 time = 3560
.meas tran vdout2_31ck177 FIND v(dout2_31) AT=3560.1n

* CHECK dout1_0 Vdout1_0ck178 = 0 time = 3580
.meas tran vdout1_0ck178 FIND v(dout1_0) AT=3580.1n

* CHECK dout1_1 Vdout1_1ck178 = 1.8 time = 3580
.meas tran vdout1_1ck178 FIND v(dout1_1) AT=3580.1n

* CHECK dout1_2 Vdout1_2ck178 = 0 time = 3580
.meas tran vdout1_2ck178 FIND v(dout1_2) AT=3580.1n

* CHECK dout1_3 Vdout1_3ck178 = 1.8 time = 3580
.meas tran vdout1_3ck178 FIND v(dout1_3) AT=3580.1n

* CHECK dout1_4 Vdout1_4ck178 = 1.8 time = 3580
.meas tran vdout1_4ck178 FIND v(dout1_4) AT=3580.1n

* CHECK dout1_5 Vdout1_5ck178 = 1.8 time = 3580
.meas tran vdout1_5ck178 FIND v(dout1_5) AT=3580.1n

* CHECK dout1_6 Vdout1_6ck178 = 1.8 time = 3580
.meas tran vdout1_6ck178 FIND v(dout1_6) AT=3580.1n

* CHECK dout1_7 Vdout1_7ck178 = 0 time = 3580
.meas tran vdout1_7ck178 FIND v(dout1_7) AT=3580.1n

* CHECK dout1_8 Vdout1_8ck178 = 1.8 time = 3580
.meas tran vdout1_8ck178 FIND v(dout1_8) AT=3580.1n

* CHECK dout1_9 Vdout1_9ck178 = 0 time = 3580
.meas tran vdout1_9ck178 FIND v(dout1_9) AT=3580.1n

* CHECK dout1_10 Vdout1_10ck178 = 1.8 time = 3580
.meas tran vdout1_10ck178 FIND v(dout1_10) AT=3580.1n

* CHECK dout1_11 Vdout1_11ck178 = 0 time = 3580
.meas tran vdout1_11ck178 FIND v(dout1_11) AT=3580.1n

* CHECK dout1_12 Vdout1_12ck178 = 0 time = 3580
.meas tran vdout1_12ck178 FIND v(dout1_12) AT=3580.1n

* CHECK dout1_13 Vdout1_13ck178 = 1.8 time = 3580
.meas tran vdout1_13ck178 FIND v(dout1_13) AT=3580.1n

* CHECK dout1_14 Vdout1_14ck178 = 1.8 time = 3580
.meas tran vdout1_14ck178 FIND v(dout1_14) AT=3580.1n

* CHECK dout1_15 Vdout1_15ck178 = 0 time = 3580
.meas tran vdout1_15ck178 FIND v(dout1_15) AT=3580.1n

* CHECK dout1_16 Vdout1_16ck178 = 1.8 time = 3580
.meas tran vdout1_16ck178 FIND v(dout1_16) AT=3580.1n

* CHECK dout1_17 Vdout1_17ck178 = 1.8 time = 3580
.meas tran vdout1_17ck178 FIND v(dout1_17) AT=3580.1n

* CHECK dout1_18 Vdout1_18ck178 = 0 time = 3580
.meas tran vdout1_18ck178 FIND v(dout1_18) AT=3580.1n

* CHECK dout1_19 Vdout1_19ck178 = 1.8 time = 3580
.meas tran vdout1_19ck178 FIND v(dout1_19) AT=3580.1n

* CHECK dout1_20 Vdout1_20ck178 = 1.8 time = 3580
.meas tran vdout1_20ck178 FIND v(dout1_20) AT=3580.1n

* CHECK dout1_21 Vdout1_21ck178 = 1.8 time = 3580
.meas tran vdout1_21ck178 FIND v(dout1_21) AT=3580.1n

* CHECK dout1_22 Vdout1_22ck178 = 1.8 time = 3580
.meas tran vdout1_22ck178 FIND v(dout1_22) AT=3580.1n

* CHECK dout1_23 Vdout1_23ck178 = 1.8 time = 3580
.meas tran vdout1_23ck178 FIND v(dout1_23) AT=3580.1n

* CHECK dout1_24 Vdout1_24ck178 = 0 time = 3580
.meas tran vdout1_24ck178 FIND v(dout1_24) AT=3580.1n

* CHECK dout1_25 Vdout1_25ck178 = 1.8 time = 3580
.meas tran vdout1_25ck178 FIND v(dout1_25) AT=3580.1n

* CHECK dout1_26 Vdout1_26ck178 = 1.8 time = 3580
.meas tran vdout1_26ck178 FIND v(dout1_26) AT=3580.1n

* CHECK dout1_27 Vdout1_27ck178 = 1.8 time = 3580
.meas tran vdout1_27ck178 FIND v(dout1_27) AT=3580.1n

* CHECK dout1_28 Vdout1_28ck178 = 1.8 time = 3580
.meas tran vdout1_28ck178 FIND v(dout1_28) AT=3580.1n

* CHECK dout1_29 Vdout1_29ck178 = 0 time = 3580
.meas tran vdout1_29ck178 FIND v(dout1_29) AT=3580.1n

* CHECK dout1_30 Vdout1_30ck178 = 1.8 time = 3580
.meas tran vdout1_30ck178 FIND v(dout1_30) AT=3580.1n

* CHECK dout1_31 Vdout1_31ck178 = 0 time = 3580
.meas tran vdout1_31ck178 FIND v(dout1_31) AT=3580.1n

* CHECK dout1_0 Vdout1_0ck179 = 0 time = 3600
.meas tran vdout1_0ck179 FIND v(dout1_0) AT=3600.1n

* CHECK dout1_1 Vdout1_1ck179 = 1.8 time = 3600
.meas tran vdout1_1ck179 FIND v(dout1_1) AT=3600.1n

* CHECK dout1_2 Vdout1_2ck179 = 0 time = 3600
.meas tran vdout1_2ck179 FIND v(dout1_2) AT=3600.1n

* CHECK dout1_3 Vdout1_3ck179 = 1.8 time = 3600
.meas tran vdout1_3ck179 FIND v(dout1_3) AT=3600.1n

* CHECK dout1_4 Vdout1_4ck179 = 0 time = 3600
.meas tran vdout1_4ck179 FIND v(dout1_4) AT=3600.1n

* CHECK dout1_5 Vdout1_5ck179 = 0 time = 3600
.meas tran vdout1_5ck179 FIND v(dout1_5) AT=3600.1n

* CHECK dout1_6 Vdout1_6ck179 = 0 time = 3600
.meas tran vdout1_6ck179 FIND v(dout1_6) AT=3600.1n

* CHECK dout1_7 Vdout1_7ck179 = 1.8 time = 3600
.meas tran vdout1_7ck179 FIND v(dout1_7) AT=3600.1n

* CHECK dout1_8 Vdout1_8ck179 = 1.8 time = 3600
.meas tran vdout1_8ck179 FIND v(dout1_8) AT=3600.1n

* CHECK dout1_9 Vdout1_9ck179 = 1.8 time = 3600
.meas tran vdout1_9ck179 FIND v(dout1_9) AT=3600.1n

* CHECK dout1_10 Vdout1_10ck179 = 1.8 time = 3600
.meas tran vdout1_10ck179 FIND v(dout1_10) AT=3600.1n

* CHECK dout1_11 Vdout1_11ck179 = 0 time = 3600
.meas tran vdout1_11ck179 FIND v(dout1_11) AT=3600.1n

* CHECK dout1_12 Vdout1_12ck179 = 0 time = 3600
.meas tran vdout1_12ck179 FIND v(dout1_12) AT=3600.1n

* CHECK dout1_13 Vdout1_13ck179 = 1.8 time = 3600
.meas tran vdout1_13ck179 FIND v(dout1_13) AT=3600.1n

* CHECK dout1_14 Vdout1_14ck179 = 0 time = 3600
.meas tran vdout1_14ck179 FIND v(dout1_14) AT=3600.1n

* CHECK dout1_15 Vdout1_15ck179 = 1.8 time = 3600
.meas tran vdout1_15ck179 FIND v(dout1_15) AT=3600.1n

* CHECK dout1_16 Vdout1_16ck179 = 0 time = 3600
.meas tran vdout1_16ck179 FIND v(dout1_16) AT=3600.1n

* CHECK dout1_17 Vdout1_17ck179 = 0 time = 3600
.meas tran vdout1_17ck179 FIND v(dout1_17) AT=3600.1n

* CHECK dout1_18 Vdout1_18ck179 = 0 time = 3600
.meas tran vdout1_18ck179 FIND v(dout1_18) AT=3600.1n

* CHECK dout1_19 Vdout1_19ck179 = 1.8 time = 3600
.meas tran vdout1_19ck179 FIND v(dout1_19) AT=3600.1n

* CHECK dout1_20 Vdout1_20ck179 = 1.8 time = 3600
.meas tran vdout1_20ck179 FIND v(dout1_20) AT=3600.1n

* CHECK dout1_21 Vdout1_21ck179 = 1.8 time = 3600
.meas tran vdout1_21ck179 FIND v(dout1_21) AT=3600.1n

* CHECK dout1_22 Vdout1_22ck179 = 1.8 time = 3600
.meas tran vdout1_22ck179 FIND v(dout1_22) AT=3600.1n

* CHECK dout1_23 Vdout1_23ck179 = 0 time = 3600
.meas tran vdout1_23ck179 FIND v(dout1_23) AT=3600.1n

* CHECK dout1_24 Vdout1_24ck179 = 1.8 time = 3600
.meas tran vdout1_24ck179 FIND v(dout1_24) AT=3600.1n

* CHECK dout1_25 Vdout1_25ck179 = 0 time = 3600
.meas tran vdout1_25ck179 FIND v(dout1_25) AT=3600.1n

* CHECK dout1_26 Vdout1_26ck179 = 0 time = 3600
.meas tran vdout1_26ck179 FIND v(dout1_26) AT=3600.1n

* CHECK dout1_27 Vdout1_27ck179 = 0 time = 3600
.meas tran vdout1_27ck179 FIND v(dout1_27) AT=3600.1n

* CHECK dout1_28 Vdout1_28ck179 = 0 time = 3600
.meas tran vdout1_28ck179 FIND v(dout1_28) AT=3600.1n

* CHECK dout1_29 Vdout1_29ck179 = 1.8 time = 3600
.meas tran vdout1_29ck179 FIND v(dout1_29) AT=3600.1n

* CHECK dout1_30 Vdout1_30ck179 = 1.8 time = 3600
.meas tran vdout1_30ck179 FIND v(dout1_30) AT=3600.1n

* CHECK dout1_31 Vdout1_31ck179 = 0 time = 3600
.meas tran vdout1_31ck179 FIND v(dout1_31) AT=3600.1n

* CHECK dout2_0 Vdout2_0ck179 = 0 time = 3600
.meas tran vdout2_0ck179 FIND v(dout2_0) AT=3600.1n

* CHECK dout2_1 Vdout2_1ck179 = 1.8 time = 3600
.meas tran vdout2_1ck179 FIND v(dout2_1) AT=3600.1n

* CHECK dout2_2 Vdout2_2ck179 = 0 time = 3600
.meas tran vdout2_2ck179 FIND v(dout2_2) AT=3600.1n

* CHECK dout2_3 Vdout2_3ck179 = 1.8 time = 3600
.meas tran vdout2_3ck179 FIND v(dout2_3) AT=3600.1n

* CHECK dout2_4 Vdout2_4ck179 = 0 time = 3600
.meas tran vdout2_4ck179 FIND v(dout2_4) AT=3600.1n

* CHECK dout2_5 Vdout2_5ck179 = 0 time = 3600
.meas tran vdout2_5ck179 FIND v(dout2_5) AT=3600.1n

* CHECK dout2_6 Vdout2_6ck179 = 0 time = 3600
.meas tran vdout2_6ck179 FIND v(dout2_6) AT=3600.1n

* CHECK dout2_7 Vdout2_7ck179 = 1.8 time = 3600
.meas tran vdout2_7ck179 FIND v(dout2_7) AT=3600.1n

* CHECK dout2_8 Vdout2_8ck179 = 1.8 time = 3600
.meas tran vdout2_8ck179 FIND v(dout2_8) AT=3600.1n

* CHECK dout2_9 Vdout2_9ck179 = 1.8 time = 3600
.meas tran vdout2_9ck179 FIND v(dout2_9) AT=3600.1n

* CHECK dout2_10 Vdout2_10ck179 = 1.8 time = 3600
.meas tran vdout2_10ck179 FIND v(dout2_10) AT=3600.1n

* CHECK dout2_11 Vdout2_11ck179 = 0 time = 3600
.meas tran vdout2_11ck179 FIND v(dout2_11) AT=3600.1n

* CHECK dout2_12 Vdout2_12ck179 = 0 time = 3600
.meas tran vdout2_12ck179 FIND v(dout2_12) AT=3600.1n

* CHECK dout2_13 Vdout2_13ck179 = 1.8 time = 3600
.meas tran vdout2_13ck179 FIND v(dout2_13) AT=3600.1n

* CHECK dout2_14 Vdout2_14ck179 = 0 time = 3600
.meas tran vdout2_14ck179 FIND v(dout2_14) AT=3600.1n

* CHECK dout2_15 Vdout2_15ck179 = 1.8 time = 3600
.meas tran vdout2_15ck179 FIND v(dout2_15) AT=3600.1n

* CHECK dout2_16 Vdout2_16ck179 = 0 time = 3600
.meas tran vdout2_16ck179 FIND v(dout2_16) AT=3600.1n

* CHECK dout2_17 Vdout2_17ck179 = 0 time = 3600
.meas tran vdout2_17ck179 FIND v(dout2_17) AT=3600.1n

* CHECK dout2_18 Vdout2_18ck179 = 0 time = 3600
.meas tran vdout2_18ck179 FIND v(dout2_18) AT=3600.1n

* CHECK dout2_19 Vdout2_19ck179 = 1.8 time = 3600
.meas tran vdout2_19ck179 FIND v(dout2_19) AT=3600.1n

* CHECK dout2_20 Vdout2_20ck179 = 1.8 time = 3600
.meas tran vdout2_20ck179 FIND v(dout2_20) AT=3600.1n

* CHECK dout2_21 Vdout2_21ck179 = 1.8 time = 3600
.meas tran vdout2_21ck179 FIND v(dout2_21) AT=3600.1n

* CHECK dout2_22 Vdout2_22ck179 = 1.8 time = 3600
.meas tran vdout2_22ck179 FIND v(dout2_22) AT=3600.1n

* CHECK dout2_23 Vdout2_23ck179 = 0 time = 3600
.meas tran vdout2_23ck179 FIND v(dout2_23) AT=3600.1n

* CHECK dout2_24 Vdout2_24ck179 = 1.8 time = 3600
.meas tran vdout2_24ck179 FIND v(dout2_24) AT=3600.1n

* CHECK dout2_25 Vdout2_25ck179 = 0 time = 3600
.meas tran vdout2_25ck179 FIND v(dout2_25) AT=3600.1n

* CHECK dout2_26 Vdout2_26ck179 = 0 time = 3600
.meas tran vdout2_26ck179 FIND v(dout2_26) AT=3600.1n

* CHECK dout2_27 Vdout2_27ck179 = 0 time = 3600
.meas tran vdout2_27ck179 FIND v(dout2_27) AT=3600.1n

* CHECK dout2_28 Vdout2_28ck179 = 0 time = 3600
.meas tran vdout2_28ck179 FIND v(dout2_28) AT=3600.1n

* CHECK dout2_29 Vdout2_29ck179 = 1.8 time = 3600
.meas tran vdout2_29ck179 FIND v(dout2_29) AT=3600.1n

* CHECK dout2_30 Vdout2_30ck179 = 1.8 time = 3600
.meas tran vdout2_30ck179 FIND v(dout2_30) AT=3600.1n

* CHECK dout2_31 Vdout2_31ck179 = 0 time = 3600
.meas tran vdout2_31ck179 FIND v(dout2_31) AT=3600.1n

* CHECK dout1_0 Vdout1_0ck181 = 0 time = 3640
.meas tran vdout1_0ck181 FIND v(dout1_0) AT=3640.1n

* CHECK dout1_1 Vdout1_1ck181 = 1.8 time = 3640
.meas tran vdout1_1ck181 FIND v(dout1_1) AT=3640.1n

* CHECK dout1_2 Vdout1_2ck181 = 0 time = 3640
.meas tran vdout1_2ck181 FIND v(dout1_2) AT=3640.1n

* CHECK dout1_3 Vdout1_3ck181 = 1.8 time = 3640
.meas tran vdout1_3ck181 FIND v(dout1_3) AT=3640.1n

* CHECK dout1_4 Vdout1_4ck181 = 0 time = 3640
.meas tran vdout1_4ck181 FIND v(dout1_4) AT=3640.1n

* CHECK dout1_5 Vdout1_5ck181 = 0 time = 3640
.meas tran vdout1_5ck181 FIND v(dout1_5) AT=3640.1n

* CHECK dout1_6 Vdout1_6ck181 = 0 time = 3640
.meas tran vdout1_6ck181 FIND v(dout1_6) AT=3640.1n

* CHECK dout1_7 Vdout1_7ck181 = 1.8 time = 3640
.meas tran vdout1_7ck181 FIND v(dout1_7) AT=3640.1n

* CHECK dout1_8 Vdout1_8ck181 = 1.8 time = 3640
.meas tran vdout1_8ck181 FIND v(dout1_8) AT=3640.1n

* CHECK dout1_9 Vdout1_9ck181 = 1.8 time = 3640
.meas tran vdout1_9ck181 FIND v(dout1_9) AT=3640.1n

* CHECK dout1_10 Vdout1_10ck181 = 1.8 time = 3640
.meas tran vdout1_10ck181 FIND v(dout1_10) AT=3640.1n

* CHECK dout1_11 Vdout1_11ck181 = 0 time = 3640
.meas tran vdout1_11ck181 FIND v(dout1_11) AT=3640.1n

* CHECK dout1_12 Vdout1_12ck181 = 0 time = 3640
.meas tran vdout1_12ck181 FIND v(dout1_12) AT=3640.1n

* CHECK dout1_13 Vdout1_13ck181 = 1.8 time = 3640
.meas tran vdout1_13ck181 FIND v(dout1_13) AT=3640.1n

* CHECK dout1_14 Vdout1_14ck181 = 0 time = 3640
.meas tran vdout1_14ck181 FIND v(dout1_14) AT=3640.1n

* CHECK dout1_15 Vdout1_15ck181 = 1.8 time = 3640
.meas tran vdout1_15ck181 FIND v(dout1_15) AT=3640.1n

* CHECK dout1_16 Vdout1_16ck181 = 0 time = 3640
.meas tran vdout1_16ck181 FIND v(dout1_16) AT=3640.1n

* CHECK dout1_17 Vdout1_17ck181 = 0 time = 3640
.meas tran vdout1_17ck181 FIND v(dout1_17) AT=3640.1n

* CHECK dout1_18 Vdout1_18ck181 = 0 time = 3640
.meas tran vdout1_18ck181 FIND v(dout1_18) AT=3640.1n

* CHECK dout1_19 Vdout1_19ck181 = 1.8 time = 3640
.meas tran vdout1_19ck181 FIND v(dout1_19) AT=3640.1n

* CHECK dout1_20 Vdout1_20ck181 = 1.8 time = 3640
.meas tran vdout1_20ck181 FIND v(dout1_20) AT=3640.1n

* CHECK dout1_21 Vdout1_21ck181 = 1.8 time = 3640
.meas tran vdout1_21ck181 FIND v(dout1_21) AT=3640.1n

* CHECK dout1_22 Vdout1_22ck181 = 1.8 time = 3640
.meas tran vdout1_22ck181 FIND v(dout1_22) AT=3640.1n

* CHECK dout1_23 Vdout1_23ck181 = 0 time = 3640
.meas tran vdout1_23ck181 FIND v(dout1_23) AT=3640.1n

* CHECK dout1_24 Vdout1_24ck181 = 1.8 time = 3640
.meas tran vdout1_24ck181 FIND v(dout1_24) AT=3640.1n

* CHECK dout1_25 Vdout1_25ck181 = 0 time = 3640
.meas tran vdout1_25ck181 FIND v(dout1_25) AT=3640.1n

* CHECK dout1_26 Vdout1_26ck181 = 0 time = 3640
.meas tran vdout1_26ck181 FIND v(dout1_26) AT=3640.1n

* CHECK dout1_27 Vdout1_27ck181 = 0 time = 3640
.meas tran vdout1_27ck181 FIND v(dout1_27) AT=3640.1n

* CHECK dout1_28 Vdout1_28ck181 = 0 time = 3640
.meas tran vdout1_28ck181 FIND v(dout1_28) AT=3640.1n

* CHECK dout1_29 Vdout1_29ck181 = 1.8 time = 3640
.meas tran vdout1_29ck181 FIND v(dout1_29) AT=3640.1n

* CHECK dout1_30 Vdout1_30ck181 = 1.8 time = 3640
.meas tran vdout1_30ck181 FIND v(dout1_30) AT=3640.1n

* CHECK dout1_31 Vdout1_31ck181 = 0 time = 3640
.meas tran vdout1_31ck181 FIND v(dout1_31) AT=3640.1n

* CHECK dout2_0 Vdout2_0ck181 = 0 time = 3640
.meas tran vdout2_0ck181 FIND v(dout2_0) AT=3640.1n

* CHECK dout2_1 Vdout2_1ck181 = 1.8 time = 3640
.meas tran vdout2_1ck181 FIND v(dout2_1) AT=3640.1n

* CHECK dout2_2 Vdout2_2ck181 = 0 time = 3640
.meas tran vdout2_2ck181 FIND v(dout2_2) AT=3640.1n

* CHECK dout2_3 Vdout2_3ck181 = 1.8 time = 3640
.meas tran vdout2_3ck181 FIND v(dout2_3) AT=3640.1n

* CHECK dout2_4 Vdout2_4ck181 = 0 time = 3640
.meas tran vdout2_4ck181 FIND v(dout2_4) AT=3640.1n

* CHECK dout2_5 Vdout2_5ck181 = 0 time = 3640
.meas tran vdout2_5ck181 FIND v(dout2_5) AT=3640.1n

* CHECK dout2_6 Vdout2_6ck181 = 0 time = 3640
.meas tran vdout2_6ck181 FIND v(dout2_6) AT=3640.1n

* CHECK dout2_7 Vdout2_7ck181 = 1.8 time = 3640
.meas tran vdout2_7ck181 FIND v(dout2_7) AT=3640.1n

* CHECK dout2_8 Vdout2_8ck181 = 1.8 time = 3640
.meas tran vdout2_8ck181 FIND v(dout2_8) AT=3640.1n

* CHECK dout2_9 Vdout2_9ck181 = 1.8 time = 3640
.meas tran vdout2_9ck181 FIND v(dout2_9) AT=3640.1n

* CHECK dout2_10 Vdout2_10ck181 = 1.8 time = 3640
.meas tran vdout2_10ck181 FIND v(dout2_10) AT=3640.1n

* CHECK dout2_11 Vdout2_11ck181 = 0 time = 3640
.meas tran vdout2_11ck181 FIND v(dout2_11) AT=3640.1n

* CHECK dout2_12 Vdout2_12ck181 = 0 time = 3640
.meas tran vdout2_12ck181 FIND v(dout2_12) AT=3640.1n

* CHECK dout2_13 Vdout2_13ck181 = 1.8 time = 3640
.meas tran vdout2_13ck181 FIND v(dout2_13) AT=3640.1n

* CHECK dout2_14 Vdout2_14ck181 = 0 time = 3640
.meas tran vdout2_14ck181 FIND v(dout2_14) AT=3640.1n

* CHECK dout2_15 Vdout2_15ck181 = 1.8 time = 3640
.meas tran vdout2_15ck181 FIND v(dout2_15) AT=3640.1n

* CHECK dout2_16 Vdout2_16ck181 = 0 time = 3640
.meas tran vdout2_16ck181 FIND v(dout2_16) AT=3640.1n

* CHECK dout2_17 Vdout2_17ck181 = 0 time = 3640
.meas tran vdout2_17ck181 FIND v(dout2_17) AT=3640.1n

* CHECK dout2_18 Vdout2_18ck181 = 0 time = 3640
.meas tran vdout2_18ck181 FIND v(dout2_18) AT=3640.1n

* CHECK dout2_19 Vdout2_19ck181 = 1.8 time = 3640
.meas tran vdout2_19ck181 FIND v(dout2_19) AT=3640.1n

* CHECK dout2_20 Vdout2_20ck181 = 1.8 time = 3640
.meas tran vdout2_20ck181 FIND v(dout2_20) AT=3640.1n

* CHECK dout2_21 Vdout2_21ck181 = 1.8 time = 3640
.meas tran vdout2_21ck181 FIND v(dout2_21) AT=3640.1n

* CHECK dout2_22 Vdout2_22ck181 = 1.8 time = 3640
.meas tran vdout2_22ck181 FIND v(dout2_22) AT=3640.1n

* CHECK dout2_23 Vdout2_23ck181 = 0 time = 3640
.meas tran vdout2_23ck181 FIND v(dout2_23) AT=3640.1n

* CHECK dout2_24 Vdout2_24ck181 = 1.8 time = 3640
.meas tran vdout2_24ck181 FIND v(dout2_24) AT=3640.1n

* CHECK dout2_25 Vdout2_25ck181 = 0 time = 3640
.meas tran vdout2_25ck181 FIND v(dout2_25) AT=3640.1n

* CHECK dout2_26 Vdout2_26ck181 = 0 time = 3640
.meas tran vdout2_26ck181 FIND v(dout2_26) AT=3640.1n

* CHECK dout2_27 Vdout2_27ck181 = 0 time = 3640
.meas tran vdout2_27ck181 FIND v(dout2_27) AT=3640.1n

* CHECK dout2_28 Vdout2_28ck181 = 0 time = 3640
.meas tran vdout2_28ck181 FIND v(dout2_28) AT=3640.1n

* CHECK dout2_29 Vdout2_29ck181 = 1.8 time = 3640
.meas tran vdout2_29ck181 FIND v(dout2_29) AT=3640.1n

* CHECK dout2_30 Vdout2_30ck181 = 1.8 time = 3640
.meas tran vdout2_30ck181 FIND v(dout2_30) AT=3640.1n

* CHECK dout2_31 Vdout2_31ck181 = 0 time = 3640
.meas tran vdout2_31ck181 FIND v(dout2_31) AT=3640.1n

* CHECK dout1_0 Vdout1_0ck182 = 0 time = 3660
.meas tran vdout1_0ck182 FIND v(dout1_0) AT=3660.1n

* CHECK dout1_1 Vdout1_1ck182 = 1.8 time = 3660
.meas tran vdout1_1ck182 FIND v(dout1_1) AT=3660.1n

* CHECK dout1_2 Vdout1_2ck182 = 0 time = 3660
.meas tran vdout1_2ck182 FIND v(dout1_2) AT=3660.1n

* CHECK dout1_3 Vdout1_3ck182 = 1.8 time = 3660
.meas tran vdout1_3ck182 FIND v(dout1_3) AT=3660.1n

* CHECK dout1_4 Vdout1_4ck182 = 0 time = 3660
.meas tran vdout1_4ck182 FIND v(dout1_4) AT=3660.1n

* CHECK dout1_5 Vdout1_5ck182 = 0 time = 3660
.meas tran vdout1_5ck182 FIND v(dout1_5) AT=3660.1n

* CHECK dout1_6 Vdout1_6ck182 = 0 time = 3660
.meas tran vdout1_6ck182 FIND v(dout1_6) AT=3660.1n

* CHECK dout1_7 Vdout1_7ck182 = 1.8 time = 3660
.meas tran vdout1_7ck182 FIND v(dout1_7) AT=3660.1n

* CHECK dout1_8 Vdout1_8ck182 = 1.8 time = 3660
.meas tran vdout1_8ck182 FIND v(dout1_8) AT=3660.1n

* CHECK dout1_9 Vdout1_9ck182 = 1.8 time = 3660
.meas tran vdout1_9ck182 FIND v(dout1_9) AT=3660.1n

* CHECK dout1_10 Vdout1_10ck182 = 1.8 time = 3660
.meas tran vdout1_10ck182 FIND v(dout1_10) AT=3660.1n

* CHECK dout1_11 Vdout1_11ck182 = 0 time = 3660
.meas tran vdout1_11ck182 FIND v(dout1_11) AT=3660.1n

* CHECK dout1_12 Vdout1_12ck182 = 0 time = 3660
.meas tran vdout1_12ck182 FIND v(dout1_12) AT=3660.1n

* CHECK dout1_13 Vdout1_13ck182 = 1.8 time = 3660
.meas tran vdout1_13ck182 FIND v(dout1_13) AT=3660.1n

* CHECK dout1_14 Vdout1_14ck182 = 0 time = 3660
.meas tran vdout1_14ck182 FIND v(dout1_14) AT=3660.1n

* CHECK dout1_15 Vdout1_15ck182 = 1.8 time = 3660
.meas tran vdout1_15ck182 FIND v(dout1_15) AT=3660.1n

* CHECK dout1_16 Vdout1_16ck182 = 0 time = 3660
.meas tran vdout1_16ck182 FIND v(dout1_16) AT=3660.1n

* CHECK dout1_17 Vdout1_17ck182 = 0 time = 3660
.meas tran vdout1_17ck182 FIND v(dout1_17) AT=3660.1n

* CHECK dout1_18 Vdout1_18ck182 = 0 time = 3660
.meas tran vdout1_18ck182 FIND v(dout1_18) AT=3660.1n

* CHECK dout1_19 Vdout1_19ck182 = 1.8 time = 3660
.meas tran vdout1_19ck182 FIND v(dout1_19) AT=3660.1n

* CHECK dout1_20 Vdout1_20ck182 = 1.8 time = 3660
.meas tran vdout1_20ck182 FIND v(dout1_20) AT=3660.1n

* CHECK dout1_21 Vdout1_21ck182 = 1.8 time = 3660
.meas tran vdout1_21ck182 FIND v(dout1_21) AT=3660.1n

* CHECK dout1_22 Vdout1_22ck182 = 1.8 time = 3660
.meas tran vdout1_22ck182 FIND v(dout1_22) AT=3660.1n

* CHECK dout1_23 Vdout1_23ck182 = 0 time = 3660
.meas tran vdout1_23ck182 FIND v(dout1_23) AT=3660.1n

* CHECK dout1_24 Vdout1_24ck182 = 1.8 time = 3660
.meas tran vdout1_24ck182 FIND v(dout1_24) AT=3660.1n

* CHECK dout1_25 Vdout1_25ck182 = 0 time = 3660
.meas tran vdout1_25ck182 FIND v(dout1_25) AT=3660.1n

* CHECK dout1_26 Vdout1_26ck182 = 0 time = 3660
.meas tran vdout1_26ck182 FIND v(dout1_26) AT=3660.1n

* CHECK dout1_27 Vdout1_27ck182 = 0 time = 3660
.meas tran vdout1_27ck182 FIND v(dout1_27) AT=3660.1n

* CHECK dout1_28 Vdout1_28ck182 = 0 time = 3660
.meas tran vdout1_28ck182 FIND v(dout1_28) AT=3660.1n

* CHECK dout1_29 Vdout1_29ck182 = 1.8 time = 3660
.meas tran vdout1_29ck182 FIND v(dout1_29) AT=3660.1n

* CHECK dout1_30 Vdout1_30ck182 = 1.8 time = 3660
.meas tran vdout1_30ck182 FIND v(dout1_30) AT=3660.1n

* CHECK dout1_31 Vdout1_31ck182 = 0 time = 3660
.meas tran vdout1_31ck182 FIND v(dout1_31) AT=3660.1n

* CHECK dout2_0 Vdout2_0ck182 = 0 time = 3660
.meas tran vdout2_0ck182 FIND v(dout2_0) AT=3660.1n

* CHECK dout2_1 Vdout2_1ck182 = 1.8 time = 3660
.meas tran vdout2_1ck182 FIND v(dout2_1) AT=3660.1n

* CHECK dout2_2 Vdout2_2ck182 = 0 time = 3660
.meas tran vdout2_2ck182 FIND v(dout2_2) AT=3660.1n

* CHECK dout2_3 Vdout2_3ck182 = 1.8 time = 3660
.meas tran vdout2_3ck182 FIND v(dout2_3) AT=3660.1n

* CHECK dout2_4 Vdout2_4ck182 = 0 time = 3660
.meas tran vdout2_4ck182 FIND v(dout2_4) AT=3660.1n

* CHECK dout2_5 Vdout2_5ck182 = 0 time = 3660
.meas tran vdout2_5ck182 FIND v(dout2_5) AT=3660.1n

* CHECK dout2_6 Vdout2_6ck182 = 0 time = 3660
.meas tran vdout2_6ck182 FIND v(dout2_6) AT=3660.1n

* CHECK dout2_7 Vdout2_7ck182 = 1.8 time = 3660
.meas tran vdout2_7ck182 FIND v(dout2_7) AT=3660.1n

* CHECK dout2_8 Vdout2_8ck182 = 1.8 time = 3660
.meas tran vdout2_8ck182 FIND v(dout2_8) AT=3660.1n

* CHECK dout2_9 Vdout2_9ck182 = 1.8 time = 3660
.meas tran vdout2_9ck182 FIND v(dout2_9) AT=3660.1n

* CHECK dout2_10 Vdout2_10ck182 = 1.8 time = 3660
.meas tran vdout2_10ck182 FIND v(dout2_10) AT=3660.1n

* CHECK dout2_11 Vdout2_11ck182 = 0 time = 3660
.meas tran vdout2_11ck182 FIND v(dout2_11) AT=3660.1n

* CHECK dout2_12 Vdout2_12ck182 = 0 time = 3660
.meas tran vdout2_12ck182 FIND v(dout2_12) AT=3660.1n

* CHECK dout2_13 Vdout2_13ck182 = 1.8 time = 3660
.meas tran vdout2_13ck182 FIND v(dout2_13) AT=3660.1n

* CHECK dout2_14 Vdout2_14ck182 = 0 time = 3660
.meas tran vdout2_14ck182 FIND v(dout2_14) AT=3660.1n

* CHECK dout2_15 Vdout2_15ck182 = 1.8 time = 3660
.meas tran vdout2_15ck182 FIND v(dout2_15) AT=3660.1n

* CHECK dout2_16 Vdout2_16ck182 = 0 time = 3660
.meas tran vdout2_16ck182 FIND v(dout2_16) AT=3660.1n

* CHECK dout2_17 Vdout2_17ck182 = 0 time = 3660
.meas tran vdout2_17ck182 FIND v(dout2_17) AT=3660.1n

* CHECK dout2_18 Vdout2_18ck182 = 0 time = 3660
.meas tran vdout2_18ck182 FIND v(dout2_18) AT=3660.1n

* CHECK dout2_19 Vdout2_19ck182 = 1.8 time = 3660
.meas tran vdout2_19ck182 FIND v(dout2_19) AT=3660.1n

* CHECK dout2_20 Vdout2_20ck182 = 1.8 time = 3660
.meas tran vdout2_20ck182 FIND v(dout2_20) AT=3660.1n

* CHECK dout2_21 Vdout2_21ck182 = 1.8 time = 3660
.meas tran vdout2_21ck182 FIND v(dout2_21) AT=3660.1n

* CHECK dout2_22 Vdout2_22ck182 = 1.8 time = 3660
.meas tran vdout2_22ck182 FIND v(dout2_22) AT=3660.1n

* CHECK dout2_23 Vdout2_23ck182 = 0 time = 3660
.meas tran vdout2_23ck182 FIND v(dout2_23) AT=3660.1n

* CHECK dout2_24 Vdout2_24ck182 = 1.8 time = 3660
.meas tran vdout2_24ck182 FIND v(dout2_24) AT=3660.1n

* CHECK dout2_25 Vdout2_25ck182 = 0 time = 3660
.meas tran vdout2_25ck182 FIND v(dout2_25) AT=3660.1n

* CHECK dout2_26 Vdout2_26ck182 = 0 time = 3660
.meas tran vdout2_26ck182 FIND v(dout2_26) AT=3660.1n

* CHECK dout2_27 Vdout2_27ck182 = 0 time = 3660
.meas tran vdout2_27ck182 FIND v(dout2_27) AT=3660.1n

* CHECK dout2_28 Vdout2_28ck182 = 0 time = 3660
.meas tran vdout2_28ck182 FIND v(dout2_28) AT=3660.1n

* CHECK dout2_29 Vdout2_29ck182 = 1.8 time = 3660
.meas tran vdout2_29ck182 FIND v(dout2_29) AT=3660.1n

* CHECK dout2_30 Vdout2_30ck182 = 1.8 time = 3660
.meas tran vdout2_30ck182 FIND v(dout2_30) AT=3660.1n

* CHECK dout2_31 Vdout2_31ck182 = 0 time = 3660
.meas tran vdout2_31ck182 FIND v(dout2_31) AT=3660.1n

* CHECK dout1_0 Vdout1_0ck183 = 1.8 time = 3680
.meas tran vdout1_0ck183 FIND v(dout1_0) AT=3680.1n

* CHECK dout1_1 Vdout1_1ck183 = 1.8 time = 3680
.meas tran vdout1_1ck183 FIND v(dout1_1) AT=3680.1n

* CHECK dout1_2 Vdout1_2ck183 = 0 time = 3680
.meas tran vdout1_2ck183 FIND v(dout1_2) AT=3680.1n

* CHECK dout1_3 Vdout1_3ck183 = 0 time = 3680
.meas tran vdout1_3ck183 FIND v(dout1_3) AT=3680.1n

* CHECK dout1_4 Vdout1_4ck183 = 0 time = 3680
.meas tran vdout1_4ck183 FIND v(dout1_4) AT=3680.1n

* CHECK dout1_5 Vdout1_5ck183 = 0 time = 3680
.meas tran vdout1_5ck183 FIND v(dout1_5) AT=3680.1n

* CHECK dout1_6 Vdout1_6ck183 = 1.8 time = 3680
.meas tran vdout1_6ck183 FIND v(dout1_6) AT=3680.1n

* CHECK dout1_7 Vdout1_7ck183 = 0 time = 3680
.meas tran vdout1_7ck183 FIND v(dout1_7) AT=3680.1n

* CHECK dout1_8 Vdout1_8ck183 = 1.8 time = 3680
.meas tran vdout1_8ck183 FIND v(dout1_8) AT=3680.1n

* CHECK dout1_9 Vdout1_9ck183 = 1.8 time = 3680
.meas tran vdout1_9ck183 FIND v(dout1_9) AT=3680.1n

* CHECK dout1_10 Vdout1_10ck183 = 0 time = 3680
.meas tran vdout1_10ck183 FIND v(dout1_10) AT=3680.1n

* CHECK dout1_11 Vdout1_11ck183 = 0 time = 3680
.meas tran vdout1_11ck183 FIND v(dout1_11) AT=3680.1n

* CHECK dout1_12 Vdout1_12ck183 = 1.8 time = 3680
.meas tran vdout1_12ck183 FIND v(dout1_12) AT=3680.1n

* CHECK dout1_13 Vdout1_13ck183 = 1.8 time = 3680
.meas tran vdout1_13ck183 FIND v(dout1_13) AT=3680.1n

* CHECK dout1_14 Vdout1_14ck183 = 0 time = 3680
.meas tran vdout1_14ck183 FIND v(dout1_14) AT=3680.1n

* CHECK dout1_15 Vdout1_15ck183 = 0 time = 3680
.meas tran vdout1_15ck183 FIND v(dout1_15) AT=3680.1n

* CHECK dout1_16 Vdout1_16ck183 = 1.8 time = 3680
.meas tran vdout1_16ck183 FIND v(dout1_16) AT=3680.1n

* CHECK dout1_17 Vdout1_17ck183 = 0 time = 3680
.meas tran vdout1_17ck183 FIND v(dout1_17) AT=3680.1n

* CHECK dout1_18 Vdout1_18ck183 = 1.8 time = 3680
.meas tran vdout1_18ck183 FIND v(dout1_18) AT=3680.1n

* CHECK dout1_19 Vdout1_19ck183 = 0 time = 3680
.meas tran vdout1_19ck183 FIND v(dout1_19) AT=3680.1n

* CHECK dout1_20 Vdout1_20ck183 = 0 time = 3680
.meas tran vdout1_20ck183 FIND v(dout1_20) AT=3680.1n

* CHECK dout1_21 Vdout1_21ck183 = 1.8 time = 3680
.meas tran vdout1_21ck183 FIND v(dout1_21) AT=3680.1n

* CHECK dout1_22 Vdout1_22ck183 = 1.8 time = 3680
.meas tran vdout1_22ck183 FIND v(dout1_22) AT=3680.1n

* CHECK dout1_23 Vdout1_23ck183 = 0 time = 3680
.meas tran vdout1_23ck183 FIND v(dout1_23) AT=3680.1n

* CHECK dout1_24 Vdout1_24ck183 = 1.8 time = 3680
.meas tran vdout1_24ck183 FIND v(dout1_24) AT=3680.1n

* CHECK dout1_25 Vdout1_25ck183 = 0 time = 3680
.meas tran vdout1_25ck183 FIND v(dout1_25) AT=3680.1n

* CHECK dout1_26 Vdout1_26ck183 = 0 time = 3680
.meas tran vdout1_26ck183 FIND v(dout1_26) AT=3680.1n

* CHECK dout1_27 Vdout1_27ck183 = 1.8 time = 3680
.meas tran vdout1_27ck183 FIND v(dout1_27) AT=3680.1n

* CHECK dout1_28 Vdout1_28ck183 = 1.8 time = 3680
.meas tran vdout1_28ck183 FIND v(dout1_28) AT=3680.1n

* CHECK dout1_29 Vdout1_29ck183 = 1.8 time = 3680
.meas tran vdout1_29ck183 FIND v(dout1_29) AT=3680.1n

* CHECK dout1_30 Vdout1_30ck183 = 0 time = 3680
.meas tran vdout1_30ck183 FIND v(dout1_30) AT=3680.1n

* CHECK dout1_31 Vdout1_31ck183 = 0 time = 3680
.meas tran vdout1_31ck183 FIND v(dout1_31) AT=3680.1n

* CHECK dout2_0 Vdout2_0ck183 = 1.8 time = 3680
.meas tran vdout2_0ck183 FIND v(dout2_0) AT=3680.1n

* CHECK dout2_1 Vdout2_1ck183 = 1.8 time = 3680
.meas tran vdout2_1ck183 FIND v(dout2_1) AT=3680.1n

* CHECK dout2_2 Vdout2_2ck183 = 0 time = 3680
.meas tran vdout2_2ck183 FIND v(dout2_2) AT=3680.1n

* CHECK dout2_3 Vdout2_3ck183 = 0 time = 3680
.meas tran vdout2_3ck183 FIND v(dout2_3) AT=3680.1n

* CHECK dout2_4 Vdout2_4ck183 = 0 time = 3680
.meas tran vdout2_4ck183 FIND v(dout2_4) AT=3680.1n

* CHECK dout2_5 Vdout2_5ck183 = 0 time = 3680
.meas tran vdout2_5ck183 FIND v(dout2_5) AT=3680.1n

* CHECK dout2_6 Vdout2_6ck183 = 1.8 time = 3680
.meas tran vdout2_6ck183 FIND v(dout2_6) AT=3680.1n

* CHECK dout2_7 Vdout2_7ck183 = 0 time = 3680
.meas tran vdout2_7ck183 FIND v(dout2_7) AT=3680.1n

* CHECK dout2_8 Vdout2_8ck183 = 1.8 time = 3680
.meas tran vdout2_8ck183 FIND v(dout2_8) AT=3680.1n

* CHECK dout2_9 Vdout2_9ck183 = 1.8 time = 3680
.meas tran vdout2_9ck183 FIND v(dout2_9) AT=3680.1n

* CHECK dout2_10 Vdout2_10ck183 = 0 time = 3680
.meas tran vdout2_10ck183 FIND v(dout2_10) AT=3680.1n

* CHECK dout2_11 Vdout2_11ck183 = 0 time = 3680
.meas tran vdout2_11ck183 FIND v(dout2_11) AT=3680.1n

* CHECK dout2_12 Vdout2_12ck183 = 1.8 time = 3680
.meas tran vdout2_12ck183 FIND v(dout2_12) AT=3680.1n

* CHECK dout2_13 Vdout2_13ck183 = 1.8 time = 3680
.meas tran vdout2_13ck183 FIND v(dout2_13) AT=3680.1n

* CHECK dout2_14 Vdout2_14ck183 = 0 time = 3680
.meas tran vdout2_14ck183 FIND v(dout2_14) AT=3680.1n

* CHECK dout2_15 Vdout2_15ck183 = 0 time = 3680
.meas tran vdout2_15ck183 FIND v(dout2_15) AT=3680.1n

* CHECK dout2_16 Vdout2_16ck183 = 1.8 time = 3680
.meas tran vdout2_16ck183 FIND v(dout2_16) AT=3680.1n

* CHECK dout2_17 Vdout2_17ck183 = 0 time = 3680
.meas tran vdout2_17ck183 FIND v(dout2_17) AT=3680.1n

* CHECK dout2_18 Vdout2_18ck183 = 1.8 time = 3680
.meas tran vdout2_18ck183 FIND v(dout2_18) AT=3680.1n

* CHECK dout2_19 Vdout2_19ck183 = 0 time = 3680
.meas tran vdout2_19ck183 FIND v(dout2_19) AT=3680.1n

* CHECK dout2_20 Vdout2_20ck183 = 0 time = 3680
.meas tran vdout2_20ck183 FIND v(dout2_20) AT=3680.1n

* CHECK dout2_21 Vdout2_21ck183 = 1.8 time = 3680
.meas tran vdout2_21ck183 FIND v(dout2_21) AT=3680.1n

* CHECK dout2_22 Vdout2_22ck183 = 1.8 time = 3680
.meas tran vdout2_22ck183 FIND v(dout2_22) AT=3680.1n

* CHECK dout2_23 Vdout2_23ck183 = 0 time = 3680
.meas tran vdout2_23ck183 FIND v(dout2_23) AT=3680.1n

* CHECK dout2_24 Vdout2_24ck183 = 1.8 time = 3680
.meas tran vdout2_24ck183 FIND v(dout2_24) AT=3680.1n

* CHECK dout2_25 Vdout2_25ck183 = 0 time = 3680
.meas tran vdout2_25ck183 FIND v(dout2_25) AT=3680.1n

* CHECK dout2_26 Vdout2_26ck183 = 0 time = 3680
.meas tran vdout2_26ck183 FIND v(dout2_26) AT=3680.1n

* CHECK dout2_27 Vdout2_27ck183 = 1.8 time = 3680
.meas tran vdout2_27ck183 FIND v(dout2_27) AT=3680.1n

* CHECK dout2_28 Vdout2_28ck183 = 1.8 time = 3680
.meas tran vdout2_28ck183 FIND v(dout2_28) AT=3680.1n

* CHECK dout2_29 Vdout2_29ck183 = 1.8 time = 3680
.meas tran vdout2_29ck183 FIND v(dout2_29) AT=3680.1n

* CHECK dout2_30 Vdout2_30ck183 = 0 time = 3680
.meas tran vdout2_30ck183 FIND v(dout2_30) AT=3680.1n

* CHECK dout2_31 Vdout2_31ck183 = 0 time = 3680
.meas tran vdout2_31ck183 FIND v(dout2_31) AT=3680.1n

* CHECK dout1_0 Vdout1_0ck184 = 0 time = 3700
.meas tran vdout1_0ck184 FIND v(dout1_0) AT=3700.1n

* CHECK dout1_1 Vdout1_1ck184 = 0 time = 3700
.meas tran vdout1_1ck184 FIND v(dout1_1) AT=3700.1n

* CHECK dout1_2 Vdout1_2ck184 = 1.8 time = 3700
.meas tran vdout1_2ck184 FIND v(dout1_2) AT=3700.1n

* CHECK dout1_3 Vdout1_3ck184 = 0 time = 3700
.meas tran vdout1_3ck184 FIND v(dout1_3) AT=3700.1n

* CHECK dout1_4 Vdout1_4ck184 = 1.8 time = 3700
.meas tran vdout1_4ck184 FIND v(dout1_4) AT=3700.1n

* CHECK dout1_5 Vdout1_5ck184 = 1.8 time = 3700
.meas tran vdout1_5ck184 FIND v(dout1_5) AT=3700.1n

* CHECK dout1_6 Vdout1_6ck184 = 1.8 time = 3700
.meas tran vdout1_6ck184 FIND v(dout1_6) AT=3700.1n

* CHECK dout1_7 Vdout1_7ck184 = 1.8 time = 3700
.meas tran vdout1_7ck184 FIND v(dout1_7) AT=3700.1n

* CHECK dout1_8 Vdout1_8ck184 = 1.8 time = 3700
.meas tran vdout1_8ck184 FIND v(dout1_8) AT=3700.1n

* CHECK dout1_9 Vdout1_9ck184 = 0 time = 3700
.meas tran vdout1_9ck184 FIND v(dout1_9) AT=3700.1n

* CHECK dout1_10 Vdout1_10ck184 = 0 time = 3700
.meas tran vdout1_10ck184 FIND v(dout1_10) AT=3700.1n

* CHECK dout1_11 Vdout1_11ck184 = 1.8 time = 3700
.meas tran vdout1_11ck184 FIND v(dout1_11) AT=3700.1n

* CHECK dout1_12 Vdout1_12ck184 = 1.8 time = 3700
.meas tran vdout1_12ck184 FIND v(dout1_12) AT=3700.1n

* CHECK dout1_13 Vdout1_13ck184 = 0 time = 3700
.meas tran vdout1_13ck184 FIND v(dout1_13) AT=3700.1n

* CHECK dout1_14 Vdout1_14ck184 = 1.8 time = 3700
.meas tran vdout1_14ck184 FIND v(dout1_14) AT=3700.1n

* CHECK dout1_15 Vdout1_15ck184 = 0 time = 3700
.meas tran vdout1_15ck184 FIND v(dout1_15) AT=3700.1n

* CHECK dout1_16 Vdout1_16ck184 = 0 time = 3700
.meas tran vdout1_16ck184 FIND v(dout1_16) AT=3700.1n

* CHECK dout1_17 Vdout1_17ck184 = 0 time = 3700
.meas tran vdout1_17ck184 FIND v(dout1_17) AT=3700.1n

* CHECK dout1_18 Vdout1_18ck184 = 1.8 time = 3700
.meas tran vdout1_18ck184 FIND v(dout1_18) AT=3700.1n

* CHECK dout1_19 Vdout1_19ck184 = 1.8 time = 3700
.meas tran vdout1_19ck184 FIND v(dout1_19) AT=3700.1n

* CHECK dout1_20 Vdout1_20ck184 = 0 time = 3700
.meas tran vdout1_20ck184 FIND v(dout1_20) AT=3700.1n

* CHECK dout1_21 Vdout1_21ck184 = 0 time = 3700
.meas tran vdout1_21ck184 FIND v(dout1_21) AT=3700.1n

* CHECK dout1_22 Vdout1_22ck184 = 0 time = 3700
.meas tran vdout1_22ck184 FIND v(dout1_22) AT=3700.1n

* CHECK dout1_23 Vdout1_23ck184 = 1.8 time = 3700
.meas tran vdout1_23ck184 FIND v(dout1_23) AT=3700.1n

* CHECK dout1_24 Vdout1_24ck184 = 0 time = 3700
.meas tran vdout1_24ck184 FIND v(dout1_24) AT=3700.1n

* CHECK dout1_25 Vdout1_25ck184 = 0 time = 3700
.meas tran vdout1_25ck184 FIND v(dout1_25) AT=3700.1n

* CHECK dout1_26 Vdout1_26ck184 = 1.8 time = 3700
.meas tran vdout1_26ck184 FIND v(dout1_26) AT=3700.1n

* CHECK dout1_27 Vdout1_27ck184 = 1.8 time = 3700
.meas tran vdout1_27ck184 FIND v(dout1_27) AT=3700.1n

* CHECK dout1_28 Vdout1_28ck184 = 1.8 time = 3700
.meas tran vdout1_28ck184 FIND v(dout1_28) AT=3700.1n

* CHECK dout1_29 Vdout1_29ck184 = 0 time = 3700
.meas tran vdout1_29ck184 FIND v(dout1_29) AT=3700.1n

* CHECK dout1_30 Vdout1_30ck184 = 0 time = 3700
.meas tran vdout1_30ck184 FIND v(dout1_30) AT=3700.1n

* CHECK dout1_31 Vdout1_31ck184 = 1.8 time = 3700
.meas tran vdout1_31ck184 FIND v(dout1_31) AT=3700.1n

* CHECK dout1_0 Vdout1_0ck185 = 0 time = 3720
.meas tran vdout1_0ck185 FIND v(dout1_0) AT=3720.1n

* CHECK dout1_1 Vdout1_1ck185 = 0 time = 3720
.meas tran vdout1_1ck185 FIND v(dout1_1) AT=3720.1n

* CHECK dout1_2 Vdout1_2ck185 = 1.8 time = 3720
.meas tran vdout1_2ck185 FIND v(dout1_2) AT=3720.1n

* CHECK dout1_3 Vdout1_3ck185 = 0 time = 3720
.meas tran vdout1_3ck185 FIND v(dout1_3) AT=3720.1n

* CHECK dout1_4 Vdout1_4ck185 = 1.8 time = 3720
.meas tran vdout1_4ck185 FIND v(dout1_4) AT=3720.1n

* CHECK dout1_5 Vdout1_5ck185 = 1.8 time = 3720
.meas tran vdout1_5ck185 FIND v(dout1_5) AT=3720.1n

* CHECK dout1_6 Vdout1_6ck185 = 1.8 time = 3720
.meas tran vdout1_6ck185 FIND v(dout1_6) AT=3720.1n

* CHECK dout1_7 Vdout1_7ck185 = 1.8 time = 3720
.meas tran vdout1_7ck185 FIND v(dout1_7) AT=3720.1n

* CHECK dout1_8 Vdout1_8ck185 = 1.8 time = 3720
.meas tran vdout1_8ck185 FIND v(dout1_8) AT=3720.1n

* CHECK dout1_9 Vdout1_9ck185 = 0 time = 3720
.meas tran vdout1_9ck185 FIND v(dout1_9) AT=3720.1n

* CHECK dout1_10 Vdout1_10ck185 = 0 time = 3720
.meas tran vdout1_10ck185 FIND v(dout1_10) AT=3720.1n

* CHECK dout1_11 Vdout1_11ck185 = 1.8 time = 3720
.meas tran vdout1_11ck185 FIND v(dout1_11) AT=3720.1n

* CHECK dout1_12 Vdout1_12ck185 = 1.8 time = 3720
.meas tran vdout1_12ck185 FIND v(dout1_12) AT=3720.1n

* CHECK dout1_13 Vdout1_13ck185 = 0 time = 3720
.meas tran vdout1_13ck185 FIND v(dout1_13) AT=3720.1n

* CHECK dout1_14 Vdout1_14ck185 = 1.8 time = 3720
.meas tran vdout1_14ck185 FIND v(dout1_14) AT=3720.1n

* CHECK dout1_15 Vdout1_15ck185 = 0 time = 3720
.meas tran vdout1_15ck185 FIND v(dout1_15) AT=3720.1n

* CHECK dout1_16 Vdout1_16ck185 = 0 time = 3720
.meas tran vdout1_16ck185 FIND v(dout1_16) AT=3720.1n

* CHECK dout1_17 Vdout1_17ck185 = 0 time = 3720
.meas tran vdout1_17ck185 FIND v(dout1_17) AT=3720.1n

* CHECK dout1_18 Vdout1_18ck185 = 1.8 time = 3720
.meas tran vdout1_18ck185 FIND v(dout1_18) AT=3720.1n

* CHECK dout1_19 Vdout1_19ck185 = 1.8 time = 3720
.meas tran vdout1_19ck185 FIND v(dout1_19) AT=3720.1n

* CHECK dout1_20 Vdout1_20ck185 = 0 time = 3720
.meas tran vdout1_20ck185 FIND v(dout1_20) AT=3720.1n

* CHECK dout1_21 Vdout1_21ck185 = 0 time = 3720
.meas tran vdout1_21ck185 FIND v(dout1_21) AT=3720.1n

* CHECK dout1_22 Vdout1_22ck185 = 0 time = 3720
.meas tran vdout1_22ck185 FIND v(dout1_22) AT=3720.1n

* CHECK dout1_23 Vdout1_23ck185 = 1.8 time = 3720
.meas tran vdout1_23ck185 FIND v(dout1_23) AT=3720.1n

* CHECK dout1_24 Vdout1_24ck185 = 0 time = 3720
.meas tran vdout1_24ck185 FIND v(dout1_24) AT=3720.1n

* CHECK dout1_25 Vdout1_25ck185 = 0 time = 3720
.meas tran vdout1_25ck185 FIND v(dout1_25) AT=3720.1n

* CHECK dout1_26 Vdout1_26ck185 = 1.8 time = 3720
.meas tran vdout1_26ck185 FIND v(dout1_26) AT=3720.1n

* CHECK dout1_27 Vdout1_27ck185 = 1.8 time = 3720
.meas tran vdout1_27ck185 FIND v(dout1_27) AT=3720.1n

* CHECK dout1_28 Vdout1_28ck185 = 1.8 time = 3720
.meas tran vdout1_28ck185 FIND v(dout1_28) AT=3720.1n

* CHECK dout1_29 Vdout1_29ck185 = 0 time = 3720
.meas tran vdout1_29ck185 FIND v(dout1_29) AT=3720.1n

* CHECK dout1_30 Vdout1_30ck185 = 0 time = 3720
.meas tran vdout1_30ck185 FIND v(dout1_30) AT=3720.1n

* CHECK dout1_31 Vdout1_31ck185 = 1.8 time = 3720
.meas tran vdout1_31ck185 FIND v(dout1_31) AT=3720.1n

* CHECK dout2_0 Vdout2_0ck185 = 0 time = 3720
.meas tran vdout2_0ck185 FIND v(dout2_0) AT=3720.1n

* CHECK dout2_1 Vdout2_1ck185 = 1.8 time = 3720
.meas tran vdout2_1ck185 FIND v(dout2_1) AT=3720.1n

* CHECK dout2_2 Vdout2_2ck185 = 0 time = 3720
.meas tran vdout2_2ck185 FIND v(dout2_2) AT=3720.1n

* CHECK dout2_3 Vdout2_3ck185 = 0 time = 3720
.meas tran vdout2_3ck185 FIND v(dout2_3) AT=3720.1n

* CHECK dout2_4 Vdout2_4ck185 = 0 time = 3720
.meas tran vdout2_4ck185 FIND v(dout2_4) AT=3720.1n

* CHECK dout2_5 Vdout2_5ck185 = 0 time = 3720
.meas tran vdout2_5ck185 FIND v(dout2_5) AT=3720.1n

* CHECK dout2_6 Vdout2_6ck185 = 0 time = 3720
.meas tran vdout2_6ck185 FIND v(dout2_6) AT=3720.1n

* CHECK dout2_7 Vdout2_7ck185 = 1.8 time = 3720
.meas tran vdout2_7ck185 FIND v(dout2_7) AT=3720.1n

* CHECK dout2_8 Vdout2_8ck185 = 0 time = 3720
.meas tran vdout2_8ck185 FIND v(dout2_8) AT=3720.1n

* CHECK dout2_9 Vdout2_9ck185 = 0 time = 3720
.meas tran vdout2_9ck185 FIND v(dout2_9) AT=3720.1n

* CHECK dout2_10 Vdout2_10ck185 = 0 time = 3720
.meas tran vdout2_10ck185 FIND v(dout2_10) AT=3720.1n

* CHECK dout2_11 Vdout2_11ck185 = 1.8 time = 3720
.meas tran vdout2_11ck185 FIND v(dout2_11) AT=3720.1n

* CHECK dout2_12 Vdout2_12ck185 = 0 time = 3720
.meas tran vdout2_12ck185 FIND v(dout2_12) AT=3720.1n

* CHECK dout2_13 Vdout2_13ck185 = 0 time = 3720
.meas tran vdout2_13ck185 FIND v(dout2_13) AT=3720.1n

* CHECK dout2_14 Vdout2_14ck185 = 1.8 time = 3720
.meas tran vdout2_14ck185 FIND v(dout2_14) AT=3720.1n

* CHECK dout2_15 Vdout2_15ck185 = 0 time = 3720
.meas tran vdout2_15ck185 FIND v(dout2_15) AT=3720.1n

* CHECK dout2_16 Vdout2_16ck185 = 1.8 time = 3720
.meas tran vdout2_16ck185 FIND v(dout2_16) AT=3720.1n

* CHECK dout2_17 Vdout2_17ck185 = 1.8 time = 3720
.meas tran vdout2_17ck185 FIND v(dout2_17) AT=3720.1n

* CHECK dout2_18 Vdout2_18ck185 = 1.8 time = 3720
.meas tran vdout2_18ck185 FIND v(dout2_18) AT=3720.1n

* CHECK dout2_19 Vdout2_19ck185 = 0 time = 3720
.meas tran vdout2_19ck185 FIND v(dout2_19) AT=3720.1n

* CHECK dout2_20 Vdout2_20ck185 = 0 time = 3720
.meas tran vdout2_20ck185 FIND v(dout2_20) AT=3720.1n

* CHECK dout2_21 Vdout2_21ck185 = 0 time = 3720
.meas tran vdout2_21ck185 FIND v(dout2_21) AT=3720.1n

* CHECK dout2_22 Vdout2_22ck185 = 1.8 time = 3720
.meas tran vdout2_22ck185 FIND v(dout2_22) AT=3720.1n

* CHECK dout2_23 Vdout2_23ck185 = 1.8 time = 3720
.meas tran vdout2_23ck185 FIND v(dout2_23) AT=3720.1n

* CHECK dout2_24 Vdout2_24ck185 = 0 time = 3720
.meas tran vdout2_24ck185 FIND v(dout2_24) AT=3720.1n

* CHECK dout2_25 Vdout2_25ck185 = 1.8 time = 3720
.meas tran vdout2_25ck185 FIND v(dout2_25) AT=3720.1n

* CHECK dout2_26 Vdout2_26ck185 = 0 time = 3720
.meas tran vdout2_26ck185 FIND v(dout2_26) AT=3720.1n

* CHECK dout2_27 Vdout2_27ck185 = 1.8 time = 3720
.meas tran vdout2_27ck185 FIND v(dout2_27) AT=3720.1n

* CHECK dout2_28 Vdout2_28ck185 = 1.8 time = 3720
.meas tran vdout2_28ck185 FIND v(dout2_28) AT=3720.1n

* CHECK dout2_29 Vdout2_29ck185 = 1.8 time = 3720
.meas tran vdout2_29ck185 FIND v(dout2_29) AT=3720.1n

* CHECK dout2_30 Vdout2_30ck185 = 0 time = 3720
.meas tran vdout2_30ck185 FIND v(dout2_30) AT=3720.1n

* CHECK dout2_31 Vdout2_31ck185 = 1.8 time = 3720
.meas tran vdout2_31ck185 FIND v(dout2_31) AT=3720.1n

* CHECK dout1_0 Vdout1_0ck186 = 0 time = 3740
.meas tran vdout1_0ck186 FIND v(dout1_0) AT=3740.1n

* CHECK dout1_1 Vdout1_1ck186 = 1.8 time = 3740
.meas tran vdout1_1ck186 FIND v(dout1_1) AT=3740.1n

* CHECK dout1_2 Vdout1_2ck186 = 0 time = 3740
.meas tran vdout1_2ck186 FIND v(dout1_2) AT=3740.1n

* CHECK dout1_3 Vdout1_3ck186 = 0 time = 3740
.meas tran vdout1_3ck186 FIND v(dout1_3) AT=3740.1n

* CHECK dout1_4 Vdout1_4ck186 = 0 time = 3740
.meas tran vdout1_4ck186 FIND v(dout1_4) AT=3740.1n

* CHECK dout1_5 Vdout1_5ck186 = 0 time = 3740
.meas tran vdout1_5ck186 FIND v(dout1_5) AT=3740.1n

* CHECK dout1_6 Vdout1_6ck186 = 0 time = 3740
.meas tran vdout1_6ck186 FIND v(dout1_6) AT=3740.1n

* CHECK dout1_7 Vdout1_7ck186 = 1.8 time = 3740
.meas tran vdout1_7ck186 FIND v(dout1_7) AT=3740.1n

* CHECK dout1_8 Vdout1_8ck186 = 0 time = 3740
.meas tran vdout1_8ck186 FIND v(dout1_8) AT=3740.1n

* CHECK dout1_9 Vdout1_9ck186 = 0 time = 3740
.meas tran vdout1_9ck186 FIND v(dout1_9) AT=3740.1n

* CHECK dout1_10 Vdout1_10ck186 = 0 time = 3740
.meas tran vdout1_10ck186 FIND v(dout1_10) AT=3740.1n

* CHECK dout1_11 Vdout1_11ck186 = 1.8 time = 3740
.meas tran vdout1_11ck186 FIND v(dout1_11) AT=3740.1n

* CHECK dout1_12 Vdout1_12ck186 = 0 time = 3740
.meas tran vdout1_12ck186 FIND v(dout1_12) AT=3740.1n

* CHECK dout1_13 Vdout1_13ck186 = 0 time = 3740
.meas tran vdout1_13ck186 FIND v(dout1_13) AT=3740.1n

* CHECK dout1_14 Vdout1_14ck186 = 1.8 time = 3740
.meas tran vdout1_14ck186 FIND v(dout1_14) AT=3740.1n

* CHECK dout1_15 Vdout1_15ck186 = 0 time = 3740
.meas tran vdout1_15ck186 FIND v(dout1_15) AT=3740.1n

* CHECK dout1_16 Vdout1_16ck186 = 1.8 time = 3740
.meas tran vdout1_16ck186 FIND v(dout1_16) AT=3740.1n

* CHECK dout1_17 Vdout1_17ck186 = 1.8 time = 3740
.meas tran vdout1_17ck186 FIND v(dout1_17) AT=3740.1n

* CHECK dout1_18 Vdout1_18ck186 = 1.8 time = 3740
.meas tran vdout1_18ck186 FIND v(dout1_18) AT=3740.1n

* CHECK dout1_19 Vdout1_19ck186 = 0 time = 3740
.meas tran vdout1_19ck186 FIND v(dout1_19) AT=3740.1n

* CHECK dout1_20 Vdout1_20ck186 = 0 time = 3740
.meas tran vdout1_20ck186 FIND v(dout1_20) AT=3740.1n

* CHECK dout1_21 Vdout1_21ck186 = 0 time = 3740
.meas tran vdout1_21ck186 FIND v(dout1_21) AT=3740.1n

* CHECK dout1_22 Vdout1_22ck186 = 1.8 time = 3740
.meas tran vdout1_22ck186 FIND v(dout1_22) AT=3740.1n

* CHECK dout1_23 Vdout1_23ck186 = 1.8 time = 3740
.meas tran vdout1_23ck186 FIND v(dout1_23) AT=3740.1n

* CHECK dout1_24 Vdout1_24ck186 = 0 time = 3740
.meas tran vdout1_24ck186 FIND v(dout1_24) AT=3740.1n

* CHECK dout1_25 Vdout1_25ck186 = 1.8 time = 3740
.meas tran vdout1_25ck186 FIND v(dout1_25) AT=3740.1n

* CHECK dout1_26 Vdout1_26ck186 = 0 time = 3740
.meas tran vdout1_26ck186 FIND v(dout1_26) AT=3740.1n

* CHECK dout1_27 Vdout1_27ck186 = 1.8 time = 3740
.meas tran vdout1_27ck186 FIND v(dout1_27) AT=3740.1n

* CHECK dout1_28 Vdout1_28ck186 = 1.8 time = 3740
.meas tran vdout1_28ck186 FIND v(dout1_28) AT=3740.1n

* CHECK dout1_29 Vdout1_29ck186 = 1.8 time = 3740
.meas tran vdout1_29ck186 FIND v(dout1_29) AT=3740.1n

* CHECK dout1_30 Vdout1_30ck186 = 0 time = 3740
.meas tran vdout1_30ck186 FIND v(dout1_30) AT=3740.1n

* CHECK dout1_31 Vdout1_31ck186 = 1.8 time = 3740
.meas tran vdout1_31ck186 FIND v(dout1_31) AT=3740.1n

* CHECK dout2_0 Vdout2_0ck186 = 1.8 time = 3740
.meas tran vdout2_0ck186 FIND v(dout2_0) AT=3740.1n

* CHECK dout2_1 Vdout2_1ck186 = 1.8 time = 3740
.meas tran vdout2_1ck186 FIND v(dout2_1) AT=3740.1n

* CHECK dout2_2 Vdout2_2ck186 = 0 time = 3740
.meas tran vdout2_2ck186 FIND v(dout2_2) AT=3740.1n

* CHECK dout2_3 Vdout2_3ck186 = 0 time = 3740
.meas tran vdout2_3ck186 FIND v(dout2_3) AT=3740.1n

* CHECK dout2_4 Vdout2_4ck186 = 1.8 time = 3740
.meas tran vdout2_4ck186 FIND v(dout2_4) AT=3740.1n

* CHECK dout2_5 Vdout2_5ck186 = 0 time = 3740
.meas tran vdout2_5ck186 FIND v(dout2_5) AT=3740.1n

* CHECK dout2_6 Vdout2_6ck186 = 0 time = 3740
.meas tran vdout2_6ck186 FIND v(dout2_6) AT=3740.1n

* CHECK dout2_7 Vdout2_7ck186 = 0 time = 3740
.meas tran vdout2_7ck186 FIND v(dout2_7) AT=3740.1n

* CHECK dout2_8 Vdout2_8ck186 = 1.8 time = 3740
.meas tran vdout2_8ck186 FIND v(dout2_8) AT=3740.1n

* CHECK dout2_9 Vdout2_9ck186 = 0 time = 3740
.meas tran vdout2_9ck186 FIND v(dout2_9) AT=3740.1n

* CHECK dout2_10 Vdout2_10ck186 = 1.8 time = 3740
.meas tran vdout2_10ck186 FIND v(dout2_10) AT=3740.1n

* CHECK dout2_11 Vdout2_11ck186 = 1.8 time = 3740
.meas tran vdout2_11ck186 FIND v(dout2_11) AT=3740.1n

* CHECK dout2_12 Vdout2_12ck186 = 1.8 time = 3740
.meas tran vdout2_12ck186 FIND v(dout2_12) AT=3740.1n

* CHECK dout2_13 Vdout2_13ck186 = 1.8 time = 3740
.meas tran vdout2_13ck186 FIND v(dout2_13) AT=3740.1n

* CHECK dout2_14 Vdout2_14ck186 = 1.8 time = 3740
.meas tran vdout2_14ck186 FIND v(dout2_14) AT=3740.1n

* CHECK dout2_15 Vdout2_15ck186 = 1.8 time = 3740
.meas tran vdout2_15ck186 FIND v(dout2_15) AT=3740.1n

* CHECK dout2_16 Vdout2_16ck186 = 1.8 time = 3740
.meas tran vdout2_16ck186 FIND v(dout2_16) AT=3740.1n

* CHECK dout2_17 Vdout2_17ck186 = 1.8 time = 3740
.meas tran vdout2_17ck186 FIND v(dout2_17) AT=3740.1n

* CHECK dout2_18 Vdout2_18ck186 = 0 time = 3740
.meas tran vdout2_18ck186 FIND v(dout2_18) AT=3740.1n

* CHECK dout2_19 Vdout2_19ck186 = 0 time = 3740
.meas tran vdout2_19ck186 FIND v(dout2_19) AT=3740.1n

* CHECK dout2_20 Vdout2_20ck186 = 1.8 time = 3740
.meas tran vdout2_20ck186 FIND v(dout2_20) AT=3740.1n

* CHECK dout2_21 Vdout2_21ck186 = 0 time = 3740
.meas tran vdout2_21ck186 FIND v(dout2_21) AT=3740.1n

* CHECK dout2_22 Vdout2_22ck186 = 0 time = 3740
.meas tran vdout2_22ck186 FIND v(dout2_22) AT=3740.1n

* CHECK dout2_23 Vdout2_23ck186 = 1.8 time = 3740
.meas tran vdout2_23ck186 FIND v(dout2_23) AT=3740.1n

* CHECK dout2_24 Vdout2_24ck186 = 1.8 time = 3740
.meas tran vdout2_24ck186 FIND v(dout2_24) AT=3740.1n

* CHECK dout2_25 Vdout2_25ck186 = 0 time = 3740
.meas tran vdout2_25ck186 FIND v(dout2_25) AT=3740.1n

* CHECK dout2_26 Vdout2_26ck186 = 0 time = 3740
.meas tran vdout2_26ck186 FIND v(dout2_26) AT=3740.1n

* CHECK dout2_27 Vdout2_27ck186 = 1.8 time = 3740
.meas tran vdout2_27ck186 FIND v(dout2_27) AT=3740.1n

* CHECK dout2_28 Vdout2_28ck186 = 1.8 time = 3740
.meas tran vdout2_28ck186 FIND v(dout2_28) AT=3740.1n

* CHECK dout2_29 Vdout2_29ck186 = 1.8 time = 3740
.meas tran vdout2_29ck186 FIND v(dout2_29) AT=3740.1n

* CHECK dout2_30 Vdout2_30ck186 = 0 time = 3740
.meas tran vdout2_30ck186 FIND v(dout2_30) AT=3740.1n

* CHECK dout2_31 Vdout2_31ck186 = 0 time = 3740
.meas tran vdout2_31ck186 FIND v(dout2_31) AT=3740.1n

* CHECK dout1_0 Vdout1_0ck187 = 0 time = 3760
.meas tran vdout1_0ck187 FIND v(dout1_0) AT=3760.1n

* CHECK dout1_1 Vdout1_1ck187 = 1.8 time = 3760
.meas tran vdout1_1ck187 FIND v(dout1_1) AT=3760.1n

* CHECK dout1_2 Vdout1_2ck187 = 0 time = 3760
.meas tran vdout1_2ck187 FIND v(dout1_2) AT=3760.1n

* CHECK dout1_3 Vdout1_3ck187 = 0 time = 3760
.meas tran vdout1_3ck187 FIND v(dout1_3) AT=3760.1n

* CHECK dout1_4 Vdout1_4ck187 = 0 time = 3760
.meas tran vdout1_4ck187 FIND v(dout1_4) AT=3760.1n

* CHECK dout1_5 Vdout1_5ck187 = 0 time = 3760
.meas tran vdout1_5ck187 FIND v(dout1_5) AT=3760.1n

* CHECK dout1_6 Vdout1_6ck187 = 0 time = 3760
.meas tran vdout1_6ck187 FIND v(dout1_6) AT=3760.1n

* CHECK dout1_7 Vdout1_7ck187 = 1.8 time = 3760
.meas tran vdout1_7ck187 FIND v(dout1_7) AT=3760.1n

* CHECK dout1_8 Vdout1_8ck187 = 0 time = 3760
.meas tran vdout1_8ck187 FIND v(dout1_8) AT=3760.1n

* CHECK dout1_9 Vdout1_9ck187 = 0 time = 3760
.meas tran vdout1_9ck187 FIND v(dout1_9) AT=3760.1n

* CHECK dout1_10 Vdout1_10ck187 = 0 time = 3760
.meas tran vdout1_10ck187 FIND v(dout1_10) AT=3760.1n

* CHECK dout1_11 Vdout1_11ck187 = 1.8 time = 3760
.meas tran vdout1_11ck187 FIND v(dout1_11) AT=3760.1n

* CHECK dout1_12 Vdout1_12ck187 = 0 time = 3760
.meas tran vdout1_12ck187 FIND v(dout1_12) AT=3760.1n

* CHECK dout1_13 Vdout1_13ck187 = 0 time = 3760
.meas tran vdout1_13ck187 FIND v(dout1_13) AT=3760.1n

* CHECK dout1_14 Vdout1_14ck187 = 1.8 time = 3760
.meas tran vdout1_14ck187 FIND v(dout1_14) AT=3760.1n

* CHECK dout1_15 Vdout1_15ck187 = 0 time = 3760
.meas tran vdout1_15ck187 FIND v(dout1_15) AT=3760.1n

* CHECK dout1_16 Vdout1_16ck187 = 1.8 time = 3760
.meas tran vdout1_16ck187 FIND v(dout1_16) AT=3760.1n

* CHECK dout1_17 Vdout1_17ck187 = 1.8 time = 3760
.meas tran vdout1_17ck187 FIND v(dout1_17) AT=3760.1n

* CHECK dout1_18 Vdout1_18ck187 = 1.8 time = 3760
.meas tran vdout1_18ck187 FIND v(dout1_18) AT=3760.1n

* CHECK dout1_19 Vdout1_19ck187 = 0 time = 3760
.meas tran vdout1_19ck187 FIND v(dout1_19) AT=3760.1n

* CHECK dout1_20 Vdout1_20ck187 = 0 time = 3760
.meas tran vdout1_20ck187 FIND v(dout1_20) AT=3760.1n

* CHECK dout1_21 Vdout1_21ck187 = 0 time = 3760
.meas tran vdout1_21ck187 FIND v(dout1_21) AT=3760.1n

* CHECK dout1_22 Vdout1_22ck187 = 1.8 time = 3760
.meas tran vdout1_22ck187 FIND v(dout1_22) AT=3760.1n

* CHECK dout1_23 Vdout1_23ck187 = 1.8 time = 3760
.meas tran vdout1_23ck187 FIND v(dout1_23) AT=3760.1n

* CHECK dout1_24 Vdout1_24ck187 = 0 time = 3760
.meas tran vdout1_24ck187 FIND v(dout1_24) AT=3760.1n

* CHECK dout1_25 Vdout1_25ck187 = 1.8 time = 3760
.meas tran vdout1_25ck187 FIND v(dout1_25) AT=3760.1n

* CHECK dout1_26 Vdout1_26ck187 = 0 time = 3760
.meas tran vdout1_26ck187 FIND v(dout1_26) AT=3760.1n

* CHECK dout1_27 Vdout1_27ck187 = 1.8 time = 3760
.meas tran vdout1_27ck187 FIND v(dout1_27) AT=3760.1n

* CHECK dout1_28 Vdout1_28ck187 = 1.8 time = 3760
.meas tran vdout1_28ck187 FIND v(dout1_28) AT=3760.1n

* CHECK dout1_29 Vdout1_29ck187 = 1.8 time = 3760
.meas tran vdout1_29ck187 FIND v(dout1_29) AT=3760.1n

* CHECK dout1_30 Vdout1_30ck187 = 0 time = 3760
.meas tran vdout1_30ck187 FIND v(dout1_30) AT=3760.1n

* CHECK dout1_31 Vdout1_31ck187 = 1.8 time = 3760
.meas tran vdout1_31ck187 FIND v(dout1_31) AT=3760.1n

* CHECK dout2_0 Vdout2_0ck187 = 1.8 time = 3760
.meas tran vdout2_0ck187 FIND v(dout2_0) AT=3760.1n

* CHECK dout2_1 Vdout2_1ck187 = 1.8 time = 3760
.meas tran vdout2_1ck187 FIND v(dout2_1) AT=3760.1n

* CHECK dout2_2 Vdout2_2ck187 = 0 time = 3760
.meas tran vdout2_2ck187 FIND v(dout2_2) AT=3760.1n

* CHECK dout2_3 Vdout2_3ck187 = 0 time = 3760
.meas tran vdout2_3ck187 FIND v(dout2_3) AT=3760.1n

* CHECK dout2_4 Vdout2_4ck187 = 1.8 time = 3760
.meas tran vdout2_4ck187 FIND v(dout2_4) AT=3760.1n

* CHECK dout2_5 Vdout2_5ck187 = 0 time = 3760
.meas tran vdout2_5ck187 FIND v(dout2_5) AT=3760.1n

* CHECK dout2_6 Vdout2_6ck187 = 0 time = 3760
.meas tran vdout2_6ck187 FIND v(dout2_6) AT=3760.1n

* CHECK dout2_7 Vdout2_7ck187 = 0 time = 3760
.meas tran vdout2_7ck187 FIND v(dout2_7) AT=3760.1n

* CHECK dout2_8 Vdout2_8ck187 = 1.8 time = 3760
.meas tran vdout2_8ck187 FIND v(dout2_8) AT=3760.1n

* CHECK dout2_9 Vdout2_9ck187 = 0 time = 3760
.meas tran vdout2_9ck187 FIND v(dout2_9) AT=3760.1n

* CHECK dout2_10 Vdout2_10ck187 = 1.8 time = 3760
.meas tran vdout2_10ck187 FIND v(dout2_10) AT=3760.1n

* CHECK dout2_11 Vdout2_11ck187 = 1.8 time = 3760
.meas tran vdout2_11ck187 FIND v(dout2_11) AT=3760.1n

* CHECK dout2_12 Vdout2_12ck187 = 1.8 time = 3760
.meas tran vdout2_12ck187 FIND v(dout2_12) AT=3760.1n

* CHECK dout2_13 Vdout2_13ck187 = 1.8 time = 3760
.meas tran vdout2_13ck187 FIND v(dout2_13) AT=3760.1n

* CHECK dout2_14 Vdout2_14ck187 = 1.8 time = 3760
.meas tran vdout2_14ck187 FIND v(dout2_14) AT=3760.1n

* CHECK dout2_15 Vdout2_15ck187 = 1.8 time = 3760
.meas tran vdout2_15ck187 FIND v(dout2_15) AT=3760.1n

* CHECK dout2_16 Vdout2_16ck187 = 1.8 time = 3760
.meas tran vdout2_16ck187 FIND v(dout2_16) AT=3760.1n

* CHECK dout2_17 Vdout2_17ck187 = 1.8 time = 3760
.meas tran vdout2_17ck187 FIND v(dout2_17) AT=3760.1n

* CHECK dout2_18 Vdout2_18ck187 = 0 time = 3760
.meas tran vdout2_18ck187 FIND v(dout2_18) AT=3760.1n

* CHECK dout2_19 Vdout2_19ck187 = 0 time = 3760
.meas tran vdout2_19ck187 FIND v(dout2_19) AT=3760.1n

* CHECK dout2_20 Vdout2_20ck187 = 1.8 time = 3760
.meas tran vdout2_20ck187 FIND v(dout2_20) AT=3760.1n

* CHECK dout2_21 Vdout2_21ck187 = 0 time = 3760
.meas tran vdout2_21ck187 FIND v(dout2_21) AT=3760.1n

* CHECK dout2_22 Vdout2_22ck187 = 0 time = 3760
.meas tran vdout2_22ck187 FIND v(dout2_22) AT=3760.1n

* CHECK dout2_23 Vdout2_23ck187 = 1.8 time = 3760
.meas tran vdout2_23ck187 FIND v(dout2_23) AT=3760.1n

* CHECK dout2_24 Vdout2_24ck187 = 1.8 time = 3760
.meas tran vdout2_24ck187 FIND v(dout2_24) AT=3760.1n

* CHECK dout2_25 Vdout2_25ck187 = 0 time = 3760
.meas tran vdout2_25ck187 FIND v(dout2_25) AT=3760.1n

* CHECK dout2_26 Vdout2_26ck187 = 0 time = 3760
.meas tran vdout2_26ck187 FIND v(dout2_26) AT=3760.1n

* CHECK dout2_27 Vdout2_27ck187 = 1.8 time = 3760
.meas tran vdout2_27ck187 FIND v(dout2_27) AT=3760.1n

* CHECK dout2_28 Vdout2_28ck187 = 1.8 time = 3760
.meas tran vdout2_28ck187 FIND v(dout2_28) AT=3760.1n

* CHECK dout2_29 Vdout2_29ck187 = 1.8 time = 3760
.meas tran vdout2_29ck187 FIND v(dout2_29) AT=3760.1n

* CHECK dout2_30 Vdout2_30ck187 = 0 time = 3760
.meas tran vdout2_30ck187 FIND v(dout2_30) AT=3760.1n

* CHECK dout2_31 Vdout2_31ck187 = 0 time = 3760
.meas tran vdout2_31ck187 FIND v(dout2_31) AT=3760.1n

* CHECK dout1_0 Vdout1_0ck188 = 1.8 time = 3780
.meas tran vdout1_0ck188 FIND v(dout1_0) AT=3780.1n

* CHECK dout1_1 Vdout1_1ck188 = 1.8 time = 3780
.meas tran vdout1_1ck188 FIND v(dout1_1) AT=3780.1n

* CHECK dout1_2 Vdout1_2ck188 = 0 time = 3780
.meas tran vdout1_2ck188 FIND v(dout1_2) AT=3780.1n

* CHECK dout1_3 Vdout1_3ck188 = 0 time = 3780
.meas tran vdout1_3ck188 FIND v(dout1_3) AT=3780.1n

* CHECK dout1_4 Vdout1_4ck188 = 1.8 time = 3780
.meas tran vdout1_4ck188 FIND v(dout1_4) AT=3780.1n

* CHECK dout1_5 Vdout1_5ck188 = 0 time = 3780
.meas tran vdout1_5ck188 FIND v(dout1_5) AT=3780.1n

* CHECK dout1_6 Vdout1_6ck188 = 0 time = 3780
.meas tran vdout1_6ck188 FIND v(dout1_6) AT=3780.1n

* CHECK dout1_7 Vdout1_7ck188 = 0 time = 3780
.meas tran vdout1_7ck188 FIND v(dout1_7) AT=3780.1n

* CHECK dout1_8 Vdout1_8ck188 = 1.8 time = 3780
.meas tran vdout1_8ck188 FIND v(dout1_8) AT=3780.1n

* CHECK dout1_9 Vdout1_9ck188 = 0 time = 3780
.meas tran vdout1_9ck188 FIND v(dout1_9) AT=3780.1n

* CHECK dout1_10 Vdout1_10ck188 = 1.8 time = 3780
.meas tran vdout1_10ck188 FIND v(dout1_10) AT=3780.1n

* CHECK dout1_11 Vdout1_11ck188 = 1.8 time = 3780
.meas tran vdout1_11ck188 FIND v(dout1_11) AT=3780.1n

* CHECK dout1_12 Vdout1_12ck188 = 1.8 time = 3780
.meas tran vdout1_12ck188 FIND v(dout1_12) AT=3780.1n

* CHECK dout1_13 Vdout1_13ck188 = 1.8 time = 3780
.meas tran vdout1_13ck188 FIND v(dout1_13) AT=3780.1n

* CHECK dout1_14 Vdout1_14ck188 = 1.8 time = 3780
.meas tran vdout1_14ck188 FIND v(dout1_14) AT=3780.1n

* CHECK dout1_15 Vdout1_15ck188 = 1.8 time = 3780
.meas tran vdout1_15ck188 FIND v(dout1_15) AT=3780.1n

* CHECK dout1_16 Vdout1_16ck188 = 1.8 time = 3780
.meas tran vdout1_16ck188 FIND v(dout1_16) AT=3780.1n

* CHECK dout1_17 Vdout1_17ck188 = 1.8 time = 3780
.meas tran vdout1_17ck188 FIND v(dout1_17) AT=3780.1n

* CHECK dout1_18 Vdout1_18ck188 = 0 time = 3780
.meas tran vdout1_18ck188 FIND v(dout1_18) AT=3780.1n

* CHECK dout1_19 Vdout1_19ck188 = 0 time = 3780
.meas tran vdout1_19ck188 FIND v(dout1_19) AT=3780.1n

* CHECK dout1_20 Vdout1_20ck188 = 1.8 time = 3780
.meas tran vdout1_20ck188 FIND v(dout1_20) AT=3780.1n

* CHECK dout1_21 Vdout1_21ck188 = 0 time = 3780
.meas tran vdout1_21ck188 FIND v(dout1_21) AT=3780.1n

* CHECK dout1_22 Vdout1_22ck188 = 0 time = 3780
.meas tran vdout1_22ck188 FIND v(dout1_22) AT=3780.1n

* CHECK dout1_23 Vdout1_23ck188 = 1.8 time = 3780
.meas tran vdout1_23ck188 FIND v(dout1_23) AT=3780.1n

* CHECK dout1_24 Vdout1_24ck188 = 1.8 time = 3780
.meas tran vdout1_24ck188 FIND v(dout1_24) AT=3780.1n

* CHECK dout1_25 Vdout1_25ck188 = 0 time = 3780
.meas tran vdout1_25ck188 FIND v(dout1_25) AT=3780.1n

* CHECK dout1_26 Vdout1_26ck188 = 0 time = 3780
.meas tran vdout1_26ck188 FIND v(dout1_26) AT=3780.1n

* CHECK dout1_27 Vdout1_27ck188 = 1.8 time = 3780
.meas tran vdout1_27ck188 FIND v(dout1_27) AT=3780.1n

* CHECK dout1_28 Vdout1_28ck188 = 1.8 time = 3780
.meas tran vdout1_28ck188 FIND v(dout1_28) AT=3780.1n

* CHECK dout1_29 Vdout1_29ck188 = 1.8 time = 3780
.meas tran vdout1_29ck188 FIND v(dout1_29) AT=3780.1n

* CHECK dout1_30 Vdout1_30ck188 = 0 time = 3780
.meas tran vdout1_30ck188 FIND v(dout1_30) AT=3780.1n

* CHECK dout1_31 Vdout1_31ck188 = 0 time = 3780
.meas tran vdout1_31ck188 FIND v(dout1_31) AT=3780.1n

* CHECK dout1_0 Vdout1_0ck189 = 0 time = 3800
.meas tran vdout1_0ck189 FIND v(dout1_0) AT=3800.1n

* CHECK dout1_1 Vdout1_1ck189 = 1.8 time = 3800
.meas tran vdout1_1ck189 FIND v(dout1_1) AT=3800.1n

* CHECK dout1_2 Vdout1_2ck189 = 0 time = 3800
.meas tran vdout1_2ck189 FIND v(dout1_2) AT=3800.1n

* CHECK dout1_3 Vdout1_3ck189 = 0 time = 3800
.meas tran vdout1_3ck189 FIND v(dout1_3) AT=3800.1n

* CHECK dout1_4 Vdout1_4ck189 = 0 time = 3800
.meas tran vdout1_4ck189 FIND v(dout1_4) AT=3800.1n

* CHECK dout1_5 Vdout1_5ck189 = 0 time = 3800
.meas tran vdout1_5ck189 FIND v(dout1_5) AT=3800.1n

* CHECK dout1_6 Vdout1_6ck189 = 0 time = 3800
.meas tran vdout1_6ck189 FIND v(dout1_6) AT=3800.1n

* CHECK dout1_7 Vdout1_7ck189 = 1.8 time = 3800
.meas tran vdout1_7ck189 FIND v(dout1_7) AT=3800.1n

* CHECK dout1_8 Vdout1_8ck189 = 0 time = 3800
.meas tran vdout1_8ck189 FIND v(dout1_8) AT=3800.1n

* CHECK dout1_9 Vdout1_9ck189 = 0 time = 3800
.meas tran vdout1_9ck189 FIND v(dout1_9) AT=3800.1n

* CHECK dout1_10 Vdout1_10ck189 = 0 time = 3800
.meas tran vdout1_10ck189 FIND v(dout1_10) AT=3800.1n

* CHECK dout1_11 Vdout1_11ck189 = 1.8 time = 3800
.meas tran vdout1_11ck189 FIND v(dout1_11) AT=3800.1n

* CHECK dout1_12 Vdout1_12ck189 = 0 time = 3800
.meas tran vdout1_12ck189 FIND v(dout1_12) AT=3800.1n

* CHECK dout1_13 Vdout1_13ck189 = 0 time = 3800
.meas tran vdout1_13ck189 FIND v(dout1_13) AT=3800.1n

* CHECK dout1_14 Vdout1_14ck189 = 1.8 time = 3800
.meas tran vdout1_14ck189 FIND v(dout1_14) AT=3800.1n

* CHECK dout1_15 Vdout1_15ck189 = 0 time = 3800
.meas tran vdout1_15ck189 FIND v(dout1_15) AT=3800.1n

* CHECK dout1_16 Vdout1_16ck189 = 1.8 time = 3800
.meas tran vdout1_16ck189 FIND v(dout1_16) AT=3800.1n

* CHECK dout1_17 Vdout1_17ck189 = 1.8 time = 3800
.meas tran vdout1_17ck189 FIND v(dout1_17) AT=3800.1n

* CHECK dout1_18 Vdout1_18ck189 = 1.8 time = 3800
.meas tran vdout1_18ck189 FIND v(dout1_18) AT=3800.1n

* CHECK dout1_19 Vdout1_19ck189 = 0 time = 3800
.meas tran vdout1_19ck189 FIND v(dout1_19) AT=3800.1n

* CHECK dout1_20 Vdout1_20ck189 = 0 time = 3800
.meas tran vdout1_20ck189 FIND v(dout1_20) AT=3800.1n

* CHECK dout1_21 Vdout1_21ck189 = 0 time = 3800
.meas tran vdout1_21ck189 FIND v(dout1_21) AT=3800.1n

* CHECK dout1_22 Vdout1_22ck189 = 1.8 time = 3800
.meas tran vdout1_22ck189 FIND v(dout1_22) AT=3800.1n

* CHECK dout1_23 Vdout1_23ck189 = 1.8 time = 3800
.meas tran vdout1_23ck189 FIND v(dout1_23) AT=3800.1n

* CHECK dout1_24 Vdout1_24ck189 = 0 time = 3800
.meas tran vdout1_24ck189 FIND v(dout1_24) AT=3800.1n

* CHECK dout1_25 Vdout1_25ck189 = 1.8 time = 3800
.meas tran vdout1_25ck189 FIND v(dout1_25) AT=3800.1n

* CHECK dout1_26 Vdout1_26ck189 = 0 time = 3800
.meas tran vdout1_26ck189 FIND v(dout1_26) AT=3800.1n

* CHECK dout1_27 Vdout1_27ck189 = 1.8 time = 3800
.meas tran vdout1_27ck189 FIND v(dout1_27) AT=3800.1n

* CHECK dout1_28 Vdout1_28ck189 = 1.8 time = 3800
.meas tran vdout1_28ck189 FIND v(dout1_28) AT=3800.1n

* CHECK dout1_29 Vdout1_29ck189 = 1.8 time = 3800
.meas tran vdout1_29ck189 FIND v(dout1_29) AT=3800.1n

* CHECK dout1_30 Vdout1_30ck189 = 0 time = 3800
.meas tran vdout1_30ck189 FIND v(dout1_30) AT=3800.1n

* CHECK dout1_31 Vdout1_31ck189 = 1.8 time = 3800
.meas tran vdout1_31ck189 FIND v(dout1_31) AT=3800.1n

* CHECK dout2_0 Vdout2_0ck189 = 1.8 time = 3800
.meas tran vdout2_0ck189 FIND v(dout2_0) AT=3800.1n

* CHECK dout2_1 Vdout2_1ck189 = 0 time = 3800
.meas tran vdout2_1ck189 FIND v(dout2_1) AT=3800.1n

* CHECK dout2_2 Vdout2_2ck189 = 1.8 time = 3800
.meas tran vdout2_2ck189 FIND v(dout2_2) AT=3800.1n

* CHECK dout2_3 Vdout2_3ck189 = 0 time = 3800
.meas tran vdout2_3ck189 FIND v(dout2_3) AT=3800.1n

* CHECK dout2_4 Vdout2_4ck189 = 1.8 time = 3800
.meas tran vdout2_4ck189 FIND v(dout2_4) AT=3800.1n

* CHECK dout2_5 Vdout2_5ck189 = 1.8 time = 3800
.meas tran vdout2_5ck189 FIND v(dout2_5) AT=3800.1n

* CHECK dout2_6 Vdout2_6ck189 = 1.8 time = 3800
.meas tran vdout2_6ck189 FIND v(dout2_6) AT=3800.1n

* CHECK dout2_7 Vdout2_7ck189 = 0 time = 3800
.meas tran vdout2_7ck189 FIND v(dout2_7) AT=3800.1n

* CHECK dout2_8 Vdout2_8ck189 = 0 time = 3800
.meas tran vdout2_8ck189 FIND v(dout2_8) AT=3800.1n

* CHECK dout2_9 Vdout2_9ck189 = 0 time = 3800
.meas tran vdout2_9ck189 FIND v(dout2_9) AT=3800.1n

* CHECK dout2_10 Vdout2_10ck189 = 0 time = 3800
.meas tran vdout2_10ck189 FIND v(dout2_10) AT=3800.1n

* CHECK dout2_11 Vdout2_11ck189 = 1.8 time = 3800
.meas tran vdout2_11ck189 FIND v(dout2_11) AT=3800.1n

* CHECK dout2_12 Vdout2_12ck189 = 1.8 time = 3800
.meas tran vdout2_12ck189 FIND v(dout2_12) AT=3800.1n

* CHECK dout2_13 Vdout2_13ck189 = 0 time = 3800
.meas tran vdout2_13ck189 FIND v(dout2_13) AT=3800.1n

* CHECK dout2_14 Vdout2_14ck189 = 0 time = 3800
.meas tran vdout2_14ck189 FIND v(dout2_14) AT=3800.1n

* CHECK dout2_15 Vdout2_15ck189 = 1.8 time = 3800
.meas tran vdout2_15ck189 FIND v(dout2_15) AT=3800.1n

* CHECK dout2_16 Vdout2_16ck189 = 0 time = 3800
.meas tran vdout2_16ck189 FIND v(dout2_16) AT=3800.1n

* CHECK dout2_17 Vdout2_17ck189 = 0 time = 3800
.meas tran vdout2_17ck189 FIND v(dout2_17) AT=3800.1n

* CHECK dout2_18 Vdout2_18ck189 = 0 time = 3800
.meas tran vdout2_18ck189 FIND v(dout2_18) AT=3800.1n

* CHECK dout2_19 Vdout2_19ck189 = 1.8 time = 3800
.meas tran vdout2_19ck189 FIND v(dout2_19) AT=3800.1n

* CHECK dout2_20 Vdout2_20ck189 = 0 time = 3800
.meas tran vdout2_20ck189 FIND v(dout2_20) AT=3800.1n

* CHECK dout2_21 Vdout2_21ck189 = 1.8 time = 3800
.meas tran vdout2_21ck189 FIND v(dout2_21) AT=3800.1n

* CHECK dout2_22 Vdout2_22ck189 = 1.8 time = 3800
.meas tran vdout2_22ck189 FIND v(dout2_22) AT=3800.1n

* CHECK dout2_23 Vdout2_23ck189 = 1.8 time = 3800
.meas tran vdout2_23ck189 FIND v(dout2_23) AT=3800.1n

* CHECK dout2_24 Vdout2_24ck189 = 0 time = 3800
.meas tran vdout2_24ck189 FIND v(dout2_24) AT=3800.1n

* CHECK dout2_25 Vdout2_25ck189 = 0 time = 3800
.meas tran vdout2_25ck189 FIND v(dout2_25) AT=3800.1n

* CHECK dout2_26 Vdout2_26ck189 = 0 time = 3800
.meas tran vdout2_26ck189 FIND v(dout2_26) AT=3800.1n

* CHECK dout2_27 Vdout2_27ck189 = 1.8 time = 3800
.meas tran vdout2_27ck189 FIND v(dout2_27) AT=3800.1n

* CHECK dout2_28 Vdout2_28ck189 = 1.8 time = 3800
.meas tran vdout2_28ck189 FIND v(dout2_28) AT=3800.1n

* CHECK dout2_29 Vdout2_29ck189 = 0 time = 3800
.meas tran vdout2_29ck189 FIND v(dout2_29) AT=3800.1n

* CHECK dout2_30 Vdout2_30ck189 = 0 time = 3800
.meas tran vdout2_30ck189 FIND v(dout2_30) AT=3800.1n

* CHECK dout2_31 Vdout2_31ck189 = 0 time = 3800
.meas tran vdout2_31ck189 FIND v(dout2_31) AT=3800.1n

* CHECK dout1_0 Vdout1_0ck190 = 1.8 time = 3820
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=3820.1n

* CHECK dout1_1 Vdout1_1ck190 = 0 time = 3820
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=3820.1n

* CHECK dout1_2 Vdout1_2ck190 = 1.8 time = 3820
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=3820.1n

* CHECK dout1_3 Vdout1_3ck190 = 0 time = 3820
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=3820.1n

* CHECK dout1_4 Vdout1_4ck190 = 1.8 time = 3820
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=3820.1n

* CHECK dout1_5 Vdout1_5ck190 = 1.8 time = 3820
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=3820.1n

* CHECK dout1_6 Vdout1_6ck190 = 1.8 time = 3820
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=3820.1n

* CHECK dout1_7 Vdout1_7ck190 = 0 time = 3820
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=3820.1n

* CHECK dout1_8 Vdout1_8ck190 = 0 time = 3820
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=3820.1n

* CHECK dout1_9 Vdout1_9ck190 = 0 time = 3820
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=3820.1n

* CHECK dout1_10 Vdout1_10ck190 = 0 time = 3820
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=3820.1n

* CHECK dout1_11 Vdout1_11ck190 = 1.8 time = 3820
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=3820.1n

* CHECK dout1_12 Vdout1_12ck190 = 1.8 time = 3820
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=3820.1n

* CHECK dout1_13 Vdout1_13ck190 = 0 time = 3820
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=3820.1n

* CHECK dout1_14 Vdout1_14ck190 = 0 time = 3820
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=3820.1n

* CHECK dout1_15 Vdout1_15ck190 = 1.8 time = 3820
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=3820.1n

* CHECK dout1_16 Vdout1_16ck190 = 0 time = 3820
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=3820.1n

* CHECK dout1_17 Vdout1_17ck190 = 0 time = 3820
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=3820.1n

* CHECK dout1_18 Vdout1_18ck190 = 0 time = 3820
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=3820.1n

* CHECK dout1_19 Vdout1_19ck190 = 1.8 time = 3820
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=3820.1n

* CHECK dout1_20 Vdout1_20ck190 = 0 time = 3820
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=3820.1n

* CHECK dout1_21 Vdout1_21ck190 = 1.8 time = 3820
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=3820.1n

* CHECK dout1_22 Vdout1_22ck190 = 1.8 time = 3820
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=3820.1n

* CHECK dout1_23 Vdout1_23ck190 = 1.8 time = 3820
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=3820.1n

* CHECK dout1_24 Vdout1_24ck190 = 0 time = 3820
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=3820.1n

* CHECK dout1_25 Vdout1_25ck190 = 0 time = 3820
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=3820.1n

* CHECK dout1_26 Vdout1_26ck190 = 0 time = 3820
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=3820.1n

* CHECK dout1_27 Vdout1_27ck190 = 1.8 time = 3820
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=3820.1n

* CHECK dout1_28 Vdout1_28ck190 = 1.8 time = 3820
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=3820.1n

* CHECK dout1_29 Vdout1_29ck190 = 0 time = 3820
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=3820.1n

* CHECK dout1_30 Vdout1_30ck190 = 0 time = 3820
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=3820.1n

* CHECK dout1_31 Vdout1_31ck190 = 0 time = 3820
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=3820.1n

* CHECK dout2_0 Vdout2_0ck190 = 0 time = 3820
.meas tran vdout2_0ck190 FIND v(dout2_0) AT=3820.1n

* CHECK dout2_1 Vdout2_1ck190 = 1.8 time = 3820
.meas tran vdout2_1ck190 FIND v(dout2_1) AT=3820.1n

* CHECK dout2_2 Vdout2_2ck190 = 0 time = 3820
.meas tran vdout2_2ck190 FIND v(dout2_2) AT=3820.1n

* CHECK dout2_3 Vdout2_3ck190 = 0 time = 3820
.meas tran vdout2_3ck190 FIND v(dout2_3) AT=3820.1n

* CHECK dout2_4 Vdout2_4ck190 = 1.8 time = 3820
.meas tran vdout2_4ck190 FIND v(dout2_4) AT=3820.1n

* CHECK dout2_5 Vdout2_5ck190 = 1.8 time = 3820
.meas tran vdout2_5ck190 FIND v(dout2_5) AT=3820.1n

* CHECK dout2_6 Vdout2_6ck190 = 0 time = 3820
.meas tran vdout2_6ck190 FIND v(dout2_6) AT=3820.1n

* CHECK dout2_7 Vdout2_7ck190 = 1.8 time = 3820
.meas tran vdout2_7ck190 FIND v(dout2_7) AT=3820.1n

* CHECK dout2_8 Vdout2_8ck190 = 0 time = 3820
.meas tran vdout2_8ck190 FIND v(dout2_8) AT=3820.1n

* CHECK dout2_9 Vdout2_9ck190 = 0 time = 3820
.meas tran vdout2_9ck190 FIND v(dout2_9) AT=3820.1n

* CHECK dout2_10 Vdout2_10ck190 = 1.8 time = 3820
.meas tran vdout2_10ck190 FIND v(dout2_10) AT=3820.1n

* CHECK dout2_11 Vdout2_11ck190 = 1.8 time = 3820
.meas tran vdout2_11ck190 FIND v(dout2_11) AT=3820.1n

* CHECK dout2_12 Vdout2_12ck190 = 1.8 time = 3820
.meas tran vdout2_12ck190 FIND v(dout2_12) AT=3820.1n

* CHECK dout2_13 Vdout2_13ck190 = 1.8 time = 3820
.meas tran vdout2_13ck190 FIND v(dout2_13) AT=3820.1n

* CHECK dout2_14 Vdout2_14ck190 = 0 time = 3820
.meas tran vdout2_14ck190 FIND v(dout2_14) AT=3820.1n

* CHECK dout2_15 Vdout2_15ck190 = 0 time = 3820
.meas tran vdout2_15ck190 FIND v(dout2_15) AT=3820.1n

* CHECK dout2_16 Vdout2_16ck190 = 1.8 time = 3820
.meas tran vdout2_16ck190 FIND v(dout2_16) AT=3820.1n

* CHECK dout2_17 Vdout2_17ck190 = 1.8 time = 3820
.meas tran vdout2_17ck190 FIND v(dout2_17) AT=3820.1n

* CHECK dout2_18 Vdout2_18ck190 = 1.8 time = 3820
.meas tran vdout2_18ck190 FIND v(dout2_18) AT=3820.1n

* CHECK dout2_19 Vdout2_19ck190 = 0 time = 3820
.meas tran vdout2_19ck190 FIND v(dout2_19) AT=3820.1n

* CHECK dout2_20 Vdout2_20ck190 = 1.8 time = 3820
.meas tran vdout2_20ck190 FIND v(dout2_20) AT=3820.1n

* CHECK dout2_21 Vdout2_21ck190 = 0 time = 3820
.meas tran vdout2_21ck190 FIND v(dout2_21) AT=3820.1n

* CHECK dout2_22 Vdout2_22ck190 = 0 time = 3820
.meas tran vdout2_22ck190 FIND v(dout2_22) AT=3820.1n

* CHECK dout2_23 Vdout2_23ck190 = 0 time = 3820
.meas tran vdout2_23ck190 FIND v(dout2_23) AT=3820.1n

* CHECK dout2_24 Vdout2_24ck190 = 0 time = 3820
.meas tran vdout2_24ck190 FIND v(dout2_24) AT=3820.1n

* CHECK dout2_25 Vdout2_25ck190 = 0 time = 3820
.meas tran vdout2_25ck190 FIND v(dout2_25) AT=3820.1n

* CHECK dout2_26 Vdout2_26ck190 = 1.8 time = 3820
.meas tran vdout2_26ck190 FIND v(dout2_26) AT=3820.1n

* CHECK dout2_27 Vdout2_27ck190 = 1.8 time = 3820
.meas tran vdout2_27ck190 FIND v(dout2_27) AT=3820.1n

* CHECK dout2_28 Vdout2_28ck190 = 0 time = 3820
.meas tran vdout2_28ck190 FIND v(dout2_28) AT=3820.1n

* CHECK dout2_29 Vdout2_29ck190 = 1.8 time = 3820
.meas tran vdout2_29ck190 FIND v(dout2_29) AT=3820.1n

* CHECK dout2_30 Vdout2_30ck190 = 1.8 time = 3820
.meas tran vdout2_30ck190 FIND v(dout2_30) AT=3820.1n

* CHECK dout2_31 Vdout2_31ck190 = 0 time = 3820
.meas tran vdout2_31ck190 FIND v(dout2_31) AT=3820.1n

* CHECK dout1_0 Vdout1_0ck191 = 0 time = 3840
.meas tran vdout1_0ck191 FIND v(dout1_0) AT=3840.1n

* CHECK dout1_1 Vdout1_1ck191 = 1.8 time = 3840
.meas tran vdout1_1ck191 FIND v(dout1_1) AT=3840.1n

* CHECK dout1_2 Vdout1_2ck191 = 0 time = 3840
.meas tran vdout1_2ck191 FIND v(dout1_2) AT=3840.1n

* CHECK dout1_3 Vdout1_3ck191 = 0 time = 3840
.meas tran vdout1_3ck191 FIND v(dout1_3) AT=3840.1n

* CHECK dout1_4 Vdout1_4ck191 = 0 time = 3840
.meas tran vdout1_4ck191 FIND v(dout1_4) AT=3840.1n

* CHECK dout1_5 Vdout1_5ck191 = 0 time = 3840
.meas tran vdout1_5ck191 FIND v(dout1_5) AT=3840.1n

* CHECK dout1_6 Vdout1_6ck191 = 0 time = 3840
.meas tran vdout1_6ck191 FIND v(dout1_6) AT=3840.1n

* CHECK dout1_7 Vdout1_7ck191 = 1.8 time = 3840
.meas tran vdout1_7ck191 FIND v(dout1_7) AT=3840.1n

* CHECK dout1_8 Vdout1_8ck191 = 0 time = 3840
.meas tran vdout1_8ck191 FIND v(dout1_8) AT=3840.1n

* CHECK dout1_9 Vdout1_9ck191 = 0 time = 3840
.meas tran vdout1_9ck191 FIND v(dout1_9) AT=3840.1n

* CHECK dout1_10 Vdout1_10ck191 = 0 time = 3840
.meas tran vdout1_10ck191 FIND v(dout1_10) AT=3840.1n

* CHECK dout1_11 Vdout1_11ck191 = 1.8 time = 3840
.meas tran vdout1_11ck191 FIND v(dout1_11) AT=3840.1n

* CHECK dout1_12 Vdout1_12ck191 = 0 time = 3840
.meas tran vdout1_12ck191 FIND v(dout1_12) AT=3840.1n

* CHECK dout1_13 Vdout1_13ck191 = 0 time = 3840
.meas tran vdout1_13ck191 FIND v(dout1_13) AT=3840.1n

* CHECK dout1_14 Vdout1_14ck191 = 1.8 time = 3840
.meas tran vdout1_14ck191 FIND v(dout1_14) AT=3840.1n

* CHECK dout1_15 Vdout1_15ck191 = 0 time = 3840
.meas tran vdout1_15ck191 FIND v(dout1_15) AT=3840.1n

* CHECK dout1_16 Vdout1_16ck191 = 1.8 time = 3840
.meas tran vdout1_16ck191 FIND v(dout1_16) AT=3840.1n

* CHECK dout1_17 Vdout1_17ck191 = 1.8 time = 3840
.meas tran vdout1_17ck191 FIND v(dout1_17) AT=3840.1n

* CHECK dout1_18 Vdout1_18ck191 = 1.8 time = 3840
.meas tran vdout1_18ck191 FIND v(dout1_18) AT=3840.1n

* CHECK dout1_19 Vdout1_19ck191 = 0 time = 3840
.meas tran vdout1_19ck191 FIND v(dout1_19) AT=3840.1n

* CHECK dout1_20 Vdout1_20ck191 = 0 time = 3840
.meas tran vdout1_20ck191 FIND v(dout1_20) AT=3840.1n

* CHECK dout1_21 Vdout1_21ck191 = 0 time = 3840
.meas tran vdout1_21ck191 FIND v(dout1_21) AT=3840.1n

* CHECK dout1_22 Vdout1_22ck191 = 1.8 time = 3840
.meas tran vdout1_22ck191 FIND v(dout1_22) AT=3840.1n

* CHECK dout1_23 Vdout1_23ck191 = 1.8 time = 3840
.meas tran vdout1_23ck191 FIND v(dout1_23) AT=3840.1n

* CHECK dout1_24 Vdout1_24ck191 = 0 time = 3840
.meas tran vdout1_24ck191 FIND v(dout1_24) AT=3840.1n

* CHECK dout1_25 Vdout1_25ck191 = 1.8 time = 3840
.meas tran vdout1_25ck191 FIND v(dout1_25) AT=3840.1n

* CHECK dout1_26 Vdout1_26ck191 = 0 time = 3840
.meas tran vdout1_26ck191 FIND v(dout1_26) AT=3840.1n

* CHECK dout1_27 Vdout1_27ck191 = 1.8 time = 3840
.meas tran vdout1_27ck191 FIND v(dout1_27) AT=3840.1n

* CHECK dout1_28 Vdout1_28ck191 = 1.8 time = 3840
.meas tran vdout1_28ck191 FIND v(dout1_28) AT=3840.1n

* CHECK dout1_29 Vdout1_29ck191 = 1.8 time = 3840
.meas tran vdout1_29ck191 FIND v(dout1_29) AT=3840.1n

* CHECK dout1_30 Vdout1_30ck191 = 0 time = 3840
.meas tran vdout1_30ck191 FIND v(dout1_30) AT=3840.1n

* CHECK dout1_31 Vdout1_31ck191 = 1.8 time = 3840
.meas tran vdout1_31ck191 FIND v(dout1_31) AT=3840.1n

* CHECK dout2_0 Vdout2_0ck191 = 0 time = 3840
.meas tran vdout2_0ck191 FIND v(dout2_0) AT=3840.1n

* CHECK dout2_1 Vdout2_1ck191 = 1.8 time = 3840
.meas tran vdout2_1ck191 FIND v(dout2_1) AT=3840.1n

* CHECK dout2_2 Vdout2_2ck191 = 0 time = 3840
.meas tran vdout2_2ck191 FIND v(dout2_2) AT=3840.1n

* CHECK dout2_3 Vdout2_3ck191 = 0 time = 3840
.meas tran vdout2_3ck191 FIND v(dout2_3) AT=3840.1n

* CHECK dout2_4 Vdout2_4ck191 = 1.8 time = 3840
.meas tran vdout2_4ck191 FIND v(dout2_4) AT=3840.1n

* CHECK dout2_5 Vdout2_5ck191 = 1.8 time = 3840
.meas tran vdout2_5ck191 FIND v(dout2_5) AT=3840.1n

* CHECK dout2_6 Vdout2_6ck191 = 0 time = 3840
.meas tran vdout2_6ck191 FIND v(dout2_6) AT=3840.1n

* CHECK dout2_7 Vdout2_7ck191 = 1.8 time = 3840
.meas tran vdout2_7ck191 FIND v(dout2_7) AT=3840.1n

* CHECK dout2_8 Vdout2_8ck191 = 0 time = 3840
.meas tran vdout2_8ck191 FIND v(dout2_8) AT=3840.1n

* CHECK dout2_9 Vdout2_9ck191 = 0 time = 3840
.meas tran vdout2_9ck191 FIND v(dout2_9) AT=3840.1n

* CHECK dout2_10 Vdout2_10ck191 = 1.8 time = 3840
.meas tran vdout2_10ck191 FIND v(dout2_10) AT=3840.1n

* CHECK dout2_11 Vdout2_11ck191 = 1.8 time = 3840
.meas tran vdout2_11ck191 FIND v(dout2_11) AT=3840.1n

* CHECK dout2_12 Vdout2_12ck191 = 1.8 time = 3840
.meas tran vdout2_12ck191 FIND v(dout2_12) AT=3840.1n

* CHECK dout2_13 Vdout2_13ck191 = 1.8 time = 3840
.meas tran vdout2_13ck191 FIND v(dout2_13) AT=3840.1n

* CHECK dout2_14 Vdout2_14ck191 = 0 time = 3840
.meas tran vdout2_14ck191 FIND v(dout2_14) AT=3840.1n

* CHECK dout2_15 Vdout2_15ck191 = 0 time = 3840
.meas tran vdout2_15ck191 FIND v(dout2_15) AT=3840.1n

* CHECK dout2_16 Vdout2_16ck191 = 1.8 time = 3840
.meas tran vdout2_16ck191 FIND v(dout2_16) AT=3840.1n

* CHECK dout2_17 Vdout2_17ck191 = 1.8 time = 3840
.meas tran vdout2_17ck191 FIND v(dout2_17) AT=3840.1n

* CHECK dout2_18 Vdout2_18ck191 = 1.8 time = 3840
.meas tran vdout2_18ck191 FIND v(dout2_18) AT=3840.1n

* CHECK dout2_19 Vdout2_19ck191 = 0 time = 3840
.meas tran vdout2_19ck191 FIND v(dout2_19) AT=3840.1n

* CHECK dout2_20 Vdout2_20ck191 = 1.8 time = 3840
.meas tran vdout2_20ck191 FIND v(dout2_20) AT=3840.1n

* CHECK dout2_21 Vdout2_21ck191 = 0 time = 3840
.meas tran vdout2_21ck191 FIND v(dout2_21) AT=3840.1n

* CHECK dout2_22 Vdout2_22ck191 = 0 time = 3840
.meas tran vdout2_22ck191 FIND v(dout2_22) AT=3840.1n

* CHECK dout2_23 Vdout2_23ck191 = 0 time = 3840
.meas tran vdout2_23ck191 FIND v(dout2_23) AT=3840.1n

* CHECK dout2_24 Vdout2_24ck191 = 0 time = 3840
.meas tran vdout2_24ck191 FIND v(dout2_24) AT=3840.1n

* CHECK dout2_25 Vdout2_25ck191 = 0 time = 3840
.meas tran vdout2_25ck191 FIND v(dout2_25) AT=3840.1n

* CHECK dout2_26 Vdout2_26ck191 = 1.8 time = 3840
.meas tran vdout2_26ck191 FIND v(dout2_26) AT=3840.1n

* CHECK dout2_27 Vdout2_27ck191 = 1.8 time = 3840
.meas tran vdout2_27ck191 FIND v(dout2_27) AT=3840.1n

* CHECK dout2_28 Vdout2_28ck191 = 0 time = 3840
.meas tran vdout2_28ck191 FIND v(dout2_28) AT=3840.1n

* CHECK dout2_29 Vdout2_29ck191 = 1.8 time = 3840
.meas tran vdout2_29ck191 FIND v(dout2_29) AT=3840.1n

* CHECK dout2_30 Vdout2_30ck191 = 1.8 time = 3840
.meas tran vdout2_30ck191 FIND v(dout2_30) AT=3840.1n

* CHECK dout2_31 Vdout2_31ck191 = 0 time = 3840
.meas tran vdout2_31ck191 FIND v(dout2_31) AT=3840.1n

* CHECK dout1_0 Vdout1_0ck192 = 0 time = 3860
.meas tran vdout1_0ck192 FIND v(dout1_0) AT=3860.1n

* CHECK dout1_1 Vdout1_1ck192 = 1.8 time = 3860
.meas tran vdout1_1ck192 FIND v(dout1_1) AT=3860.1n

* CHECK dout1_2 Vdout1_2ck192 = 0 time = 3860
.meas tran vdout1_2ck192 FIND v(dout1_2) AT=3860.1n

* CHECK dout1_3 Vdout1_3ck192 = 0 time = 3860
.meas tran vdout1_3ck192 FIND v(dout1_3) AT=3860.1n

* CHECK dout1_4 Vdout1_4ck192 = 1.8 time = 3860
.meas tran vdout1_4ck192 FIND v(dout1_4) AT=3860.1n

* CHECK dout1_5 Vdout1_5ck192 = 1.8 time = 3860
.meas tran vdout1_5ck192 FIND v(dout1_5) AT=3860.1n

* CHECK dout1_6 Vdout1_6ck192 = 0 time = 3860
.meas tran vdout1_6ck192 FIND v(dout1_6) AT=3860.1n

* CHECK dout1_7 Vdout1_7ck192 = 1.8 time = 3860
.meas tran vdout1_7ck192 FIND v(dout1_7) AT=3860.1n

* CHECK dout1_8 Vdout1_8ck192 = 0 time = 3860
.meas tran vdout1_8ck192 FIND v(dout1_8) AT=3860.1n

* CHECK dout1_9 Vdout1_9ck192 = 0 time = 3860
.meas tran vdout1_9ck192 FIND v(dout1_9) AT=3860.1n

* CHECK dout1_10 Vdout1_10ck192 = 1.8 time = 3860
.meas tran vdout1_10ck192 FIND v(dout1_10) AT=3860.1n

* CHECK dout1_11 Vdout1_11ck192 = 1.8 time = 3860
.meas tran vdout1_11ck192 FIND v(dout1_11) AT=3860.1n

* CHECK dout1_12 Vdout1_12ck192 = 1.8 time = 3860
.meas tran vdout1_12ck192 FIND v(dout1_12) AT=3860.1n

* CHECK dout1_13 Vdout1_13ck192 = 1.8 time = 3860
.meas tran vdout1_13ck192 FIND v(dout1_13) AT=3860.1n

* CHECK dout1_14 Vdout1_14ck192 = 0 time = 3860
.meas tran vdout1_14ck192 FIND v(dout1_14) AT=3860.1n

* CHECK dout1_15 Vdout1_15ck192 = 0 time = 3860
.meas tran vdout1_15ck192 FIND v(dout1_15) AT=3860.1n

* CHECK dout1_16 Vdout1_16ck192 = 1.8 time = 3860
.meas tran vdout1_16ck192 FIND v(dout1_16) AT=3860.1n

* CHECK dout1_17 Vdout1_17ck192 = 1.8 time = 3860
.meas tran vdout1_17ck192 FIND v(dout1_17) AT=3860.1n

* CHECK dout1_18 Vdout1_18ck192 = 1.8 time = 3860
.meas tran vdout1_18ck192 FIND v(dout1_18) AT=3860.1n

* CHECK dout1_19 Vdout1_19ck192 = 0 time = 3860
.meas tran vdout1_19ck192 FIND v(dout1_19) AT=3860.1n

* CHECK dout1_20 Vdout1_20ck192 = 1.8 time = 3860
.meas tran vdout1_20ck192 FIND v(dout1_20) AT=3860.1n

* CHECK dout1_21 Vdout1_21ck192 = 0 time = 3860
.meas tran vdout1_21ck192 FIND v(dout1_21) AT=3860.1n

* CHECK dout1_22 Vdout1_22ck192 = 0 time = 3860
.meas tran vdout1_22ck192 FIND v(dout1_22) AT=3860.1n

* CHECK dout1_23 Vdout1_23ck192 = 0 time = 3860
.meas tran vdout1_23ck192 FIND v(dout1_23) AT=3860.1n

* CHECK dout1_24 Vdout1_24ck192 = 0 time = 3860
.meas tran vdout1_24ck192 FIND v(dout1_24) AT=3860.1n

* CHECK dout1_25 Vdout1_25ck192 = 0 time = 3860
.meas tran vdout1_25ck192 FIND v(dout1_25) AT=3860.1n

* CHECK dout1_26 Vdout1_26ck192 = 1.8 time = 3860
.meas tran vdout1_26ck192 FIND v(dout1_26) AT=3860.1n

* CHECK dout1_27 Vdout1_27ck192 = 1.8 time = 3860
.meas tran vdout1_27ck192 FIND v(dout1_27) AT=3860.1n

* CHECK dout1_28 Vdout1_28ck192 = 0 time = 3860
.meas tran vdout1_28ck192 FIND v(dout1_28) AT=3860.1n

* CHECK dout1_29 Vdout1_29ck192 = 1.8 time = 3860
.meas tran vdout1_29ck192 FIND v(dout1_29) AT=3860.1n

* CHECK dout1_30 Vdout1_30ck192 = 1.8 time = 3860
.meas tran vdout1_30ck192 FIND v(dout1_30) AT=3860.1n

* CHECK dout1_31 Vdout1_31ck192 = 0 time = 3860
.meas tran vdout1_31ck192 FIND v(dout1_31) AT=3860.1n

* CHECK dout2_0 Vdout2_0ck192 = 0 time = 3860
.meas tran vdout2_0ck192 FIND v(dout2_0) AT=3860.1n

* CHECK dout2_1 Vdout2_1ck192 = 1.8 time = 3860
.meas tran vdout2_1ck192 FIND v(dout2_1) AT=3860.1n

* CHECK dout2_2 Vdout2_2ck192 = 0 time = 3860
.meas tran vdout2_2ck192 FIND v(dout2_2) AT=3860.1n

* CHECK dout2_3 Vdout2_3ck192 = 0 time = 3860
.meas tran vdout2_3ck192 FIND v(dout2_3) AT=3860.1n

* CHECK dout2_4 Vdout2_4ck192 = 0 time = 3860
.meas tran vdout2_4ck192 FIND v(dout2_4) AT=3860.1n

* CHECK dout2_5 Vdout2_5ck192 = 0 time = 3860
.meas tran vdout2_5ck192 FIND v(dout2_5) AT=3860.1n

* CHECK dout2_6 Vdout2_6ck192 = 0 time = 3860
.meas tran vdout2_6ck192 FIND v(dout2_6) AT=3860.1n

* CHECK dout2_7 Vdout2_7ck192 = 1.8 time = 3860
.meas tran vdout2_7ck192 FIND v(dout2_7) AT=3860.1n

* CHECK dout2_8 Vdout2_8ck192 = 0 time = 3860
.meas tran vdout2_8ck192 FIND v(dout2_8) AT=3860.1n

* CHECK dout2_9 Vdout2_9ck192 = 0 time = 3860
.meas tran vdout2_9ck192 FIND v(dout2_9) AT=3860.1n

* CHECK dout2_10 Vdout2_10ck192 = 0 time = 3860
.meas tran vdout2_10ck192 FIND v(dout2_10) AT=3860.1n

* CHECK dout2_11 Vdout2_11ck192 = 1.8 time = 3860
.meas tran vdout2_11ck192 FIND v(dout2_11) AT=3860.1n

* CHECK dout2_12 Vdout2_12ck192 = 0 time = 3860
.meas tran vdout2_12ck192 FIND v(dout2_12) AT=3860.1n

* CHECK dout2_13 Vdout2_13ck192 = 0 time = 3860
.meas tran vdout2_13ck192 FIND v(dout2_13) AT=3860.1n

* CHECK dout2_14 Vdout2_14ck192 = 1.8 time = 3860
.meas tran vdout2_14ck192 FIND v(dout2_14) AT=3860.1n

* CHECK dout2_15 Vdout2_15ck192 = 0 time = 3860
.meas tran vdout2_15ck192 FIND v(dout2_15) AT=3860.1n

* CHECK dout2_16 Vdout2_16ck192 = 1.8 time = 3860
.meas tran vdout2_16ck192 FIND v(dout2_16) AT=3860.1n

* CHECK dout2_17 Vdout2_17ck192 = 1.8 time = 3860
.meas tran vdout2_17ck192 FIND v(dout2_17) AT=3860.1n

* CHECK dout2_18 Vdout2_18ck192 = 1.8 time = 3860
.meas tran vdout2_18ck192 FIND v(dout2_18) AT=3860.1n

* CHECK dout2_19 Vdout2_19ck192 = 0 time = 3860
.meas tran vdout2_19ck192 FIND v(dout2_19) AT=3860.1n

* CHECK dout2_20 Vdout2_20ck192 = 0 time = 3860
.meas tran vdout2_20ck192 FIND v(dout2_20) AT=3860.1n

* CHECK dout2_21 Vdout2_21ck192 = 0 time = 3860
.meas tran vdout2_21ck192 FIND v(dout2_21) AT=3860.1n

* CHECK dout2_22 Vdout2_22ck192 = 1.8 time = 3860
.meas tran vdout2_22ck192 FIND v(dout2_22) AT=3860.1n

* CHECK dout2_23 Vdout2_23ck192 = 1.8 time = 3860
.meas tran vdout2_23ck192 FIND v(dout2_23) AT=3860.1n

* CHECK dout2_24 Vdout2_24ck192 = 0 time = 3860
.meas tran vdout2_24ck192 FIND v(dout2_24) AT=3860.1n

* CHECK dout2_25 Vdout2_25ck192 = 1.8 time = 3860
.meas tran vdout2_25ck192 FIND v(dout2_25) AT=3860.1n

* CHECK dout2_26 Vdout2_26ck192 = 0 time = 3860
.meas tran vdout2_26ck192 FIND v(dout2_26) AT=3860.1n

* CHECK dout2_27 Vdout2_27ck192 = 1.8 time = 3860
.meas tran vdout2_27ck192 FIND v(dout2_27) AT=3860.1n

* CHECK dout2_28 Vdout2_28ck192 = 1.8 time = 3860
.meas tran vdout2_28ck192 FIND v(dout2_28) AT=3860.1n

* CHECK dout2_29 Vdout2_29ck192 = 1.8 time = 3860
.meas tran vdout2_29ck192 FIND v(dout2_29) AT=3860.1n

* CHECK dout2_30 Vdout2_30ck192 = 0 time = 3860
.meas tran vdout2_30ck192 FIND v(dout2_30) AT=3860.1n

* CHECK dout2_31 Vdout2_31ck192 = 1.8 time = 3860
.meas tran vdout2_31ck192 FIND v(dout2_31) AT=3860.1n

* CHECK dout2_0 Vdout2_0ck193 = 0 time = 3880
.meas tran vdout2_0ck193 FIND v(dout2_0) AT=3880.1n

* CHECK dout2_1 Vdout2_1ck193 = 1.8 time = 3880
.meas tran vdout2_1ck193 FIND v(dout2_1) AT=3880.1n

* CHECK dout2_2 Vdout2_2ck193 = 0 time = 3880
.meas tran vdout2_2ck193 FIND v(dout2_2) AT=3880.1n

* CHECK dout2_3 Vdout2_3ck193 = 0 time = 3880
.meas tran vdout2_3ck193 FIND v(dout2_3) AT=3880.1n

* CHECK dout2_4 Vdout2_4ck193 = 1.8 time = 3880
.meas tran vdout2_4ck193 FIND v(dout2_4) AT=3880.1n

* CHECK dout2_5 Vdout2_5ck193 = 1.8 time = 3880
.meas tran vdout2_5ck193 FIND v(dout2_5) AT=3880.1n

* CHECK dout2_6 Vdout2_6ck193 = 0 time = 3880
.meas tran vdout2_6ck193 FIND v(dout2_6) AT=3880.1n

* CHECK dout2_7 Vdout2_7ck193 = 1.8 time = 3880
.meas tran vdout2_7ck193 FIND v(dout2_7) AT=3880.1n

* CHECK dout2_8 Vdout2_8ck193 = 0 time = 3880
.meas tran vdout2_8ck193 FIND v(dout2_8) AT=3880.1n

* CHECK dout2_9 Vdout2_9ck193 = 0 time = 3880
.meas tran vdout2_9ck193 FIND v(dout2_9) AT=3880.1n

* CHECK dout2_10 Vdout2_10ck193 = 1.8 time = 3880
.meas tran vdout2_10ck193 FIND v(dout2_10) AT=3880.1n

* CHECK dout2_11 Vdout2_11ck193 = 1.8 time = 3880
.meas tran vdout2_11ck193 FIND v(dout2_11) AT=3880.1n

* CHECK dout2_12 Vdout2_12ck193 = 1.8 time = 3880
.meas tran vdout2_12ck193 FIND v(dout2_12) AT=3880.1n

* CHECK dout2_13 Vdout2_13ck193 = 1.8 time = 3880
.meas tran vdout2_13ck193 FIND v(dout2_13) AT=3880.1n

* CHECK dout2_14 Vdout2_14ck193 = 0 time = 3880
.meas tran vdout2_14ck193 FIND v(dout2_14) AT=3880.1n

* CHECK dout2_15 Vdout2_15ck193 = 0 time = 3880
.meas tran vdout2_15ck193 FIND v(dout2_15) AT=3880.1n

* CHECK dout2_16 Vdout2_16ck193 = 1.8 time = 3880
.meas tran vdout2_16ck193 FIND v(dout2_16) AT=3880.1n

* CHECK dout2_17 Vdout2_17ck193 = 1.8 time = 3880
.meas tran vdout2_17ck193 FIND v(dout2_17) AT=3880.1n

* CHECK dout2_18 Vdout2_18ck193 = 1.8 time = 3880
.meas tran vdout2_18ck193 FIND v(dout2_18) AT=3880.1n

* CHECK dout2_19 Vdout2_19ck193 = 0 time = 3880
.meas tran vdout2_19ck193 FIND v(dout2_19) AT=3880.1n

* CHECK dout2_20 Vdout2_20ck193 = 1.8 time = 3880
.meas tran vdout2_20ck193 FIND v(dout2_20) AT=3880.1n

* CHECK dout2_21 Vdout2_21ck193 = 0 time = 3880
.meas tran vdout2_21ck193 FIND v(dout2_21) AT=3880.1n

* CHECK dout2_22 Vdout2_22ck193 = 0 time = 3880
.meas tran vdout2_22ck193 FIND v(dout2_22) AT=3880.1n

* CHECK dout2_23 Vdout2_23ck193 = 0 time = 3880
.meas tran vdout2_23ck193 FIND v(dout2_23) AT=3880.1n

* CHECK dout2_24 Vdout2_24ck193 = 0 time = 3880
.meas tran vdout2_24ck193 FIND v(dout2_24) AT=3880.1n

* CHECK dout2_25 Vdout2_25ck193 = 0 time = 3880
.meas tran vdout2_25ck193 FIND v(dout2_25) AT=3880.1n

* CHECK dout2_26 Vdout2_26ck193 = 1.8 time = 3880
.meas tran vdout2_26ck193 FIND v(dout2_26) AT=3880.1n

* CHECK dout2_27 Vdout2_27ck193 = 1.8 time = 3880
.meas tran vdout2_27ck193 FIND v(dout2_27) AT=3880.1n

* CHECK dout2_28 Vdout2_28ck193 = 0 time = 3880
.meas tran vdout2_28ck193 FIND v(dout2_28) AT=3880.1n

* CHECK dout2_29 Vdout2_29ck193 = 1.8 time = 3880
.meas tran vdout2_29ck193 FIND v(dout2_29) AT=3880.1n

* CHECK dout2_30 Vdout2_30ck193 = 1.8 time = 3880
.meas tran vdout2_30ck193 FIND v(dout2_30) AT=3880.1n

* CHECK dout2_31 Vdout2_31ck193 = 0 time = 3880
.meas tran vdout2_31ck193 FIND v(dout2_31) AT=3880.1n

* CHECK dout1_0 Vdout1_0ck194 = 0 time = 3900
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=3900.1n

* CHECK dout1_1 Vdout1_1ck194 = 1.8 time = 3900
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=3900.1n

* CHECK dout1_2 Vdout1_2ck194 = 1.8 time = 3900
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=3900.1n

* CHECK dout1_3 Vdout1_3ck194 = 1.8 time = 3900
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=3900.1n

* CHECK dout1_4 Vdout1_4ck194 = 1.8 time = 3900
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=3900.1n

* CHECK dout1_5 Vdout1_5ck194 = 1.8 time = 3900
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=3900.1n

* CHECK dout1_6 Vdout1_6ck194 = 0 time = 3900
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=3900.1n

* CHECK dout1_7 Vdout1_7ck194 = 1.8 time = 3900
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=3900.1n

* CHECK dout1_8 Vdout1_8ck194 = 1.8 time = 3900
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=3900.1n

* CHECK dout1_9 Vdout1_9ck194 = 0 time = 3900
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=3900.1n

* CHECK dout1_10 Vdout1_10ck194 = 1.8 time = 3900
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=3900.1n

* CHECK dout1_11 Vdout1_11ck194 = 0 time = 3900
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=3900.1n

* CHECK dout1_12 Vdout1_12ck194 = 0 time = 3900
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=3900.1n

* CHECK dout1_13 Vdout1_13ck194 = 1.8 time = 3900
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=3900.1n

* CHECK dout1_14 Vdout1_14ck194 = 1.8 time = 3900
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=3900.1n

* CHECK dout1_15 Vdout1_15ck194 = 1.8 time = 3900
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=3900.1n

* CHECK dout1_16 Vdout1_16ck194 = 1.8 time = 3900
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=3900.1n

* CHECK dout1_17 Vdout1_17ck194 = 0 time = 3900
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=3900.1n

* CHECK dout1_18 Vdout1_18ck194 = 0 time = 3900
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=3900.1n

* CHECK dout1_19 Vdout1_19ck194 = 0 time = 3900
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=3900.1n

* CHECK dout1_20 Vdout1_20ck194 = 0 time = 3900
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=3900.1n

* CHECK dout1_21 Vdout1_21ck194 = 0 time = 3900
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=3900.1n

* CHECK dout1_22 Vdout1_22ck194 = 0 time = 3900
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=3900.1n

* CHECK dout1_23 Vdout1_23ck194 = 1.8 time = 3900
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=3900.1n

* CHECK dout1_24 Vdout1_24ck194 = 0 time = 3900
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=3900.1n

* CHECK dout1_25 Vdout1_25ck194 = 1.8 time = 3900
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=3900.1n

* CHECK dout1_26 Vdout1_26ck194 = 0 time = 3900
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=3900.1n

* CHECK dout1_27 Vdout1_27ck194 = 0 time = 3900
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=3900.1n

* CHECK dout1_28 Vdout1_28ck194 = 0 time = 3900
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=3900.1n

* CHECK dout1_29 Vdout1_29ck194 = 1.8 time = 3900
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=3900.1n

* CHECK dout1_30 Vdout1_30ck194 = 0 time = 3900
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=3900.1n

* CHECK dout1_31 Vdout1_31ck194 = 0 time = 3900
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=3900.1n

* CHECK dout2_0 Vdout2_0ck194 = 0 time = 3900
.meas tran vdout2_0ck194 FIND v(dout2_0) AT=3900.1n

* CHECK dout2_1 Vdout2_1ck194 = 1.8 time = 3900
.meas tran vdout2_1ck194 FIND v(dout2_1) AT=3900.1n

* CHECK dout2_2 Vdout2_2ck194 = 1.8 time = 3900
.meas tran vdout2_2ck194 FIND v(dout2_2) AT=3900.1n

* CHECK dout2_3 Vdout2_3ck194 = 1.8 time = 3900
.meas tran vdout2_3ck194 FIND v(dout2_3) AT=3900.1n

* CHECK dout2_4 Vdout2_4ck194 = 1.8 time = 3900
.meas tran vdout2_4ck194 FIND v(dout2_4) AT=3900.1n

* CHECK dout2_5 Vdout2_5ck194 = 1.8 time = 3900
.meas tran vdout2_5ck194 FIND v(dout2_5) AT=3900.1n

* CHECK dout2_6 Vdout2_6ck194 = 1.8 time = 3900
.meas tran vdout2_6ck194 FIND v(dout2_6) AT=3900.1n

* CHECK dout2_7 Vdout2_7ck194 = 0 time = 3900
.meas tran vdout2_7ck194 FIND v(dout2_7) AT=3900.1n

* CHECK dout2_8 Vdout2_8ck194 = 0 time = 3900
.meas tran vdout2_8ck194 FIND v(dout2_8) AT=3900.1n

* CHECK dout2_9 Vdout2_9ck194 = 1.8 time = 3900
.meas tran vdout2_9ck194 FIND v(dout2_9) AT=3900.1n

* CHECK dout2_10 Vdout2_10ck194 = 1.8 time = 3900
.meas tran vdout2_10ck194 FIND v(dout2_10) AT=3900.1n

* CHECK dout2_11 Vdout2_11ck194 = 0 time = 3900
.meas tran vdout2_11ck194 FIND v(dout2_11) AT=3900.1n

* CHECK dout2_12 Vdout2_12ck194 = 0 time = 3900
.meas tran vdout2_12ck194 FIND v(dout2_12) AT=3900.1n

* CHECK dout2_13 Vdout2_13ck194 = 0 time = 3900
.meas tran vdout2_13ck194 FIND v(dout2_13) AT=3900.1n

* CHECK dout2_14 Vdout2_14ck194 = 1.8 time = 3900
.meas tran vdout2_14ck194 FIND v(dout2_14) AT=3900.1n

* CHECK dout2_15 Vdout2_15ck194 = 1.8 time = 3900
.meas tran vdout2_15ck194 FIND v(dout2_15) AT=3900.1n

* CHECK dout2_16 Vdout2_16ck194 = 1.8 time = 3900
.meas tran vdout2_16ck194 FIND v(dout2_16) AT=3900.1n

* CHECK dout2_17 Vdout2_17ck194 = 0 time = 3900
.meas tran vdout2_17ck194 FIND v(dout2_17) AT=3900.1n

* CHECK dout2_18 Vdout2_18ck194 = 0 time = 3900
.meas tran vdout2_18ck194 FIND v(dout2_18) AT=3900.1n

* CHECK dout2_19 Vdout2_19ck194 = 0 time = 3900
.meas tran vdout2_19ck194 FIND v(dout2_19) AT=3900.1n

* CHECK dout2_20 Vdout2_20ck194 = 1.8 time = 3900
.meas tran vdout2_20ck194 FIND v(dout2_20) AT=3900.1n

* CHECK dout2_21 Vdout2_21ck194 = 1.8 time = 3900
.meas tran vdout2_21ck194 FIND v(dout2_21) AT=3900.1n

* CHECK dout2_22 Vdout2_22ck194 = 0 time = 3900
.meas tran vdout2_22ck194 FIND v(dout2_22) AT=3900.1n

* CHECK dout2_23 Vdout2_23ck194 = 0 time = 3900
.meas tran vdout2_23ck194 FIND v(dout2_23) AT=3900.1n

* CHECK dout2_24 Vdout2_24ck194 = 0 time = 3900
.meas tran vdout2_24ck194 FIND v(dout2_24) AT=3900.1n

* CHECK dout2_25 Vdout2_25ck194 = 0 time = 3900
.meas tran vdout2_25ck194 FIND v(dout2_25) AT=3900.1n

* CHECK dout2_26 Vdout2_26ck194 = 1.8 time = 3900
.meas tran vdout2_26ck194 FIND v(dout2_26) AT=3900.1n

* CHECK dout2_27 Vdout2_27ck194 = 0 time = 3900
.meas tran vdout2_27ck194 FIND v(dout2_27) AT=3900.1n

* CHECK dout2_28 Vdout2_28ck194 = 0 time = 3900
.meas tran vdout2_28ck194 FIND v(dout2_28) AT=3900.1n

* CHECK dout2_29 Vdout2_29ck194 = 1.8 time = 3900
.meas tran vdout2_29ck194 FIND v(dout2_29) AT=3900.1n

* CHECK dout2_30 Vdout2_30ck194 = 0 time = 3900
.meas tran vdout2_30ck194 FIND v(dout2_30) AT=3900.1n

* CHECK dout2_31 Vdout2_31ck194 = 1.8 time = 3900
.meas tran vdout2_31ck194 FIND v(dout2_31) AT=3900.1n

* CHECK dout1_0 Vdout1_0ck195 = 1.8 time = 3920
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=3920.1n

* CHECK dout1_1 Vdout1_1ck195 = 0 time = 3920
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=3920.1n

* CHECK dout1_2 Vdout1_2ck195 = 1.8 time = 3920
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=3920.1n

* CHECK dout1_3 Vdout1_3ck195 = 0 time = 3920
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=3920.1n

* CHECK dout1_4 Vdout1_4ck195 = 0 time = 3920
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=3920.1n

* CHECK dout1_5 Vdout1_5ck195 = 0 time = 3920
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=3920.1n

* CHECK dout1_6 Vdout1_6ck195 = 0 time = 3920
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=3920.1n

* CHECK dout1_7 Vdout1_7ck195 = 1.8 time = 3920
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=3920.1n

* CHECK dout1_8 Vdout1_8ck195 = 0 time = 3920
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=3920.1n

* CHECK dout1_9 Vdout1_9ck195 = 1.8 time = 3920
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=3920.1n

* CHECK dout1_10 Vdout1_10ck195 = 0 time = 3920
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=3920.1n

* CHECK dout1_11 Vdout1_11ck195 = 1.8 time = 3920
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=3920.1n

* CHECK dout1_12 Vdout1_12ck195 = 1.8 time = 3920
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=3920.1n

* CHECK dout1_13 Vdout1_13ck195 = 0 time = 3920
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=3920.1n

* CHECK dout1_14 Vdout1_14ck195 = 0 time = 3920
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=3920.1n

* CHECK dout1_15 Vdout1_15ck195 = 1.8 time = 3920
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=3920.1n

* CHECK dout1_16 Vdout1_16ck195 = 1.8 time = 3920
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=3920.1n

* CHECK dout1_17 Vdout1_17ck195 = 0 time = 3920
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=3920.1n

* CHECK dout1_18 Vdout1_18ck195 = 0 time = 3920
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=3920.1n

* CHECK dout1_19 Vdout1_19ck195 = 0 time = 3920
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=3920.1n

* CHECK dout1_20 Vdout1_20ck195 = 1.8 time = 3920
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=3920.1n

* CHECK dout1_21 Vdout1_21ck195 = 0 time = 3920
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=3920.1n

* CHECK dout1_22 Vdout1_22ck195 = 1.8 time = 3920
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=3920.1n

* CHECK dout1_23 Vdout1_23ck195 = 1.8 time = 3920
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=3920.1n

* CHECK dout1_24 Vdout1_24ck195 = 1.8 time = 3920
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=3920.1n

* CHECK dout1_25 Vdout1_25ck195 = 0 time = 3920
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=3920.1n

* CHECK dout1_26 Vdout1_26ck195 = 0 time = 3920
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=3920.1n

* CHECK dout1_27 Vdout1_27ck195 = 0 time = 3920
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=3920.1n

* CHECK dout1_28 Vdout1_28ck195 = 0 time = 3920
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=3920.1n

* CHECK dout1_29 Vdout1_29ck195 = 0 time = 3920
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=3920.1n

* CHECK dout1_30 Vdout1_30ck195 = 0 time = 3920
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=3920.1n

* CHECK dout1_31 Vdout1_31ck195 = 1.8 time = 3920
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=3920.1n

* CHECK dout2_0 Vdout2_0ck195 = 0 time = 3920
.meas tran vdout2_0ck195 FIND v(dout2_0) AT=3920.1n

* CHECK dout2_1 Vdout2_1ck195 = 1.8 time = 3920
.meas tran vdout2_1ck195 FIND v(dout2_1) AT=3920.1n

* CHECK dout2_2 Vdout2_2ck195 = 1.8 time = 3920
.meas tran vdout2_2ck195 FIND v(dout2_2) AT=3920.1n

* CHECK dout2_3 Vdout2_3ck195 = 1.8 time = 3920
.meas tran vdout2_3ck195 FIND v(dout2_3) AT=3920.1n

* CHECK dout2_4 Vdout2_4ck195 = 1.8 time = 3920
.meas tran vdout2_4ck195 FIND v(dout2_4) AT=3920.1n

* CHECK dout2_5 Vdout2_5ck195 = 1.8 time = 3920
.meas tran vdout2_5ck195 FIND v(dout2_5) AT=3920.1n

* CHECK dout2_6 Vdout2_6ck195 = 0 time = 3920
.meas tran vdout2_6ck195 FIND v(dout2_6) AT=3920.1n

* CHECK dout2_7 Vdout2_7ck195 = 1.8 time = 3920
.meas tran vdout2_7ck195 FIND v(dout2_7) AT=3920.1n

* CHECK dout2_8 Vdout2_8ck195 = 1.8 time = 3920
.meas tran vdout2_8ck195 FIND v(dout2_8) AT=3920.1n

* CHECK dout2_9 Vdout2_9ck195 = 0 time = 3920
.meas tran vdout2_9ck195 FIND v(dout2_9) AT=3920.1n

* CHECK dout2_10 Vdout2_10ck195 = 1.8 time = 3920
.meas tran vdout2_10ck195 FIND v(dout2_10) AT=3920.1n

* CHECK dout2_11 Vdout2_11ck195 = 0 time = 3920
.meas tran vdout2_11ck195 FIND v(dout2_11) AT=3920.1n

* CHECK dout2_12 Vdout2_12ck195 = 0 time = 3920
.meas tran vdout2_12ck195 FIND v(dout2_12) AT=3920.1n

* CHECK dout2_13 Vdout2_13ck195 = 1.8 time = 3920
.meas tran vdout2_13ck195 FIND v(dout2_13) AT=3920.1n

* CHECK dout2_14 Vdout2_14ck195 = 1.8 time = 3920
.meas tran vdout2_14ck195 FIND v(dout2_14) AT=3920.1n

* CHECK dout2_15 Vdout2_15ck195 = 1.8 time = 3920
.meas tran vdout2_15ck195 FIND v(dout2_15) AT=3920.1n

* CHECK dout2_16 Vdout2_16ck195 = 1.8 time = 3920
.meas tran vdout2_16ck195 FIND v(dout2_16) AT=3920.1n

* CHECK dout2_17 Vdout2_17ck195 = 0 time = 3920
.meas tran vdout2_17ck195 FIND v(dout2_17) AT=3920.1n

* CHECK dout2_18 Vdout2_18ck195 = 0 time = 3920
.meas tran vdout2_18ck195 FIND v(dout2_18) AT=3920.1n

* CHECK dout2_19 Vdout2_19ck195 = 0 time = 3920
.meas tran vdout2_19ck195 FIND v(dout2_19) AT=3920.1n

* CHECK dout2_20 Vdout2_20ck195 = 0 time = 3920
.meas tran vdout2_20ck195 FIND v(dout2_20) AT=3920.1n

* CHECK dout2_21 Vdout2_21ck195 = 0 time = 3920
.meas tran vdout2_21ck195 FIND v(dout2_21) AT=3920.1n

* CHECK dout2_22 Vdout2_22ck195 = 0 time = 3920
.meas tran vdout2_22ck195 FIND v(dout2_22) AT=3920.1n

* CHECK dout2_23 Vdout2_23ck195 = 1.8 time = 3920
.meas tran vdout2_23ck195 FIND v(dout2_23) AT=3920.1n

* CHECK dout2_24 Vdout2_24ck195 = 0 time = 3920
.meas tran vdout2_24ck195 FIND v(dout2_24) AT=3920.1n

* CHECK dout2_25 Vdout2_25ck195 = 1.8 time = 3920
.meas tran vdout2_25ck195 FIND v(dout2_25) AT=3920.1n

* CHECK dout2_26 Vdout2_26ck195 = 0 time = 3920
.meas tran vdout2_26ck195 FIND v(dout2_26) AT=3920.1n

* CHECK dout2_27 Vdout2_27ck195 = 0 time = 3920
.meas tran vdout2_27ck195 FIND v(dout2_27) AT=3920.1n

* CHECK dout2_28 Vdout2_28ck195 = 0 time = 3920
.meas tran vdout2_28ck195 FIND v(dout2_28) AT=3920.1n

* CHECK dout2_29 Vdout2_29ck195 = 1.8 time = 3920
.meas tran vdout2_29ck195 FIND v(dout2_29) AT=3920.1n

* CHECK dout2_30 Vdout2_30ck195 = 0 time = 3920
.meas tran vdout2_30ck195 FIND v(dout2_30) AT=3920.1n

* CHECK dout2_31 Vdout2_31ck195 = 0 time = 3920
.meas tran vdout2_31ck195 FIND v(dout2_31) AT=3920.1n

* CHECK dout1_0 Vdout1_0ck196 = 1.8 time = 3940
.meas tran vdout1_0ck196 FIND v(dout1_0) AT=3940.1n

* CHECK dout1_1 Vdout1_1ck196 = 1.8 time = 3940
.meas tran vdout1_1ck196 FIND v(dout1_1) AT=3940.1n

* CHECK dout1_2 Vdout1_2ck196 = 1.8 time = 3940
.meas tran vdout1_2ck196 FIND v(dout1_2) AT=3940.1n

* CHECK dout1_3 Vdout1_3ck196 = 1.8 time = 3940
.meas tran vdout1_3ck196 FIND v(dout1_3) AT=3940.1n

* CHECK dout1_4 Vdout1_4ck196 = 0 time = 3940
.meas tran vdout1_4ck196 FIND v(dout1_4) AT=3940.1n

* CHECK dout1_5 Vdout1_5ck196 = 0 time = 3940
.meas tran vdout1_5ck196 FIND v(dout1_5) AT=3940.1n

* CHECK dout1_6 Vdout1_6ck196 = 0 time = 3940
.meas tran vdout1_6ck196 FIND v(dout1_6) AT=3940.1n

* CHECK dout1_7 Vdout1_7ck196 = 1.8 time = 3940
.meas tran vdout1_7ck196 FIND v(dout1_7) AT=3940.1n

* CHECK dout1_8 Vdout1_8ck196 = 0 time = 3940
.meas tran vdout1_8ck196 FIND v(dout1_8) AT=3940.1n

* CHECK dout1_9 Vdout1_9ck196 = 0 time = 3940
.meas tran vdout1_9ck196 FIND v(dout1_9) AT=3940.1n

* CHECK dout1_10 Vdout1_10ck196 = 1.8 time = 3940
.meas tran vdout1_10ck196 FIND v(dout1_10) AT=3940.1n

* CHECK dout1_11 Vdout1_11ck196 = 0 time = 3940
.meas tran vdout1_11ck196 FIND v(dout1_11) AT=3940.1n

* CHECK dout1_12 Vdout1_12ck196 = 0 time = 3940
.meas tran vdout1_12ck196 FIND v(dout1_12) AT=3940.1n

* CHECK dout1_13 Vdout1_13ck196 = 0 time = 3940
.meas tran vdout1_13ck196 FIND v(dout1_13) AT=3940.1n

* CHECK dout1_14 Vdout1_14ck196 = 0 time = 3940
.meas tran vdout1_14ck196 FIND v(dout1_14) AT=3940.1n

* CHECK dout1_15 Vdout1_15ck196 = 0 time = 3940
.meas tran vdout1_15ck196 FIND v(dout1_15) AT=3940.1n

* CHECK dout1_16 Vdout1_16ck196 = 1.8 time = 3940
.meas tran vdout1_16ck196 FIND v(dout1_16) AT=3940.1n

* CHECK dout1_17 Vdout1_17ck196 = 0 time = 3940
.meas tran vdout1_17ck196 FIND v(dout1_17) AT=3940.1n

* CHECK dout1_18 Vdout1_18ck196 = 0 time = 3940
.meas tran vdout1_18ck196 FIND v(dout1_18) AT=3940.1n

* CHECK dout1_19 Vdout1_19ck196 = 1.8 time = 3940
.meas tran vdout1_19ck196 FIND v(dout1_19) AT=3940.1n

* CHECK dout1_20 Vdout1_20ck196 = 1.8 time = 3940
.meas tran vdout1_20ck196 FIND v(dout1_20) AT=3940.1n

* CHECK dout1_21 Vdout1_21ck196 = 0 time = 3940
.meas tran vdout1_21ck196 FIND v(dout1_21) AT=3940.1n

* CHECK dout1_22 Vdout1_22ck196 = 1.8 time = 3940
.meas tran vdout1_22ck196 FIND v(dout1_22) AT=3940.1n

* CHECK dout1_23 Vdout1_23ck196 = 1.8 time = 3940
.meas tran vdout1_23ck196 FIND v(dout1_23) AT=3940.1n

* CHECK dout1_24 Vdout1_24ck196 = 0 time = 3940
.meas tran vdout1_24ck196 FIND v(dout1_24) AT=3940.1n

* CHECK dout1_25 Vdout1_25ck196 = 0 time = 3940
.meas tran vdout1_25ck196 FIND v(dout1_25) AT=3940.1n

* CHECK dout1_26 Vdout1_26ck196 = 0 time = 3940
.meas tran vdout1_26ck196 FIND v(dout1_26) AT=3940.1n

* CHECK dout1_27 Vdout1_27ck196 = 1.8 time = 3940
.meas tran vdout1_27ck196 FIND v(dout1_27) AT=3940.1n

* CHECK dout1_28 Vdout1_28ck196 = 0 time = 3940
.meas tran vdout1_28ck196 FIND v(dout1_28) AT=3940.1n

* CHECK dout1_29 Vdout1_29ck196 = 1.8 time = 3940
.meas tran vdout1_29ck196 FIND v(dout1_29) AT=3940.1n

* CHECK dout1_30 Vdout1_30ck196 = 0 time = 3940
.meas tran vdout1_30ck196 FIND v(dout1_30) AT=3940.1n

* CHECK dout1_31 Vdout1_31ck196 = 0 time = 3940
.meas tran vdout1_31ck196 FIND v(dout1_31) AT=3940.1n

* CHECK dout2_0 Vdout2_0ck196 = 1.8 time = 3940
.meas tran vdout2_0ck196 FIND v(dout2_0) AT=3940.1n

* CHECK dout2_1 Vdout2_1ck196 = 1.8 time = 3940
.meas tran vdout2_1ck196 FIND v(dout2_1) AT=3940.1n

* CHECK dout2_2 Vdout2_2ck196 = 1.8 time = 3940
.meas tran vdout2_2ck196 FIND v(dout2_2) AT=3940.1n

* CHECK dout2_3 Vdout2_3ck196 = 1.8 time = 3940
.meas tran vdout2_3ck196 FIND v(dout2_3) AT=3940.1n

* CHECK dout2_4 Vdout2_4ck196 = 0 time = 3940
.meas tran vdout2_4ck196 FIND v(dout2_4) AT=3940.1n

* CHECK dout2_5 Vdout2_5ck196 = 0 time = 3940
.meas tran vdout2_5ck196 FIND v(dout2_5) AT=3940.1n

* CHECK dout2_6 Vdout2_6ck196 = 0 time = 3940
.meas tran vdout2_6ck196 FIND v(dout2_6) AT=3940.1n

* CHECK dout2_7 Vdout2_7ck196 = 1.8 time = 3940
.meas tran vdout2_7ck196 FIND v(dout2_7) AT=3940.1n

* CHECK dout2_8 Vdout2_8ck196 = 0 time = 3940
.meas tran vdout2_8ck196 FIND v(dout2_8) AT=3940.1n

* CHECK dout2_9 Vdout2_9ck196 = 0 time = 3940
.meas tran vdout2_9ck196 FIND v(dout2_9) AT=3940.1n

* CHECK dout2_10 Vdout2_10ck196 = 1.8 time = 3940
.meas tran vdout2_10ck196 FIND v(dout2_10) AT=3940.1n

* CHECK dout2_11 Vdout2_11ck196 = 0 time = 3940
.meas tran vdout2_11ck196 FIND v(dout2_11) AT=3940.1n

* CHECK dout2_12 Vdout2_12ck196 = 0 time = 3940
.meas tran vdout2_12ck196 FIND v(dout2_12) AT=3940.1n

* CHECK dout2_13 Vdout2_13ck196 = 0 time = 3940
.meas tran vdout2_13ck196 FIND v(dout2_13) AT=3940.1n

* CHECK dout2_14 Vdout2_14ck196 = 0 time = 3940
.meas tran vdout2_14ck196 FIND v(dout2_14) AT=3940.1n

* CHECK dout2_15 Vdout2_15ck196 = 0 time = 3940
.meas tran vdout2_15ck196 FIND v(dout2_15) AT=3940.1n

* CHECK dout2_16 Vdout2_16ck196 = 1.8 time = 3940
.meas tran vdout2_16ck196 FIND v(dout2_16) AT=3940.1n

* CHECK dout2_17 Vdout2_17ck196 = 0 time = 3940
.meas tran vdout2_17ck196 FIND v(dout2_17) AT=3940.1n

* CHECK dout2_18 Vdout2_18ck196 = 0 time = 3940
.meas tran vdout2_18ck196 FIND v(dout2_18) AT=3940.1n

* CHECK dout2_19 Vdout2_19ck196 = 1.8 time = 3940
.meas tran vdout2_19ck196 FIND v(dout2_19) AT=3940.1n

* CHECK dout2_20 Vdout2_20ck196 = 1.8 time = 3940
.meas tran vdout2_20ck196 FIND v(dout2_20) AT=3940.1n

* CHECK dout2_21 Vdout2_21ck196 = 0 time = 3940
.meas tran vdout2_21ck196 FIND v(dout2_21) AT=3940.1n

* CHECK dout2_22 Vdout2_22ck196 = 1.8 time = 3940
.meas tran vdout2_22ck196 FIND v(dout2_22) AT=3940.1n

* CHECK dout2_23 Vdout2_23ck196 = 1.8 time = 3940
.meas tran vdout2_23ck196 FIND v(dout2_23) AT=3940.1n

* CHECK dout2_24 Vdout2_24ck196 = 0 time = 3940
.meas tran vdout2_24ck196 FIND v(dout2_24) AT=3940.1n

* CHECK dout2_25 Vdout2_25ck196 = 0 time = 3940
.meas tran vdout2_25ck196 FIND v(dout2_25) AT=3940.1n

* CHECK dout2_26 Vdout2_26ck196 = 0 time = 3940
.meas tran vdout2_26ck196 FIND v(dout2_26) AT=3940.1n

* CHECK dout2_27 Vdout2_27ck196 = 1.8 time = 3940
.meas tran vdout2_27ck196 FIND v(dout2_27) AT=3940.1n

* CHECK dout2_28 Vdout2_28ck196 = 0 time = 3940
.meas tran vdout2_28ck196 FIND v(dout2_28) AT=3940.1n

* CHECK dout2_29 Vdout2_29ck196 = 1.8 time = 3940
.meas tran vdout2_29ck196 FIND v(dout2_29) AT=3940.1n

* CHECK dout2_30 Vdout2_30ck196 = 0 time = 3940
.meas tran vdout2_30ck196 FIND v(dout2_30) AT=3940.1n

* CHECK dout2_31 Vdout2_31ck196 = 0 time = 3940
.meas tran vdout2_31ck196 FIND v(dout2_31) AT=3940.1n

* CHECK dout2_0 Vdout2_0ck197 = 0 time = 3960
.meas tran vdout2_0ck197 FIND v(dout2_0) AT=3960.1n

* CHECK dout2_1 Vdout2_1ck197 = 1.8 time = 3960
.meas tran vdout2_1ck197 FIND v(dout2_1) AT=3960.1n

* CHECK dout2_2 Vdout2_2ck197 = 1.8 time = 3960
.meas tran vdout2_2ck197 FIND v(dout2_2) AT=3960.1n

* CHECK dout2_3 Vdout2_3ck197 = 1.8 time = 3960
.meas tran vdout2_3ck197 FIND v(dout2_3) AT=3960.1n

* CHECK dout2_4 Vdout2_4ck197 = 1.8 time = 3960
.meas tran vdout2_4ck197 FIND v(dout2_4) AT=3960.1n

* CHECK dout2_5 Vdout2_5ck197 = 0 time = 3960
.meas tran vdout2_5ck197 FIND v(dout2_5) AT=3960.1n

* CHECK dout2_6 Vdout2_6ck197 = 1.8 time = 3960
.meas tran vdout2_6ck197 FIND v(dout2_6) AT=3960.1n

* CHECK dout2_7 Vdout2_7ck197 = 0 time = 3960
.meas tran vdout2_7ck197 FIND v(dout2_7) AT=3960.1n

* CHECK dout2_8 Vdout2_8ck197 = 1.8 time = 3960
.meas tran vdout2_8ck197 FIND v(dout2_8) AT=3960.1n

* CHECK dout2_9 Vdout2_9ck197 = 1.8 time = 3960
.meas tran vdout2_9ck197 FIND v(dout2_9) AT=3960.1n

* CHECK dout2_10 Vdout2_10ck197 = 1.8 time = 3960
.meas tran vdout2_10ck197 FIND v(dout2_10) AT=3960.1n

* CHECK dout2_11 Vdout2_11ck197 = 0 time = 3960
.meas tran vdout2_11ck197 FIND v(dout2_11) AT=3960.1n

* CHECK dout2_12 Vdout2_12ck197 = 1.8 time = 3960
.meas tran vdout2_12ck197 FIND v(dout2_12) AT=3960.1n

* CHECK dout2_13 Vdout2_13ck197 = 0 time = 3960
.meas tran vdout2_13ck197 FIND v(dout2_13) AT=3960.1n

* CHECK dout2_14 Vdout2_14ck197 = 0 time = 3960
.meas tran vdout2_14ck197 FIND v(dout2_14) AT=3960.1n

* CHECK dout2_15 Vdout2_15ck197 = 1.8 time = 3960
.meas tran vdout2_15ck197 FIND v(dout2_15) AT=3960.1n

* CHECK dout2_16 Vdout2_16ck197 = 1.8 time = 3960
.meas tran vdout2_16ck197 FIND v(dout2_16) AT=3960.1n

* CHECK dout2_17 Vdout2_17ck197 = 0 time = 3960
.meas tran vdout2_17ck197 FIND v(dout2_17) AT=3960.1n

* CHECK dout2_18 Vdout2_18ck197 = 1.8 time = 3960
.meas tran vdout2_18ck197 FIND v(dout2_18) AT=3960.1n

* CHECK dout2_19 Vdout2_19ck197 = 0 time = 3960
.meas tran vdout2_19ck197 FIND v(dout2_19) AT=3960.1n

* CHECK dout2_20 Vdout2_20ck197 = 1.8 time = 3960
.meas tran vdout2_20ck197 FIND v(dout2_20) AT=3960.1n

* CHECK dout2_21 Vdout2_21ck197 = 1.8 time = 3960
.meas tran vdout2_21ck197 FIND v(dout2_21) AT=3960.1n

* CHECK dout2_22 Vdout2_22ck197 = 0 time = 3960
.meas tran vdout2_22ck197 FIND v(dout2_22) AT=3960.1n

* CHECK dout2_23 Vdout2_23ck197 = 1.8 time = 3960
.meas tran vdout2_23ck197 FIND v(dout2_23) AT=3960.1n

* CHECK dout2_24 Vdout2_24ck197 = 0 time = 3960
.meas tran vdout2_24ck197 FIND v(dout2_24) AT=3960.1n

* CHECK dout2_25 Vdout2_25ck197 = 0 time = 3960
.meas tran vdout2_25ck197 FIND v(dout2_25) AT=3960.1n

* CHECK dout2_26 Vdout2_26ck197 = 0 time = 3960
.meas tran vdout2_26ck197 FIND v(dout2_26) AT=3960.1n

* CHECK dout2_27 Vdout2_27ck197 = 1.8 time = 3960
.meas tran vdout2_27ck197 FIND v(dout2_27) AT=3960.1n

* CHECK dout2_28 Vdout2_28ck197 = 1.8 time = 3960
.meas tran vdout2_28ck197 FIND v(dout2_28) AT=3960.1n

* CHECK dout2_29 Vdout2_29ck197 = 0 time = 3960
.meas tran vdout2_29ck197 FIND v(dout2_29) AT=3960.1n

* CHECK dout2_30 Vdout2_30ck197 = 0 time = 3960
.meas tran vdout2_30ck197 FIND v(dout2_30) AT=3960.1n

* CHECK dout2_31 Vdout2_31ck197 = 0 time = 3960
.meas tran vdout2_31ck197 FIND v(dout2_31) AT=3960.1n

* CHECK dout1_0 Vdout1_0ck198 = 0 time = 3980
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=3980.1n

* CHECK dout1_1 Vdout1_1ck198 = 1.8 time = 3980
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=3980.1n

* CHECK dout1_2 Vdout1_2ck198 = 0 time = 3980
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=3980.1n

* CHECK dout1_3 Vdout1_3ck198 = 1.8 time = 3980
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=3980.1n

* CHECK dout1_4 Vdout1_4ck198 = 0 time = 3980
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=3980.1n

* CHECK dout1_5 Vdout1_5ck198 = 1.8 time = 3980
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=3980.1n

* CHECK dout1_6 Vdout1_6ck198 = 0 time = 3980
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=3980.1n

* CHECK dout1_7 Vdout1_7ck198 = 1.8 time = 3980
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=3980.1n

* CHECK dout1_8 Vdout1_8ck198 = 1.8 time = 3980
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=3980.1n

* CHECK dout1_9 Vdout1_9ck198 = 0 time = 3980
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=3980.1n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 3980
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=3980.1n

* CHECK dout1_11 Vdout1_11ck198 = 0 time = 3980
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=3980.1n

* CHECK dout1_12 Vdout1_12ck198 = 0 time = 3980
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=3980.1n

* CHECK dout1_13 Vdout1_13ck198 = 1.8 time = 3980
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=3980.1n

* CHECK dout1_14 Vdout1_14ck198 = 1.8 time = 3980
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=3980.1n

* CHECK dout1_15 Vdout1_15ck198 = 0 time = 3980
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=3980.1n

* CHECK dout1_16 Vdout1_16ck198 = 1.8 time = 3980
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=3980.1n

* CHECK dout1_17 Vdout1_17ck198 = 1.8 time = 3980
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=3980.1n

* CHECK dout1_18 Vdout1_18ck198 = 1.8 time = 3980
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=3980.1n

* CHECK dout1_19 Vdout1_19ck198 = 1.8 time = 3980
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=3980.1n

* CHECK dout1_20 Vdout1_20ck198 = 1.8 time = 3980
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=3980.1n

* CHECK dout1_21 Vdout1_21ck198 = 1.8 time = 3980
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=3980.1n

* CHECK dout1_22 Vdout1_22ck198 = 0 time = 3980
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=3980.1n

* CHECK dout1_23 Vdout1_23ck198 = 0 time = 3980
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=3980.1n

* CHECK dout1_24 Vdout1_24ck198 = 1.8 time = 3980
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=3980.1n

* CHECK dout1_25 Vdout1_25ck198 = 1.8 time = 3980
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=3980.1n

* CHECK dout1_26 Vdout1_26ck198 = 1.8 time = 3980
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=3980.1n

* CHECK dout1_27 Vdout1_27ck198 = 1.8 time = 3980
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=3980.1n

* CHECK dout1_28 Vdout1_28ck198 = 1.8 time = 3980
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=3980.1n

* CHECK dout1_29 Vdout1_29ck198 = 1.8 time = 3980
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=3980.1n

* CHECK dout1_30 Vdout1_30ck198 = 1.8 time = 3980
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=3980.1n

* CHECK dout1_31 Vdout1_31ck198 = 1.8 time = 3980
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=3980.1n

* CHECK dout2_0 Vdout2_0ck198 = 0 time = 3980
.meas tran vdout2_0ck198 FIND v(dout2_0) AT=3980.1n

* CHECK dout2_1 Vdout2_1ck198 = 0 time = 3980
.meas tran vdout2_1ck198 FIND v(dout2_1) AT=3980.1n

* CHECK dout2_2 Vdout2_2ck198 = 0 time = 3980
.meas tran vdout2_2ck198 FIND v(dout2_2) AT=3980.1n

* CHECK dout2_3 Vdout2_3ck198 = 0 time = 3980
.meas tran vdout2_3ck198 FIND v(dout2_3) AT=3980.1n

* CHECK dout2_4 Vdout2_4ck198 = 0 time = 3980
.meas tran vdout2_4ck198 FIND v(dout2_4) AT=3980.1n

* CHECK dout2_5 Vdout2_5ck198 = 1.8 time = 3980
.meas tran vdout2_5ck198 FIND v(dout2_5) AT=3980.1n

* CHECK dout2_6 Vdout2_6ck198 = 1.8 time = 3980
.meas tran vdout2_6ck198 FIND v(dout2_6) AT=3980.1n

* CHECK dout2_7 Vdout2_7ck198 = 1.8 time = 3980
.meas tran vdout2_7ck198 FIND v(dout2_7) AT=3980.1n

* CHECK dout2_8 Vdout2_8ck198 = 0 time = 3980
.meas tran vdout2_8ck198 FIND v(dout2_8) AT=3980.1n

* CHECK dout2_9 Vdout2_9ck198 = 1.8 time = 3980
.meas tran vdout2_9ck198 FIND v(dout2_9) AT=3980.1n

* CHECK dout2_10 Vdout2_10ck198 = 0 time = 3980
.meas tran vdout2_10ck198 FIND v(dout2_10) AT=3980.1n

* CHECK dout2_11 Vdout2_11ck198 = 1.8 time = 3980
.meas tran vdout2_11ck198 FIND v(dout2_11) AT=3980.1n

* CHECK dout2_12 Vdout2_12ck198 = 0 time = 3980
.meas tran vdout2_12ck198 FIND v(dout2_12) AT=3980.1n

* CHECK dout2_13 Vdout2_13ck198 = 0 time = 3980
.meas tran vdout2_13ck198 FIND v(dout2_13) AT=3980.1n

* CHECK dout2_14 Vdout2_14ck198 = 1.8 time = 3980
.meas tran vdout2_14ck198 FIND v(dout2_14) AT=3980.1n

* CHECK dout2_15 Vdout2_15ck198 = 0 time = 3980
.meas tran vdout2_15ck198 FIND v(dout2_15) AT=3980.1n

* CHECK dout2_16 Vdout2_16ck198 = 0 time = 3980
.meas tran vdout2_16ck198 FIND v(dout2_16) AT=3980.1n

* CHECK dout2_17 Vdout2_17ck198 = 1.8 time = 3980
.meas tran vdout2_17ck198 FIND v(dout2_17) AT=3980.1n

* CHECK dout2_18 Vdout2_18ck198 = 0 time = 3980
.meas tran vdout2_18ck198 FIND v(dout2_18) AT=3980.1n

* CHECK dout2_19 Vdout2_19ck198 = 1.8 time = 3980
.meas tran vdout2_19ck198 FIND v(dout2_19) AT=3980.1n

* CHECK dout2_20 Vdout2_20ck198 = 0 time = 3980
.meas tran vdout2_20ck198 FIND v(dout2_20) AT=3980.1n

* CHECK dout2_21 Vdout2_21ck198 = 0 time = 3980
.meas tran vdout2_21ck198 FIND v(dout2_21) AT=3980.1n

* CHECK dout2_22 Vdout2_22ck198 = 1.8 time = 3980
.meas tran vdout2_22ck198 FIND v(dout2_22) AT=3980.1n

* CHECK dout2_23 Vdout2_23ck198 = 1.8 time = 3980
.meas tran vdout2_23ck198 FIND v(dout2_23) AT=3980.1n

* CHECK dout2_24 Vdout2_24ck198 = 1.8 time = 3980
.meas tran vdout2_24ck198 FIND v(dout2_24) AT=3980.1n

* CHECK dout2_25 Vdout2_25ck198 = 1.8 time = 3980
.meas tran vdout2_25ck198 FIND v(dout2_25) AT=3980.1n

* CHECK dout2_26 Vdout2_26ck198 = 0 time = 3980
.meas tran vdout2_26ck198 FIND v(dout2_26) AT=3980.1n

* CHECK dout2_27 Vdout2_27ck198 = 1.8 time = 3980
.meas tran vdout2_27ck198 FIND v(dout2_27) AT=3980.1n

* CHECK dout2_28 Vdout2_28ck198 = 0 time = 3980
.meas tran vdout2_28ck198 FIND v(dout2_28) AT=3980.1n

* CHECK dout2_29 Vdout2_29ck198 = 0 time = 3980
.meas tran vdout2_29ck198 FIND v(dout2_29) AT=3980.1n

* CHECK dout2_30 Vdout2_30ck198 = 1.8 time = 3980
.meas tran vdout2_30ck198 FIND v(dout2_30) AT=3980.1n

* CHECK dout2_31 Vdout2_31ck198 = 0 time = 3980
.meas tran vdout2_31ck198 FIND v(dout2_31) AT=3980.1n

* CHECK dout1_0 Vdout1_0ck199 = 0 time = 4000
.meas tran vdout1_0ck199 FIND v(dout1_0) AT=4000.1n

* CHECK dout1_1 Vdout1_1ck199 = 1.8 time = 4000
.meas tran vdout1_1ck199 FIND v(dout1_1) AT=4000.1n

* CHECK dout1_2 Vdout1_2ck199 = 0 time = 4000
.meas tran vdout1_2ck199 FIND v(dout1_2) AT=4000.1n

* CHECK dout1_3 Vdout1_3ck199 = 1.8 time = 4000
.meas tran vdout1_3ck199 FIND v(dout1_3) AT=4000.1n

* CHECK dout1_4 Vdout1_4ck199 = 0 time = 4000
.meas tran vdout1_4ck199 FIND v(dout1_4) AT=4000.1n

* CHECK dout1_5 Vdout1_5ck199 = 1.8 time = 4000
.meas tran vdout1_5ck199 FIND v(dout1_5) AT=4000.1n

* CHECK dout1_6 Vdout1_6ck199 = 0 time = 4000
.meas tran vdout1_6ck199 FIND v(dout1_6) AT=4000.1n

* CHECK dout1_7 Vdout1_7ck199 = 1.8 time = 4000
.meas tran vdout1_7ck199 FIND v(dout1_7) AT=4000.1n

* CHECK dout1_8 Vdout1_8ck199 = 1.8 time = 4000
.meas tran vdout1_8ck199 FIND v(dout1_8) AT=4000.1n

* CHECK dout1_9 Vdout1_9ck199 = 0 time = 4000
.meas tran vdout1_9ck199 FIND v(dout1_9) AT=4000.1n

* CHECK dout1_10 Vdout1_10ck199 = 0 time = 4000
.meas tran vdout1_10ck199 FIND v(dout1_10) AT=4000.1n

* CHECK dout1_11 Vdout1_11ck199 = 0 time = 4000
.meas tran vdout1_11ck199 FIND v(dout1_11) AT=4000.1n

* CHECK dout1_12 Vdout1_12ck199 = 0 time = 4000
.meas tran vdout1_12ck199 FIND v(dout1_12) AT=4000.1n

* CHECK dout1_13 Vdout1_13ck199 = 1.8 time = 4000
.meas tran vdout1_13ck199 FIND v(dout1_13) AT=4000.1n

* CHECK dout1_14 Vdout1_14ck199 = 1.8 time = 4000
.meas tran vdout1_14ck199 FIND v(dout1_14) AT=4000.1n

* CHECK dout1_15 Vdout1_15ck199 = 0 time = 4000
.meas tran vdout1_15ck199 FIND v(dout1_15) AT=4000.1n

* CHECK dout1_16 Vdout1_16ck199 = 1.8 time = 4000
.meas tran vdout1_16ck199 FIND v(dout1_16) AT=4000.1n

* CHECK dout1_17 Vdout1_17ck199 = 1.8 time = 4000
.meas tran vdout1_17ck199 FIND v(dout1_17) AT=4000.1n

* CHECK dout1_18 Vdout1_18ck199 = 1.8 time = 4000
.meas tran vdout1_18ck199 FIND v(dout1_18) AT=4000.1n

* CHECK dout1_19 Vdout1_19ck199 = 1.8 time = 4000
.meas tran vdout1_19ck199 FIND v(dout1_19) AT=4000.1n

* CHECK dout1_20 Vdout1_20ck199 = 1.8 time = 4000
.meas tran vdout1_20ck199 FIND v(dout1_20) AT=4000.1n

* CHECK dout1_21 Vdout1_21ck199 = 1.8 time = 4000
.meas tran vdout1_21ck199 FIND v(dout1_21) AT=4000.1n

* CHECK dout1_22 Vdout1_22ck199 = 0 time = 4000
.meas tran vdout1_22ck199 FIND v(dout1_22) AT=4000.1n

* CHECK dout1_23 Vdout1_23ck199 = 0 time = 4000
.meas tran vdout1_23ck199 FIND v(dout1_23) AT=4000.1n

* CHECK dout1_24 Vdout1_24ck199 = 1.8 time = 4000
.meas tran vdout1_24ck199 FIND v(dout1_24) AT=4000.1n

* CHECK dout1_25 Vdout1_25ck199 = 1.8 time = 4000
.meas tran vdout1_25ck199 FIND v(dout1_25) AT=4000.1n

* CHECK dout1_26 Vdout1_26ck199 = 1.8 time = 4000
.meas tran vdout1_26ck199 FIND v(dout1_26) AT=4000.1n

* CHECK dout1_27 Vdout1_27ck199 = 1.8 time = 4000
.meas tran vdout1_27ck199 FIND v(dout1_27) AT=4000.1n

* CHECK dout1_28 Vdout1_28ck199 = 1.8 time = 4000
.meas tran vdout1_28ck199 FIND v(dout1_28) AT=4000.1n

* CHECK dout1_29 Vdout1_29ck199 = 1.8 time = 4000
.meas tran vdout1_29ck199 FIND v(dout1_29) AT=4000.1n

* CHECK dout1_30 Vdout1_30ck199 = 1.8 time = 4000
.meas tran vdout1_30ck199 FIND v(dout1_30) AT=4000.1n

* CHECK dout1_31 Vdout1_31ck199 = 1.8 time = 4000
.meas tran vdout1_31ck199 FIND v(dout1_31) AT=4000.1n

* CHECK dout2_0 Vdout2_0ck199 = 0 time = 4000
.meas tran vdout2_0ck199 FIND v(dout2_0) AT=4000.1n

* CHECK dout2_1 Vdout2_1ck199 = 1.8 time = 4000
.meas tran vdout2_1ck199 FIND v(dout2_1) AT=4000.1n

* CHECK dout2_2 Vdout2_2ck199 = 1.8 time = 4000
.meas tran vdout2_2ck199 FIND v(dout2_2) AT=4000.1n

* CHECK dout2_3 Vdout2_3ck199 = 1.8 time = 4000
.meas tran vdout2_3ck199 FIND v(dout2_3) AT=4000.1n

* CHECK dout2_4 Vdout2_4ck199 = 1.8 time = 4000
.meas tran vdout2_4ck199 FIND v(dout2_4) AT=4000.1n

* CHECK dout2_5 Vdout2_5ck199 = 1.8 time = 4000
.meas tran vdout2_5ck199 FIND v(dout2_5) AT=4000.1n

* CHECK dout2_6 Vdout2_6ck199 = 0 time = 4000
.meas tran vdout2_6ck199 FIND v(dout2_6) AT=4000.1n

* CHECK dout2_7 Vdout2_7ck199 = 1.8 time = 4000
.meas tran vdout2_7ck199 FIND v(dout2_7) AT=4000.1n

* CHECK dout2_8 Vdout2_8ck199 = 1.8 time = 4000
.meas tran vdout2_8ck199 FIND v(dout2_8) AT=4000.1n

* CHECK dout2_9 Vdout2_9ck199 = 0 time = 4000
.meas tran vdout2_9ck199 FIND v(dout2_9) AT=4000.1n

* CHECK dout2_10 Vdout2_10ck199 = 1.8 time = 4000
.meas tran vdout2_10ck199 FIND v(dout2_10) AT=4000.1n

* CHECK dout2_11 Vdout2_11ck199 = 0 time = 4000
.meas tran vdout2_11ck199 FIND v(dout2_11) AT=4000.1n

* CHECK dout2_12 Vdout2_12ck199 = 0 time = 4000
.meas tran vdout2_12ck199 FIND v(dout2_12) AT=4000.1n

* CHECK dout2_13 Vdout2_13ck199 = 1.8 time = 4000
.meas tran vdout2_13ck199 FIND v(dout2_13) AT=4000.1n

* CHECK dout2_14 Vdout2_14ck199 = 1.8 time = 4000
.meas tran vdout2_14ck199 FIND v(dout2_14) AT=4000.1n

* CHECK dout2_15 Vdout2_15ck199 = 1.8 time = 4000
.meas tran vdout2_15ck199 FIND v(dout2_15) AT=4000.1n

* CHECK dout2_16 Vdout2_16ck199 = 1.8 time = 4000
.meas tran vdout2_16ck199 FIND v(dout2_16) AT=4000.1n

* CHECK dout2_17 Vdout2_17ck199 = 0 time = 4000
.meas tran vdout2_17ck199 FIND v(dout2_17) AT=4000.1n

* CHECK dout2_18 Vdout2_18ck199 = 0 time = 4000
.meas tran vdout2_18ck199 FIND v(dout2_18) AT=4000.1n

* CHECK dout2_19 Vdout2_19ck199 = 0 time = 4000
.meas tran vdout2_19ck199 FIND v(dout2_19) AT=4000.1n

* CHECK dout2_20 Vdout2_20ck199 = 0 time = 4000
.meas tran vdout2_20ck199 FIND v(dout2_20) AT=4000.1n

* CHECK dout2_21 Vdout2_21ck199 = 0 time = 4000
.meas tran vdout2_21ck199 FIND v(dout2_21) AT=4000.1n

* CHECK dout2_22 Vdout2_22ck199 = 0 time = 4000
.meas tran vdout2_22ck199 FIND v(dout2_22) AT=4000.1n

* CHECK dout2_23 Vdout2_23ck199 = 1.8 time = 4000
.meas tran vdout2_23ck199 FIND v(dout2_23) AT=4000.1n

* CHECK dout2_24 Vdout2_24ck199 = 0 time = 4000
.meas tran vdout2_24ck199 FIND v(dout2_24) AT=4000.1n

* CHECK dout2_25 Vdout2_25ck199 = 1.8 time = 4000
.meas tran vdout2_25ck199 FIND v(dout2_25) AT=4000.1n

* CHECK dout2_26 Vdout2_26ck199 = 0 time = 4000
.meas tran vdout2_26ck199 FIND v(dout2_26) AT=4000.1n

* CHECK dout2_27 Vdout2_27ck199 = 0 time = 4000
.meas tran vdout2_27ck199 FIND v(dout2_27) AT=4000.1n

* CHECK dout2_28 Vdout2_28ck199 = 0 time = 4000
.meas tran vdout2_28ck199 FIND v(dout2_28) AT=4000.1n

* CHECK dout2_29 Vdout2_29ck199 = 1.8 time = 4000
.meas tran vdout2_29ck199 FIND v(dout2_29) AT=4000.1n

* CHECK dout2_30 Vdout2_30ck199 = 0 time = 4000
.meas tran vdout2_30ck199 FIND v(dout2_30) AT=4000.1n

* CHECK dout2_31 Vdout2_31ck199 = 0 time = 4000
.meas tran vdout2_31ck199 FIND v(dout2_31) AT=4000.1n

* CHECK dout1_0 Vdout1_0ck200 = 0 time = 4020
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=4020.1n

* CHECK dout1_1 Vdout1_1ck200 = 1.8 time = 4020
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=4020.1n

* CHECK dout1_2 Vdout1_2ck200 = 1.8 time = 4020
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=4020.1n

* CHECK dout1_3 Vdout1_3ck200 = 1.8 time = 4020
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=4020.1n

* CHECK dout1_4 Vdout1_4ck200 = 1.8 time = 4020
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=4020.1n

* CHECK dout1_5 Vdout1_5ck200 = 1.8 time = 4020
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=4020.1n

* CHECK dout1_6 Vdout1_6ck200 = 0 time = 4020
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=4020.1n

* CHECK dout1_7 Vdout1_7ck200 = 1.8 time = 4020
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=4020.1n

* CHECK dout1_8 Vdout1_8ck200 = 1.8 time = 4020
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=4020.1n

* CHECK dout1_9 Vdout1_9ck200 = 0 time = 4020
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=4020.1n

* CHECK dout1_10 Vdout1_10ck200 = 1.8 time = 4020
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=4020.1n

* CHECK dout1_11 Vdout1_11ck200 = 0 time = 4020
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=4020.1n

* CHECK dout1_12 Vdout1_12ck200 = 0 time = 4020
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=4020.1n

* CHECK dout1_13 Vdout1_13ck200 = 1.8 time = 4020
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=4020.1n

* CHECK dout1_14 Vdout1_14ck200 = 1.8 time = 4020
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=4020.1n

* CHECK dout1_15 Vdout1_15ck200 = 1.8 time = 4020
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=4020.1n

* CHECK dout1_16 Vdout1_16ck200 = 1.8 time = 4020
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=4020.1n

* CHECK dout1_17 Vdout1_17ck200 = 0 time = 4020
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=4020.1n

* CHECK dout1_18 Vdout1_18ck200 = 0 time = 4020
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=4020.1n

* CHECK dout1_19 Vdout1_19ck200 = 0 time = 4020
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=4020.1n

* CHECK dout1_20 Vdout1_20ck200 = 0 time = 4020
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=4020.1n

* CHECK dout1_21 Vdout1_21ck200 = 0 time = 4020
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=4020.1n

* CHECK dout1_22 Vdout1_22ck200 = 0 time = 4020
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=4020.1n

* CHECK dout1_23 Vdout1_23ck200 = 1.8 time = 4020
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=4020.1n

* CHECK dout1_24 Vdout1_24ck200 = 0 time = 4020
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=4020.1n

* CHECK dout1_25 Vdout1_25ck200 = 1.8 time = 4020
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=4020.1n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 4020
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=4020.1n

* CHECK dout1_27 Vdout1_27ck200 = 0 time = 4020
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=4020.1n

* CHECK dout1_28 Vdout1_28ck200 = 0 time = 4020
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=4020.1n

* CHECK dout1_29 Vdout1_29ck200 = 1.8 time = 4020
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=4020.1n

* CHECK dout1_30 Vdout1_30ck200 = 0 time = 4020
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=4020.1n

* CHECK dout1_31 Vdout1_31ck200 = 0 time = 4020
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=4020.1n

* CHECK dout2_0 Vdout2_0ck200 = 0 time = 4020
.meas tran vdout2_0ck200 FIND v(dout2_0) AT=4020.1n

* CHECK dout2_1 Vdout2_1ck200 = 1.8 time = 4020
.meas tran vdout2_1ck200 FIND v(dout2_1) AT=4020.1n

* CHECK dout2_2 Vdout2_2ck200 = 0 time = 4020
.meas tran vdout2_2ck200 FIND v(dout2_2) AT=4020.1n

* CHECK dout2_3 Vdout2_3ck200 = 1.8 time = 4020
.meas tran vdout2_3ck200 FIND v(dout2_3) AT=4020.1n

* CHECK dout2_4 Vdout2_4ck200 = 0 time = 4020
.meas tran vdout2_4ck200 FIND v(dout2_4) AT=4020.1n

* CHECK dout2_5 Vdout2_5ck200 = 1.8 time = 4020
.meas tran vdout2_5ck200 FIND v(dout2_5) AT=4020.1n

* CHECK dout2_6 Vdout2_6ck200 = 0 time = 4020
.meas tran vdout2_6ck200 FIND v(dout2_6) AT=4020.1n

* CHECK dout2_7 Vdout2_7ck200 = 1.8 time = 4020
.meas tran vdout2_7ck200 FIND v(dout2_7) AT=4020.1n

* CHECK dout2_8 Vdout2_8ck200 = 1.8 time = 4020
.meas tran vdout2_8ck200 FIND v(dout2_8) AT=4020.1n

* CHECK dout2_9 Vdout2_9ck200 = 0 time = 4020
.meas tran vdout2_9ck200 FIND v(dout2_9) AT=4020.1n

* CHECK dout2_10 Vdout2_10ck200 = 0 time = 4020
.meas tran vdout2_10ck200 FIND v(dout2_10) AT=4020.1n

* CHECK dout2_11 Vdout2_11ck200 = 0 time = 4020
.meas tran vdout2_11ck200 FIND v(dout2_11) AT=4020.1n

* CHECK dout2_12 Vdout2_12ck200 = 0 time = 4020
.meas tran vdout2_12ck200 FIND v(dout2_12) AT=4020.1n

* CHECK dout2_13 Vdout2_13ck200 = 1.8 time = 4020
.meas tran vdout2_13ck200 FIND v(dout2_13) AT=4020.1n

* CHECK dout2_14 Vdout2_14ck200 = 1.8 time = 4020
.meas tran vdout2_14ck200 FIND v(dout2_14) AT=4020.1n

* CHECK dout2_15 Vdout2_15ck200 = 0 time = 4020
.meas tran vdout2_15ck200 FIND v(dout2_15) AT=4020.1n

* CHECK dout2_16 Vdout2_16ck200 = 1.8 time = 4020
.meas tran vdout2_16ck200 FIND v(dout2_16) AT=4020.1n

* CHECK dout2_17 Vdout2_17ck200 = 1.8 time = 4020
.meas tran vdout2_17ck200 FIND v(dout2_17) AT=4020.1n

* CHECK dout2_18 Vdout2_18ck200 = 1.8 time = 4020
.meas tran vdout2_18ck200 FIND v(dout2_18) AT=4020.1n

* CHECK dout2_19 Vdout2_19ck200 = 1.8 time = 4020
.meas tran vdout2_19ck200 FIND v(dout2_19) AT=4020.1n

* CHECK dout2_20 Vdout2_20ck200 = 1.8 time = 4020
.meas tran vdout2_20ck200 FIND v(dout2_20) AT=4020.1n

* CHECK dout2_21 Vdout2_21ck200 = 1.8 time = 4020
.meas tran vdout2_21ck200 FIND v(dout2_21) AT=4020.1n

* CHECK dout2_22 Vdout2_22ck200 = 0 time = 4020
.meas tran vdout2_22ck200 FIND v(dout2_22) AT=4020.1n

* CHECK dout2_23 Vdout2_23ck200 = 0 time = 4020
.meas tran vdout2_23ck200 FIND v(dout2_23) AT=4020.1n

* CHECK dout2_24 Vdout2_24ck200 = 1.8 time = 4020
.meas tran vdout2_24ck200 FIND v(dout2_24) AT=4020.1n

* CHECK dout2_25 Vdout2_25ck200 = 1.8 time = 4020
.meas tran vdout2_25ck200 FIND v(dout2_25) AT=4020.1n

* CHECK dout2_26 Vdout2_26ck200 = 1.8 time = 4020
.meas tran vdout2_26ck200 FIND v(dout2_26) AT=4020.1n

* CHECK dout2_27 Vdout2_27ck200 = 1.8 time = 4020
.meas tran vdout2_27ck200 FIND v(dout2_27) AT=4020.1n

* CHECK dout2_28 Vdout2_28ck200 = 1.8 time = 4020
.meas tran vdout2_28ck200 FIND v(dout2_28) AT=4020.1n

* CHECK dout2_29 Vdout2_29ck200 = 1.8 time = 4020
.meas tran vdout2_29ck200 FIND v(dout2_29) AT=4020.1n

* CHECK dout2_30 Vdout2_30ck200 = 1.8 time = 4020
.meas tran vdout2_30ck200 FIND v(dout2_30) AT=4020.1n

* CHECK dout2_31 Vdout2_31ck200 = 1.8 time = 4020
.meas tran vdout2_31ck200 FIND v(dout2_31) AT=4020.1n

* CHECK dout1_0 Vdout1_0ck201 = 0 time = 4040
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=4040.1n

* CHECK dout1_1 Vdout1_1ck201 = 1.8 time = 4040
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=4040.1n

* CHECK dout1_2 Vdout1_2ck201 = 0 time = 4040
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=4040.1n

* CHECK dout1_3 Vdout1_3ck201 = 1.8 time = 4040
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=4040.1n

* CHECK dout1_4 Vdout1_4ck201 = 0 time = 4040
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=4040.1n

* CHECK dout1_5 Vdout1_5ck201 = 1.8 time = 4040
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=4040.1n

* CHECK dout1_6 Vdout1_6ck201 = 0 time = 4040
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=4040.1n

* CHECK dout1_7 Vdout1_7ck201 = 1.8 time = 4040
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=4040.1n

* CHECK dout1_8 Vdout1_8ck201 = 1.8 time = 4040
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=4040.1n

* CHECK dout1_9 Vdout1_9ck201 = 0 time = 4040
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=4040.1n

* CHECK dout1_10 Vdout1_10ck201 = 0 time = 4040
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=4040.1n

* CHECK dout1_11 Vdout1_11ck201 = 0 time = 4040
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=4040.1n

* CHECK dout1_12 Vdout1_12ck201 = 0 time = 4040
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=4040.1n

* CHECK dout1_13 Vdout1_13ck201 = 1.8 time = 4040
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=4040.1n

* CHECK dout1_14 Vdout1_14ck201 = 1.8 time = 4040
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=4040.1n

* CHECK dout1_15 Vdout1_15ck201 = 0 time = 4040
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=4040.1n

* CHECK dout1_16 Vdout1_16ck201 = 1.8 time = 4040
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=4040.1n

* CHECK dout1_17 Vdout1_17ck201 = 1.8 time = 4040
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=4040.1n

* CHECK dout1_18 Vdout1_18ck201 = 1.8 time = 4040
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=4040.1n

* CHECK dout1_19 Vdout1_19ck201 = 1.8 time = 4040
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=4040.1n

* CHECK dout1_20 Vdout1_20ck201 = 1.8 time = 4040
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=4040.1n

* CHECK dout1_21 Vdout1_21ck201 = 1.8 time = 4040
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=4040.1n

* CHECK dout1_22 Vdout1_22ck201 = 0 time = 4040
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=4040.1n

* CHECK dout1_23 Vdout1_23ck201 = 0 time = 4040
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=4040.1n

* CHECK dout1_24 Vdout1_24ck201 = 1.8 time = 4040
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=4040.1n

* CHECK dout1_25 Vdout1_25ck201 = 1.8 time = 4040
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=4040.1n

* CHECK dout1_26 Vdout1_26ck201 = 1.8 time = 4040
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=4040.1n

* CHECK dout1_27 Vdout1_27ck201 = 1.8 time = 4040
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=4040.1n

* CHECK dout1_28 Vdout1_28ck201 = 1.8 time = 4040
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=4040.1n

* CHECK dout1_29 Vdout1_29ck201 = 1.8 time = 4040
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=4040.1n

* CHECK dout1_30 Vdout1_30ck201 = 1.8 time = 4040
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=4040.1n

* CHECK dout1_31 Vdout1_31ck201 = 1.8 time = 4040
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=4040.1n

* CHECK dout1_0 Vdout1_0ck202 = 0 time = 4060
.meas tran vdout1_0ck202 FIND v(dout1_0) AT=4060.1n

* CHECK dout1_1 Vdout1_1ck202 = 0 time = 4060
.meas tran vdout1_1ck202 FIND v(dout1_1) AT=4060.1n

* CHECK dout1_2 Vdout1_2ck202 = 0 time = 4060
.meas tran vdout1_2ck202 FIND v(dout1_2) AT=4060.1n

* CHECK dout1_3 Vdout1_3ck202 = 0 time = 4060
.meas tran vdout1_3ck202 FIND v(dout1_3) AT=4060.1n

* CHECK dout1_4 Vdout1_4ck202 = 0 time = 4060
.meas tran vdout1_4ck202 FIND v(dout1_4) AT=4060.1n

* CHECK dout1_5 Vdout1_5ck202 = 1.8 time = 4060
.meas tran vdout1_5ck202 FIND v(dout1_5) AT=4060.1n

* CHECK dout1_6 Vdout1_6ck202 = 1.8 time = 4060
.meas tran vdout1_6ck202 FIND v(dout1_6) AT=4060.1n

* CHECK dout1_7 Vdout1_7ck202 = 1.8 time = 4060
.meas tran vdout1_7ck202 FIND v(dout1_7) AT=4060.1n

* CHECK dout1_8 Vdout1_8ck202 = 0 time = 4060
.meas tran vdout1_8ck202 FIND v(dout1_8) AT=4060.1n

* CHECK dout1_9 Vdout1_9ck202 = 1.8 time = 4060
.meas tran vdout1_9ck202 FIND v(dout1_9) AT=4060.1n

* CHECK dout1_10 Vdout1_10ck202 = 0 time = 4060
.meas tran vdout1_10ck202 FIND v(dout1_10) AT=4060.1n

* CHECK dout1_11 Vdout1_11ck202 = 1.8 time = 4060
.meas tran vdout1_11ck202 FIND v(dout1_11) AT=4060.1n

* CHECK dout1_12 Vdout1_12ck202 = 0 time = 4060
.meas tran vdout1_12ck202 FIND v(dout1_12) AT=4060.1n

* CHECK dout1_13 Vdout1_13ck202 = 0 time = 4060
.meas tran vdout1_13ck202 FIND v(dout1_13) AT=4060.1n

* CHECK dout1_14 Vdout1_14ck202 = 1.8 time = 4060
.meas tran vdout1_14ck202 FIND v(dout1_14) AT=4060.1n

* CHECK dout1_15 Vdout1_15ck202 = 0 time = 4060
.meas tran vdout1_15ck202 FIND v(dout1_15) AT=4060.1n

* CHECK dout1_16 Vdout1_16ck202 = 0 time = 4060
.meas tran vdout1_16ck202 FIND v(dout1_16) AT=4060.1n

* CHECK dout1_17 Vdout1_17ck202 = 1.8 time = 4060
.meas tran vdout1_17ck202 FIND v(dout1_17) AT=4060.1n

* CHECK dout1_18 Vdout1_18ck202 = 0 time = 4060
.meas tran vdout1_18ck202 FIND v(dout1_18) AT=4060.1n

* CHECK dout1_19 Vdout1_19ck202 = 1.8 time = 4060
.meas tran vdout1_19ck202 FIND v(dout1_19) AT=4060.1n

* CHECK dout1_20 Vdout1_20ck202 = 0 time = 4060
.meas tran vdout1_20ck202 FIND v(dout1_20) AT=4060.1n

* CHECK dout1_21 Vdout1_21ck202 = 0 time = 4060
.meas tran vdout1_21ck202 FIND v(dout1_21) AT=4060.1n

* CHECK dout1_22 Vdout1_22ck202 = 1.8 time = 4060
.meas tran vdout1_22ck202 FIND v(dout1_22) AT=4060.1n

* CHECK dout1_23 Vdout1_23ck202 = 1.8 time = 4060
.meas tran vdout1_23ck202 FIND v(dout1_23) AT=4060.1n

* CHECK dout1_24 Vdout1_24ck202 = 1.8 time = 4060
.meas tran vdout1_24ck202 FIND v(dout1_24) AT=4060.1n

* CHECK dout1_25 Vdout1_25ck202 = 1.8 time = 4060
.meas tran vdout1_25ck202 FIND v(dout1_25) AT=4060.1n

* CHECK dout1_26 Vdout1_26ck202 = 0 time = 4060
.meas tran vdout1_26ck202 FIND v(dout1_26) AT=4060.1n

* CHECK dout1_27 Vdout1_27ck202 = 1.8 time = 4060
.meas tran vdout1_27ck202 FIND v(dout1_27) AT=4060.1n

* CHECK dout1_28 Vdout1_28ck202 = 0 time = 4060
.meas tran vdout1_28ck202 FIND v(dout1_28) AT=4060.1n

* CHECK dout1_29 Vdout1_29ck202 = 0 time = 4060
.meas tran vdout1_29ck202 FIND v(dout1_29) AT=4060.1n

* CHECK dout1_30 Vdout1_30ck202 = 1.8 time = 4060
.meas tran vdout1_30ck202 FIND v(dout1_30) AT=4060.1n

* CHECK dout1_31 Vdout1_31ck202 = 0 time = 4060
.meas tran vdout1_31ck202 FIND v(dout1_31) AT=4060.1n

* CHECK dout1_0 Vdout1_0ck203 = 0 time = 4080
.meas tran vdout1_0ck203 FIND v(dout1_0) AT=4080.1n

* CHECK dout1_1 Vdout1_1ck203 = 1.8 time = 4080
.meas tran vdout1_1ck203 FIND v(dout1_1) AT=4080.1n

* CHECK dout1_2 Vdout1_2ck203 = 0 time = 4080
.meas tran vdout1_2ck203 FIND v(dout1_2) AT=4080.1n

* CHECK dout1_3 Vdout1_3ck203 = 1.8 time = 4080
.meas tran vdout1_3ck203 FIND v(dout1_3) AT=4080.1n

* CHECK dout1_4 Vdout1_4ck203 = 0 time = 4080
.meas tran vdout1_4ck203 FIND v(dout1_4) AT=4080.1n

* CHECK dout1_5 Vdout1_5ck203 = 1.8 time = 4080
.meas tran vdout1_5ck203 FIND v(dout1_5) AT=4080.1n

* CHECK dout1_6 Vdout1_6ck203 = 0 time = 4080
.meas tran vdout1_6ck203 FIND v(dout1_6) AT=4080.1n

* CHECK dout1_7 Vdout1_7ck203 = 1.8 time = 4080
.meas tran vdout1_7ck203 FIND v(dout1_7) AT=4080.1n

* CHECK dout1_8 Vdout1_8ck203 = 1.8 time = 4080
.meas tran vdout1_8ck203 FIND v(dout1_8) AT=4080.1n

* CHECK dout1_9 Vdout1_9ck203 = 0 time = 4080
.meas tran vdout1_9ck203 FIND v(dout1_9) AT=4080.1n

* CHECK dout1_10 Vdout1_10ck203 = 0 time = 4080
.meas tran vdout1_10ck203 FIND v(dout1_10) AT=4080.1n

* CHECK dout1_11 Vdout1_11ck203 = 0 time = 4080
.meas tran vdout1_11ck203 FIND v(dout1_11) AT=4080.1n

* CHECK dout1_12 Vdout1_12ck203 = 0 time = 4080
.meas tran vdout1_12ck203 FIND v(dout1_12) AT=4080.1n

* CHECK dout1_13 Vdout1_13ck203 = 1.8 time = 4080
.meas tran vdout1_13ck203 FIND v(dout1_13) AT=4080.1n

* CHECK dout1_14 Vdout1_14ck203 = 1.8 time = 4080
.meas tran vdout1_14ck203 FIND v(dout1_14) AT=4080.1n

* CHECK dout1_15 Vdout1_15ck203 = 0 time = 4080
.meas tran vdout1_15ck203 FIND v(dout1_15) AT=4080.1n

* CHECK dout1_16 Vdout1_16ck203 = 1.8 time = 4080
.meas tran vdout1_16ck203 FIND v(dout1_16) AT=4080.1n

* CHECK dout1_17 Vdout1_17ck203 = 1.8 time = 4080
.meas tran vdout1_17ck203 FIND v(dout1_17) AT=4080.1n

* CHECK dout1_18 Vdout1_18ck203 = 1.8 time = 4080
.meas tran vdout1_18ck203 FIND v(dout1_18) AT=4080.1n

* CHECK dout1_19 Vdout1_19ck203 = 1.8 time = 4080
.meas tran vdout1_19ck203 FIND v(dout1_19) AT=4080.1n

* CHECK dout1_20 Vdout1_20ck203 = 1.8 time = 4080
.meas tran vdout1_20ck203 FIND v(dout1_20) AT=4080.1n

* CHECK dout1_21 Vdout1_21ck203 = 1.8 time = 4080
.meas tran vdout1_21ck203 FIND v(dout1_21) AT=4080.1n

* CHECK dout1_22 Vdout1_22ck203 = 0 time = 4080
.meas tran vdout1_22ck203 FIND v(dout1_22) AT=4080.1n

* CHECK dout1_23 Vdout1_23ck203 = 0 time = 4080
.meas tran vdout1_23ck203 FIND v(dout1_23) AT=4080.1n

* CHECK dout1_24 Vdout1_24ck203 = 1.8 time = 4080
.meas tran vdout1_24ck203 FIND v(dout1_24) AT=4080.1n

* CHECK dout1_25 Vdout1_25ck203 = 1.8 time = 4080
.meas tran vdout1_25ck203 FIND v(dout1_25) AT=4080.1n

* CHECK dout1_26 Vdout1_26ck203 = 1.8 time = 4080
.meas tran vdout1_26ck203 FIND v(dout1_26) AT=4080.1n

* CHECK dout1_27 Vdout1_27ck203 = 1.8 time = 4080
.meas tran vdout1_27ck203 FIND v(dout1_27) AT=4080.1n

* CHECK dout1_28 Vdout1_28ck203 = 1.8 time = 4080
.meas tran vdout1_28ck203 FIND v(dout1_28) AT=4080.1n

* CHECK dout1_29 Vdout1_29ck203 = 1.8 time = 4080
.meas tran vdout1_29ck203 FIND v(dout1_29) AT=4080.1n

* CHECK dout1_30 Vdout1_30ck203 = 1.8 time = 4080
.meas tran vdout1_30ck203 FIND v(dout1_30) AT=4080.1n

* CHECK dout1_31 Vdout1_31ck203 = 1.8 time = 4080
.meas tran vdout1_31ck203 FIND v(dout1_31) AT=4080.1n

* CHECK dout2_0 Vdout2_0ck203 = 1.8 time = 4080
.meas tran vdout2_0ck203 FIND v(dout2_0) AT=4080.1n

* CHECK dout2_1 Vdout2_1ck203 = 0 time = 4080
.meas tran vdout2_1ck203 FIND v(dout2_1) AT=4080.1n

* CHECK dout2_2 Vdout2_2ck203 = 1.8 time = 4080
.meas tran vdout2_2ck203 FIND v(dout2_2) AT=4080.1n

* CHECK dout2_3 Vdout2_3ck203 = 0 time = 4080
.meas tran vdout2_3ck203 FIND v(dout2_3) AT=4080.1n

* CHECK dout2_4 Vdout2_4ck203 = 1.8 time = 4080
.meas tran vdout2_4ck203 FIND v(dout2_4) AT=4080.1n

* CHECK dout2_5 Vdout2_5ck203 = 0 time = 4080
.meas tran vdout2_5ck203 FIND v(dout2_5) AT=4080.1n

* CHECK dout2_6 Vdout2_6ck203 = 0 time = 4080
.meas tran vdout2_6ck203 FIND v(dout2_6) AT=4080.1n

* CHECK dout2_7 Vdout2_7ck203 = 1.8 time = 4080
.meas tran vdout2_7ck203 FIND v(dout2_7) AT=4080.1n

* CHECK dout2_8 Vdout2_8ck203 = 0 time = 4080
.meas tran vdout2_8ck203 FIND v(dout2_8) AT=4080.1n

* CHECK dout2_9 Vdout2_9ck203 = 1.8 time = 4080
.meas tran vdout2_9ck203 FIND v(dout2_9) AT=4080.1n

* CHECK dout2_10 Vdout2_10ck203 = 0 time = 4080
.meas tran vdout2_10ck203 FIND v(dout2_10) AT=4080.1n

* CHECK dout2_11 Vdout2_11ck203 = 1.8 time = 4080
.meas tran vdout2_11ck203 FIND v(dout2_11) AT=4080.1n

* CHECK dout2_12 Vdout2_12ck203 = 1.8 time = 4080
.meas tran vdout2_12ck203 FIND v(dout2_12) AT=4080.1n

* CHECK dout2_13 Vdout2_13ck203 = 1.8 time = 4080
.meas tran vdout2_13ck203 FIND v(dout2_13) AT=4080.1n

* CHECK dout2_14 Vdout2_14ck203 = 1.8 time = 4080
.meas tran vdout2_14ck203 FIND v(dout2_14) AT=4080.1n

* CHECK dout2_15 Vdout2_15ck203 = 1.8 time = 4080
.meas tran vdout2_15ck203 FIND v(dout2_15) AT=4080.1n

* CHECK dout2_16 Vdout2_16ck203 = 1.8 time = 4080
.meas tran vdout2_16ck203 FIND v(dout2_16) AT=4080.1n

* CHECK dout2_17 Vdout2_17ck203 = 1.8 time = 4080
.meas tran vdout2_17ck203 FIND v(dout2_17) AT=4080.1n

* CHECK dout2_18 Vdout2_18ck203 = 1.8 time = 4080
.meas tran vdout2_18ck203 FIND v(dout2_18) AT=4080.1n

* CHECK dout2_19 Vdout2_19ck203 = 0 time = 4080
.meas tran vdout2_19ck203 FIND v(dout2_19) AT=4080.1n

* CHECK dout2_20 Vdout2_20ck203 = 1.8 time = 4080
.meas tran vdout2_20ck203 FIND v(dout2_20) AT=4080.1n

* CHECK dout2_21 Vdout2_21ck203 = 1.8 time = 4080
.meas tran vdout2_21ck203 FIND v(dout2_21) AT=4080.1n

* CHECK dout2_22 Vdout2_22ck203 = 0 time = 4080
.meas tran vdout2_22ck203 FIND v(dout2_22) AT=4080.1n

* CHECK dout2_23 Vdout2_23ck203 = 0 time = 4080
.meas tran vdout2_23ck203 FIND v(dout2_23) AT=4080.1n

* CHECK dout2_24 Vdout2_24ck203 = 0 time = 4080
.meas tran vdout2_24ck203 FIND v(dout2_24) AT=4080.1n

* CHECK dout2_25 Vdout2_25ck203 = 1.8 time = 4080
.meas tran vdout2_25ck203 FIND v(dout2_25) AT=4080.1n

* CHECK dout2_26 Vdout2_26ck203 = 1.8 time = 4080
.meas tran vdout2_26ck203 FIND v(dout2_26) AT=4080.1n

* CHECK dout2_27 Vdout2_27ck203 = 1.8 time = 4080
.meas tran vdout2_27ck203 FIND v(dout2_27) AT=4080.1n

* CHECK dout2_28 Vdout2_28ck203 = 1.8 time = 4080
.meas tran vdout2_28ck203 FIND v(dout2_28) AT=4080.1n

* CHECK dout2_29 Vdout2_29ck203 = 0 time = 4080
.meas tran vdout2_29ck203 FIND v(dout2_29) AT=4080.1n

* CHECK dout2_30 Vdout2_30ck203 = 1.8 time = 4080
.meas tran vdout2_30ck203 FIND v(dout2_30) AT=4080.1n

* CHECK dout2_31 Vdout2_31ck203 = 1.8 time = 4080
.meas tran vdout2_31ck203 FIND v(dout2_31) AT=4080.1n

* CHECK dout1_0 Vdout1_0ck204 = 1.8 time = 4100
.meas tran vdout1_0ck204 FIND v(dout1_0) AT=4100.1n

* CHECK dout1_1 Vdout1_1ck204 = 0 time = 4100
.meas tran vdout1_1ck204 FIND v(dout1_1) AT=4100.1n

* CHECK dout1_2 Vdout1_2ck204 = 1.8 time = 4100
.meas tran vdout1_2ck204 FIND v(dout1_2) AT=4100.1n

* CHECK dout1_3 Vdout1_3ck204 = 0 time = 4100
.meas tran vdout1_3ck204 FIND v(dout1_3) AT=4100.1n

* CHECK dout1_4 Vdout1_4ck204 = 1.8 time = 4100
.meas tran vdout1_4ck204 FIND v(dout1_4) AT=4100.1n

* CHECK dout1_5 Vdout1_5ck204 = 0 time = 4100
.meas tran vdout1_5ck204 FIND v(dout1_5) AT=4100.1n

* CHECK dout1_6 Vdout1_6ck204 = 0 time = 4100
.meas tran vdout1_6ck204 FIND v(dout1_6) AT=4100.1n

* CHECK dout1_7 Vdout1_7ck204 = 1.8 time = 4100
.meas tran vdout1_7ck204 FIND v(dout1_7) AT=4100.1n

* CHECK dout1_8 Vdout1_8ck204 = 0 time = 4100
.meas tran vdout1_8ck204 FIND v(dout1_8) AT=4100.1n

* CHECK dout1_9 Vdout1_9ck204 = 1.8 time = 4100
.meas tran vdout1_9ck204 FIND v(dout1_9) AT=4100.1n

* CHECK dout1_10 Vdout1_10ck204 = 0 time = 4100
.meas tran vdout1_10ck204 FIND v(dout1_10) AT=4100.1n

* CHECK dout1_11 Vdout1_11ck204 = 1.8 time = 4100
.meas tran vdout1_11ck204 FIND v(dout1_11) AT=4100.1n

* CHECK dout1_12 Vdout1_12ck204 = 1.8 time = 4100
.meas tran vdout1_12ck204 FIND v(dout1_12) AT=4100.1n

* CHECK dout1_13 Vdout1_13ck204 = 1.8 time = 4100
.meas tran vdout1_13ck204 FIND v(dout1_13) AT=4100.1n

* CHECK dout1_14 Vdout1_14ck204 = 1.8 time = 4100
.meas tran vdout1_14ck204 FIND v(dout1_14) AT=4100.1n

* CHECK dout1_15 Vdout1_15ck204 = 1.8 time = 4100
.meas tran vdout1_15ck204 FIND v(dout1_15) AT=4100.1n

* CHECK dout1_16 Vdout1_16ck204 = 1.8 time = 4100
.meas tran vdout1_16ck204 FIND v(dout1_16) AT=4100.1n

* CHECK dout1_17 Vdout1_17ck204 = 1.8 time = 4100
.meas tran vdout1_17ck204 FIND v(dout1_17) AT=4100.1n

* CHECK dout1_18 Vdout1_18ck204 = 1.8 time = 4100
.meas tran vdout1_18ck204 FIND v(dout1_18) AT=4100.1n

* CHECK dout1_19 Vdout1_19ck204 = 0 time = 4100
.meas tran vdout1_19ck204 FIND v(dout1_19) AT=4100.1n

* CHECK dout1_20 Vdout1_20ck204 = 1.8 time = 4100
.meas tran vdout1_20ck204 FIND v(dout1_20) AT=4100.1n

* CHECK dout1_21 Vdout1_21ck204 = 1.8 time = 4100
.meas tran vdout1_21ck204 FIND v(dout1_21) AT=4100.1n

* CHECK dout1_22 Vdout1_22ck204 = 0 time = 4100
.meas tran vdout1_22ck204 FIND v(dout1_22) AT=4100.1n

* CHECK dout1_23 Vdout1_23ck204 = 0 time = 4100
.meas tran vdout1_23ck204 FIND v(dout1_23) AT=4100.1n

* CHECK dout1_24 Vdout1_24ck204 = 0 time = 4100
.meas tran vdout1_24ck204 FIND v(dout1_24) AT=4100.1n

* CHECK dout1_25 Vdout1_25ck204 = 1.8 time = 4100
.meas tran vdout1_25ck204 FIND v(dout1_25) AT=4100.1n

* CHECK dout1_26 Vdout1_26ck204 = 1.8 time = 4100
.meas tran vdout1_26ck204 FIND v(dout1_26) AT=4100.1n

* CHECK dout1_27 Vdout1_27ck204 = 1.8 time = 4100
.meas tran vdout1_27ck204 FIND v(dout1_27) AT=4100.1n

* CHECK dout1_28 Vdout1_28ck204 = 1.8 time = 4100
.meas tran vdout1_28ck204 FIND v(dout1_28) AT=4100.1n

* CHECK dout1_29 Vdout1_29ck204 = 0 time = 4100
.meas tran vdout1_29ck204 FIND v(dout1_29) AT=4100.1n

* CHECK dout1_30 Vdout1_30ck204 = 1.8 time = 4100
.meas tran vdout1_30ck204 FIND v(dout1_30) AT=4100.1n

* CHECK dout1_31 Vdout1_31ck204 = 1.8 time = 4100
.meas tran vdout1_31ck204 FIND v(dout1_31) AT=4100.1n

* CHECK dout2_0 Vdout2_0ck204 = 1.8 time = 4100
.meas tran vdout2_0ck204 FIND v(dout2_0) AT=4100.1n

* CHECK dout2_1 Vdout2_1ck204 = 0 time = 4100
.meas tran vdout2_1ck204 FIND v(dout2_1) AT=4100.1n

* CHECK dout2_2 Vdout2_2ck204 = 1.8 time = 4100
.meas tran vdout2_2ck204 FIND v(dout2_2) AT=4100.1n

* CHECK dout2_3 Vdout2_3ck204 = 0 time = 4100
.meas tran vdout2_3ck204 FIND v(dout2_3) AT=4100.1n

* CHECK dout2_4 Vdout2_4ck204 = 1.8 time = 4100
.meas tran vdout2_4ck204 FIND v(dout2_4) AT=4100.1n

* CHECK dout2_5 Vdout2_5ck204 = 0 time = 4100
.meas tran vdout2_5ck204 FIND v(dout2_5) AT=4100.1n

* CHECK dout2_6 Vdout2_6ck204 = 0 time = 4100
.meas tran vdout2_6ck204 FIND v(dout2_6) AT=4100.1n

* CHECK dout2_7 Vdout2_7ck204 = 1.8 time = 4100
.meas tran vdout2_7ck204 FIND v(dout2_7) AT=4100.1n

* CHECK dout2_8 Vdout2_8ck204 = 0 time = 4100
.meas tran vdout2_8ck204 FIND v(dout2_8) AT=4100.1n

* CHECK dout2_9 Vdout2_9ck204 = 1.8 time = 4100
.meas tran vdout2_9ck204 FIND v(dout2_9) AT=4100.1n

* CHECK dout2_10 Vdout2_10ck204 = 0 time = 4100
.meas tran vdout2_10ck204 FIND v(dout2_10) AT=4100.1n

* CHECK dout2_11 Vdout2_11ck204 = 1.8 time = 4100
.meas tran vdout2_11ck204 FIND v(dout2_11) AT=4100.1n

* CHECK dout2_12 Vdout2_12ck204 = 1.8 time = 4100
.meas tran vdout2_12ck204 FIND v(dout2_12) AT=4100.1n

* CHECK dout2_13 Vdout2_13ck204 = 1.8 time = 4100
.meas tran vdout2_13ck204 FIND v(dout2_13) AT=4100.1n

* CHECK dout2_14 Vdout2_14ck204 = 1.8 time = 4100
.meas tran vdout2_14ck204 FIND v(dout2_14) AT=4100.1n

* CHECK dout2_15 Vdout2_15ck204 = 1.8 time = 4100
.meas tran vdout2_15ck204 FIND v(dout2_15) AT=4100.1n

* CHECK dout2_16 Vdout2_16ck204 = 1.8 time = 4100
.meas tran vdout2_16ck204 FIND v(dout2_16) AT=4100.1n

* CHECK dout2_17 Vdout2_17ck204 = 1.8 time = 4100
.meas tran vdout2_17ck204 FIND v(dout2_17) AT=4100.1n

* CHECK dout2_18 Vdout2_18ck204 = 1.8 time = 4100
.meas tran vdout2_18ck204 FIND v(dout2_18) AT=4100.1n

* CHECK dout2_19 Vdout2_19ck204 = 0 time = 4100
.meas tran vdout2_19ck204 FIND v(dout2_19) AT=4100.1n

* CHECK dout2_20 Vdout2_20ck204 = 1.8 time = 4100
.meas tran vdout2_20ck204 FIND v(dout2_20) AT=4100.1n

* CHECK dout2_21 Vdout2_21ck204 = 1.8 time = 4100
.meas tran vdout2_21ck204 FIND v(dout2_21) AT=4100.1n

* CHECK dout2_22 Vdout2_22ck204 = 0 time = 4100
.meas tran vdout2_22ck204 FIND v(dout2_22) AT=4100.1n

* CHECK dout2_23 Vdout2_23ck204 = 0 time = 4100
.meas tran vdout2_23ck204 FIND v(dout2_23) AT=4100.1n

* CHECK dout2_24 Vdout2_24ck204 = 0 time = 4100
.meas tran vdout2_24ck204 FIND v(dout2_24) AT=4100.1n

* CHECK dout2_25 Vdout2_25ck204 = 1.8 time = 4100
.meas tran vdout2_25ck204 FIND v(dout2_25) AT=4100.1n

* CHECK dout2_26 Vdout2_26ck204 = 1.8 time = 4100
.meas tran vdout2_26ck204 FIND v(dout2_26) AT=4100.1n

* CHECK dout2_27 Vdout2_27ck204 = 1.8 time = 4100
.meas tran vdout2_27ck204 FIND v(dout2_27) AT=4100.1n

* CHECK dout2_28 Vdout2_28ck204 = 1.8 time = 4100
.meas tran vdout2_28ck204 FIND v(dout2_28) AT=4100.1n

* CHECK dout2_29 Vdout2_29ck204 = 0 time = 4100
.meas tran vdout2_29ck204 FIND v(dout2_29) AT=4100.1n

* CHECK dout2_30 Vdout2_30ck204 = 1.8 time = 4100
.meas tran vdout2_30ck204 FIND v(dout2_30) AT=4100.1n

* CHECK dout2_31 Vdout2_31ck204 = 1.8 time = 4100
.meas tran vdout2_31ck204 FIND v(dout2_31) AT=4100.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
